#ifndef _JETBRAINSMONO_MEDIUMITALIC72PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF9,
  0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x8F, 0x3F, 0xF0, 0x03,
  0xFE, 0x3E, 0x1F, 0xF0, 0x0F, 0xF8, 0x7C, 0x3F, 0xE0, 0x1F, 0xE0, 0xF8,
  0x3F, 0xC0, 0x7F, 0x81, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x3E,
  0x00, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x00,
  0x3F, 0xE1, 0xE0, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x00, 0x00, 0xFF, 0xC7,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xF7, 0xFF, 0x80, 0x00, 0x01, 0xE3, 0xFF,
  0x00, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0x83, 0xFE, 0x00, 0x00,
  0x1F, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x0F,
  0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0x81, 0xFE, 0x0F, 0xF8, 0x1E, 0x03,
  0xFC, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0x3F,
  0xF0, 0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF1, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x9F, 0xE0, 0x0F, 0xF0, 0xFF, 0x87,
  0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF0, 0x0F, 0xFB, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80,
  0x07, 0xE0, 0x03, 0x8F, 0xC0, 0x1F, 0x80, 0x7E, 0x3F, 0xC0, 0x7C, 0x07,
  0xF9, 0xFF, 0xC1, 0xF0, 0x7F, 0xE7, 0xFF, 0x87, 0x87, 0xFF, 0xFF, 0xFF,
  0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0x73, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x03, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC3, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xE1,
  0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xF8, 0x00,
  0x7F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0xFF,
  0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x02, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x40, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0x1F, 0xFF, 0xC0,
  0x03, 0xF9, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE7, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF7, 0xFC, 0x00,
  0x3F, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xFC, 0x7E, 0x07, 0xE0,
  0x03, 0xFF, 0xE7, 0xE0, 0x7E, 0x00, 0x7F, 0xFE, 0x7E, 0x0F, 0xE0, 0x0F,
  0xFF, 0xF7, 0xC0, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x81,
  0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x07,
  0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00,
  0xFF, 0xFF, 0x7E, 0x07, 0xE0, 0x07, 0xFF, 0xE7, 0xE0, 0x7E, 0x00, 0x7F,
  0xFE, 0x7E, 0x07, 0xE0, 0x01, 0xFF, 0x8F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xA0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x00, 0x7F,
  0xF8, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0x00,
  0xFD, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xCF,
  0x80, 0x7E, 0xFC, 0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x0F,
  0xDF, 0xC0, 0x3F, 0x3E, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x07, 0xF3, 0xF0, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x3F, 0x3F, 0x80, 0x7F,
  0x1F, 0x0F, 0x8F, 0xE0, 0x1F, 0xC7, 0xC7, 0xE3, 0xF8, 0x07, 0xE1, 0xF1,
  0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xBE, 0x1F,
  0xC0, 0x3F, 0x87, 0xEF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x03,
  0xF8, 0x3F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xFC, 0x3F, 0x80, 0x3F, 0x83,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xE0,
  0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF,
  0xF0, 0x01, 0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xFC, 0x03, 0xFB, 0xF0, 0x03,
  0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x03, 0xF8, 0x07,
  0xF3, 0xF8, 0x03, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0x07, 0xF1, 0xF8,
  0x07, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0,
  0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x80, 0x1F, 0x9F,
  0xC0, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x3F,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE3, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7B, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0x78, 0x07, 0xE0, 0xFE, 0x03,
  0xEF, 0x00, 0xFC, 0x1F, 0xC0, 0x7D, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0x3C,
  0x07, 0xF0, 0x7F, 0x01, 0xEF, 0x80, 0xFC, 0x0F, 0xE0, 0x7D, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0x3E, 0x07, 0xF0, 0x3F, 0x01, 0xE7, 0xC0, 0xFE, 0x07,
  0xE0, 0x7C, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x9F, 0x07, 0xF0, 0x1F, 0x81,
  0xE3, 0xE0, 0xFE, 0x03, 0xF0, 0x3C, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0x8F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF1, 0xE0, 0xFE, 0x01, 0xF8, 0x3C, 0x3C, 0x1F,
  0xC0, 0x7F, 0x0F, 0x87, 0x83, 0xF0, 0x0F, 0xE1, 0xF0, 0xF0, 0x7E, 0x01,
  0xFC, 0x3C, 0x1E, 0x1F, 0xC0, 0x3F, 0x87, 0x83, 0xC3, 0xF8, 0x07, 0xF1,
  0xF0, 0x78, 0x7E, 0x00, 0xFE, 0x3E, 0x0F, 0x0F, 0xC0, 0x1F, 0xC7, 0x81,
  0xE3, 0xF8, 0x03, 0xF1, 0xF0, 0x3C, 0x7E, 0x00, 0x7E, 0x3E, 0x07, 0x8F,
  0xC0, 0x0F, 0xC7, 0xC0, 0xF1, 0xF8, 0x01, 0xF8, 0xF0, 0x3E, 0x7F, 0x00,
  0x3F, 0x3E, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x00, 0xFC,
  0xF0, 0x1F, 0x3F, 0x00, 0x1F, 0xBE, 0x03, 0xEF, 0xE0, 0x03, 0xF7, 0xC0,
  0x7D, 0xF8, 0x00, 0x7E, 0xF8, 0x0F, 0xBF, 0x00, 0x0F, 0xDE, 0x01, 0xF7,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xBF, 0x00,
  0x0F, 0xFE, 0x00, 0xF7, 0xE0, 0x01, 0xFB, 0xC0, 0x1E, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xDF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x01,
  0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xEF,
  0xEF, 0xE0, 0x7F, 0xE0, 0x0E, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0E, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xE0,
  0x1F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xE1,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0xF0, 0x03,
  0xF9, 0xFF, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0xC0, 0x7F,
  0x7F, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xE0,
  0x0F, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8,
  0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xF3, 0xFC, 0x00,
  0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xFE,
  0xFE, 0x00, 0xFF, 0xFB, 0xFB, 0xF8, 0x07, 0xFE, 0x00, 0xEF, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3B, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFD, 0xFE, 0x00,
  0x7F, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0xF8,
  0x7F, 0x00, 0x03, 0xFF, 0x83, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x01, 0xFF,
  0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0x01,
  0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xEF, 0xEF,
  0xE0, 0x7F, 0xE0, 0x0E, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFF,
  0xDF, 0xE0, 0x0F, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xE0, 0x01,
  0xFF, 0xC1, 0xFE, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xFE, 0x00,
  0x3F, 0xCF, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0x80, 0x3F, 0xBF, 0xFF,
  0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x03, 0xF9, 0xFF, 0x0F, 0xFC, 0x03, 0xFB, 0xFF, 0x9F,
  0xFE, 0x03, 0xF7, 0xFF, 0x9F, 0xFE, 0x03, 0xF7, 0xFF, 0xBF, 0xFE, 0x03,
  0xFF, 0x7F, 0xFB, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0x7F,
  0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x01, 0xFC, 0x1F, 0xC0, 0x3E, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xFC,
  0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xF8, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xC3, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xF8,
  0x07, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xF3, 0xFF, 0xFE, 0x00, 0x3F, 0x9F, 0xFF,
  0xF8, 0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFD, 0xFF, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xFF,
  0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x01,
  0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xEF,
  0xEF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0E, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xE0,
  0x3F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xE3,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0xF8, 0x00, 0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xFF, 0x80,
  0x3F, 0x9F, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0x80, 0x7E, 0x7E, 0x01, 0xEF,
  0x00, 0xFC, 0xFC, 0x03, 0xDE, 0x03, 0xF9, 0xF8, 0x0F, 0xBC, 0x07, 0xE3,
  0xF0, 0x1E, 0x78, 0x0F, 0xC7, 0xE0, 0x3C, 0xF0, 0x1F, 0x8F, 0xC0, 0xF9,
  0xE0, 0x7E, 0x1F, 0x81, 0xF3, 0xC0, 0xFC, 0x3F, 0x03, 0xC7, 0x81, 0xF8,
  0x7E, 0x07, 0x8F, 0x07, 0xE0, 0xFC, 0x1F, 0x1E, 0x0F, 0xC1, 0xF8, 0x3C,
  0x3C, 0x1F, 0x83, 0xF0, 0x78, 0x78, 0x7F, 0x07, 0xE1, 0xF0, 0xF0, 0xFC,
  0x0F, 0xC3, 0xC1, 0xE1, 0xF8, 0x1F, 0x87, 0x83, 0xC3, 0xF0, 0x3F, 0x1F,
  0x07, 0x8F, 0xC0, 0x7E, 0x3C, 0x0F, 0x1F, 0x80, 0xFC, 0x78, 0x1E, 0x3F,
  0x01, 0xF9, 0xF0, 0x3C, 0xFC, 0x03, 0xF3, 0xC0, 0x79, 0xF8, 0x07, 0xE7,
  0x80, 0xF3, 0xF0, 0x0F, 0xDF, 0x01, 0xEF, 0xC0, 0x1F, 0xBE, 0x03, 0xDF,
  0x80, 0x3F, 0x78, 0x07, 0xBF, 0x00, 0x7E, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xC3, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0xE0, 0x07, 0xF1, 0xFF, 0xFF,
  0x80, 0x3F, 0x1F, 0xFF, 0xFC, 0x03, 0xF9, 0xFE, 0x1F, 0xF0, 0x1F, 0xCF,
  0xE0, 0x7F, 0xC0, 0xFE, 0x7F, 0x01, 0xFE, 0x0F, 0xF3, 0xF8, 0x07, 0xFF,
  0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xE0,
  0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x10, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 18, 53, 43, 13, -53 },
  { 121, 25, 22, 43, 13, -53 },
  { 190, 43, 53, 43, 1, -53 },
  { 475, 39, 73, 43, 3, -63 },
  { 831, 51, 53, 43, -3, -53 },
  { 1169, 41, 54, 43, 1, -53 },
  { 1446, 11, 22, 43, 20, -53 },
  { 1477, 30, 70, 43, 11, -61 },
  { 1740, 30, 70, 43, 4, -61 },
  { 2003, 38, 38, 43, 4, -44 },
  { 2184, 35, 34, 43, 5, -41 },
  { 2333, 20, 23, 43, 6, -11 },
  { 2391, 25, 7, 43, 10, -27 },
  { 2413, 14, 13, 43, 12, -12 },
  { 2436, 45, 68, 43, 0, -60 },
  { 2819, 37, 54, 43, 4, -53 },
  { 3069, 34, 53, 43, 3, -53 },
  { 3295, 38, 53, 43, 3, -53 },
  { 3547, 38, 54, 43, 3, -53 },
  { 3804, 36, 53, 43, 4, -53 },
  { 4043, 37, 54, 43, 4, -53 },
  { 4293, 36, 54, 43, 3, -53 },
  { 4536, 36, 53, 43, 8, -53 },
  { 4775, 38, 54, 43, 3, -53 },
  { 5032, 36, 53, 43, 6, -53 },
  { 5271, 19, 41, 43, 12, -40 },
  { 5369, 24, 52, 43, 7, -40 },
  { 5525, 35, 39, 43, 6, -43 },
  { 5696, 35, 24, 43, 5, -36 },
  { 5801, 36, 39, 43, 3, -43 },
  { 5977, 30, 53, 43, 10, -53 },
  { 6176, 44, 66, 43, 0, -53 },
  { 6539, 37, 53, 43, 0, -53 },
  { 6785, 39, 53, 43, 3, -53 },
  { 7044, 38, 54, 43, 4, -53 },
  { 7301, 38, 53, 43, 3, -53 },
  { 7553, 39, 53, 43, 4, -53 },
  { 7812, 40, 53, 43, 3, -53 },
  { 8077, 38, 54, 43, 4, -53 },
  { 8334, 39, 53, 43, 3, -53 },
  { 8593, 37, 53, 43, 4, -53 },
  { 8839, 40, 54, 43, 1, -53 },
  { 9109, 42, 53, 43, 3, -53 },
  { 9388, 32, 53, 43, 5, -53 },
  { 9600, 42, 53, 43, 2, -53 },
  { 9879, 40, 53, 43, 3, -53 },
  { 10144, 37, 54, 43, 4, -53 },
  { 10394, 40, 53, 43, 3, -53 },
  { 10659, 37, 66, 43, 4, -53 },
  { 10965, 39, 53, 43, 3, -53 },
  { 11224, 39, 54, 43, 3, -53 },
  { 11488, 37, 53, 43, 8, -53 },
  { 11734, 39, 54, 43, 4, -53 },
  { 11998, 37, 53, 43, 8, -53 },
  { 12244, 43, 53, 43, 4, -53 },
  { 12529, 46, 53, 43, -1, -53 },
  { 12834, 39, 53, 43, 7, -53 },
  { 13093, 39, 53, 43, 3, -53 },
  { 13352, 29, 68, 43, 10, -60 },
  { 13599, 23, 68, 43, 11, -60 },
  { 13795, 29, 68, 43, 6, -60 },
  { 14042, 33, 29, 43, 6, -53 },
  { 14162, 35, 7, 43, 0, 2 },
  { 14193, 15, 11, 43, 18, -57 },
  { 14214, 36, 41, 43, 4, -40 },
  { 14399, 36, 54, 43, 3, -53 },
  { 14642, 36, 41, 43, 4, -40 },
  { 14827, 38, 54, 43, 4, -53 },
  { 15084, 35, 41, 43, 4, -40 },
  { 15264, 50, 66, 43, -4, -53 },
  { 15677, 36, 53, 43, 4, -40 },
  { 15916, 36, 53, 43, 3, -53 },
  { 16155, 36, 56, 43, 2, -56 },
  { 16407, 38, 69, 43, 1, -56 },
  { 16735, 40, 53, 43, 3, -53 },
  { 17000, 31, 53, 43, 7, -53 },
  { 17206, 40, 40, 43, 1, -40 },
  { 17406, 36, 40, 43, 3, -40 },
  { 17586, 35, 41, 43, 4, -40 },
  { 17766, 38, 53, 43, 1, -40 },
  { 18018, 36, 53, 43, 4, -40 },
  { 18257, 37, 40, 43, 4, -40 },
  { 18442, 36, 41, 43, 3, -40 },
  { 18627, 35, 50, 43, 6, -50 },
  { 18846, 36, 41, 43, 4, -40 },
  { 19031, 36, 40, 43, 7, -40 },
  { 19211, 39, 40, 43, 5, -40 },
  { 19406, 42, 40, 43, 0, -40 },
  { 19616, 36, 53, 43, 4, -40 },
  { 19855, 36, 40, 43, 3, -40 },
  { 20035, 38, 68, 43, 6, -60 },
  { 20358, 19, 68, 43, 13, -60 },
  { 20520, 37, 68, 43, 2, -60 },
  { 20835, 37, 16, 43, 4, -33 },
};

const GFXfont JetBrainsMono_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_MEDIUMITALIC72PT7B_H_
