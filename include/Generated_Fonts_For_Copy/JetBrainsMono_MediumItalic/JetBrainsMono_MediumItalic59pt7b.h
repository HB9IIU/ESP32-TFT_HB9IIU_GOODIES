#ifndef _JETBRAINSMONO_MEDIUMITALIC59PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8,
  0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F,
  0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x7B, 0xFE, 0x01, 0xFC, 0x78, 0xFE, 0x03, 0xF8, 0x78,
  0x7F, 0x03, 0xF0, 0x78, 0x7F, 0x03, 0xF0, 0x70, 0x7F, 0x07, 0xF0, 0x70,
  0x7F, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0xF0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x03, 0xFC, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xDF,
  0xF0, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x03, 0x83,
  0xF8, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x07, 0x83,
  0xF8, 0x7E, 0x07, 0x83, 0xF8, 0x7E, 0x07, 0x83, 0xF0, 0x7F, 0x07, 0x07,
  0xF0, 0x7F, 0x07, 0x07, 0xF0, 0x7F, 0x8F, 0x1F, 0xE0, 0x3F, 0xEF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x3F,
  0xFC, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x83, 0xE3, 0xE0, 0x00, 0x07, 0xFF,
  0xE3, 0xE0, 0x00, 0x03, 0xFF, 0xF3, 0xE0, 0x00, 0x00, 0xFF, 0xE3, 0xE0,
  0x00, 0x00, 0x3F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF,
  0x80, 0x00, 0x00, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0xF9, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x3F, 0x00, 0x00, 0xF8,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x3F,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x3E,
  0x00, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x7F, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x87, 0xE0, 0x7F, 0x3F, 0x83, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x0F,
  0xFF, 0x81, 0xFC, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xF0, 0x1F,
  0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x03, 0xE0, 0x04, 0x7C, 0x07,
  0xC0, 0x7D, 0xFE, 0x0F, 0x07, 0xFB, 0xFF, 0x1E, 0x3F, 0xFF, 0xFF, 0x38,
  0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xF8, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x3E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7E,
  0x0F, 0x87, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFE, 0x7E, 0x00, 0x7F, 0xC7, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0x80, 0xFE, 0x00, 0xF0, 0x0F, 0xC0, 0x0C,
  0x00, 0xFC, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE3,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x1F,
  0xBF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x38, 0x00,
  0x0F, 0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFF,
  0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xE7, 0xF0, 0x00, 0x08, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x81, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x18,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x1F, 0xF3, 0xE0, 0xF8, 0x07,
  0xFF, 0xBE, 0x0F, 0x80, 0x7F, 0xFB, 0xE0, 0xF8, 0x0F, 0xF3, 0xFE, 0x1F,
  0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x3F,
  0x00, 0xFC, 0x3F, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x3E, 0x00, 0xF8, 0x3F,
  0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x7E, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x0F,
  0x83, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x7E,
  0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7C,
  0x07, 0xF9, 0xFF, 0x07, 0xC0, 0x3F, 0xFD, 0xF0, 0x7C, 0x03, 0xFF, 0x9F,
  0x0F, 0xC0, 0x1F, 0xF1, 0xF0, 0xFC, 0x00, 0x78, 0x20, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF0,
  0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x1F,
  0xC1, 0xFF, 0xFC, 0x3F, 0x83, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xE0, 0xFC,
  0x0F, 0xFF, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x07, 0xBC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x7D,
  0xF0, 0x1F, 0xBC, 0x0F, 0xBE, 0x03, 0xE7, 0xC3, 0xE7, 0xC0, 0x7C, 0xF8,
  0x7C, 0xF8, 0x0F, 0x9F, 0x0F, 0x3F, 0x01, 0xF1, 0xE3, 0xE7, 0xC0, 0x3E,
  0x3C, 0x78, 0xF8, 0x0F, 0xC7, 0x9F, 0x1F, 0x01, 0xF8, 0xF3, 0xC7, 0xE0,
  0x3F, 0x1F, 0xF8, 0xFC, 0x07, 0xE3, 0xFE, 0x1F, 0x80, 0xFC, 0x7F, 0xC3,
  0xE0, 0x1F, 0x87, 0xF8, 0xFC, 0x03, 0xE0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F,
  0xC3, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x7F,
  0x80, 0x07, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x1F,
  0xF8, 0x01, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x03,
  0xFF, 0x80, 0x3F, 0x03, 0xF7, 0xC0, 0x3F, 0x01, 0xFB, 0xE0, 0x1F, 0x80,
  0xFD, 0xF0, 0x0F, 0xC0, 0x7E, 0xF8, 0x07, 0xE0, 0x3F, 0x7E, 0x03, 0xF0,
  0x1F, 0x1F, 0x01, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC,
  0x07, 0xE3, 0xE0, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x1F,
  0x80, 0xFC, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x87,
  0xE0, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xC0, 0xF8,
  0xFC, 0x07, 0xE0, 0x7C, 0x7E, 0x03, 0xF0, 0x3E, 0x3F, 0x03, 0xF0, 0x1F,
  0x9F, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0x01,
  0xF7, 0xE0, 0x3F, 0x00, 0xFB, 0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x0F, 0x80,
  0x3F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFC, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xC0, 0x7C,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x0F,
  0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x07,
  0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xE7,
  0xE0, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0x03,
  0xE3, 0xF0, 0x1F, 0xC0, 0x7C, 0x7E, 0x07, 0xF8, 0x1F, 0x8F, 0xC0, 0xFF,
  0x03, 0xF1, 0xF8, 0x1F, 0xE0, 0x7C, 0x3E, 0x03, 0xBC, 0x0F, 0x87, 0xC0,
  0xF7, 0x83, 0xF0, 0xF8, 0x1E, 0xF0, 0x7E, 0x1F, 0x03, 0x9C, 0x0F, 0x83,
  0xE0, 0xF3, 0x81, 0xF0, 0x7C, 0x1E, 0x70, 0x7E, 0x0F, 0x83, 0xCE, 0x0F,
  0x81, 0xF0, 0x71, 0xC1, 0xF0, 0x3E, 0x1E, 0x38, 0x3E, 0x07, 0xC3, 0xC7,
  0x0F, 0xC0, 0xF8, 0x78, 0xE1, 0xF0, 0x3F, 0x1E, 0x3C, 0x3E, 0x07, 0xE3,
  0xC7, 0x87, 0xC0, 0xFC, 0x78, 0xF1, 0xF8, 0x1F, 0x8E, 0x1E, 0x3E, 0x03,
  0xF3, 0xC3, 0xC7, 0xC0, 0x7C, 0x78, 0x78, 0xF8, 0x0F, 0x8F, 0x0F, 0x3E,
  0x01, 0xF1, 0xC1, 0xE7, 0xC0, 0x3E, 0x78, 0x3C, 0xF8, 0x07, 0xCF, 0x07,
  0x9F, 0x00, 0xF9, 0xC0, 0xF7, 0xC0, 0x1F, 0x78, 0x1E, 0xF8, 0x03, 0xEF,
  0x03, 0xDF, 0x00, 0x7D, 0xE0, 0x73, 0xE0, 0x0F, 0xB8, 0x0E, 0xF8, 0x01,
  0xFF, 0x01, 0xDF, 0x00, 0x3F, 0xE0, 0x3B, 0xE0, 0x07, 0xFC, 0x07, 0x7C,
  0x00, 0xF7, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF,
  0x7F, 0x03, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF,
  0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x7E, 0x01, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xC7, 0xE0, 0x07, 0xFE,
  0x1F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xFC, 0x7F, 0xF0, 0x07, 0xE3, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xC0, 0x7E,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0xC0, 0x1F,
  0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xEF, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0xC0,
  0x7E, 0x7F, 0xFE, 0x01, 0xF9, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0xF1, 0xFC, 0x00,
  0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xFD, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0x1F, 0x80, 0x07,
  0xFE, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x8F,
  0xC0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x7F, 0x01, 0xFF,
  0xF3, 0xF8, 0x07, 0xFF, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xFC, 0x7F, 0xF0, 0x07, 0xF7, 0xFF, 0xE0, 0x1F, 0x9F,
  0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x81, 0xFF, 0xEF, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0x81, 0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x03,
  0xE7, 0xF8, 0xFF, 0x01, 0xF7, 0xFC, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x03,
  0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0xC0,
  0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1E,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF8, 0x7E, 0x07,
  0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x80,
  0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0,
  0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xFF, 0x00, 0x7F, 0x7F, 0xFE, 0x01,
  0xF9, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xF1, 0xFF, 0xC0, 0x0F, 0xE7, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xC0,
  0x3F, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0xFF, 0x80, 0x3F, 0x81, 0xFB, 0x81, 0xFF, 0x03, 0xF7, 0xFF, 0xFC,
  0x07, 0xEF, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x00,
  0x7F, 0x0F, 0xFC, 0x00, 0xFE, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFF, 0x7F, 0x03, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0x00,
  0xFF, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x3B, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x7E, 0x01, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xC7, 0xE0, 0x07,
  0xFE, 0x1F, 0x80, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xE3, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x80,
  0x7E, 0xFF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3E,
  0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F, 0xE0, 0x7C,
  0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x1D, 0xE0, 0xF8,
  0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x39, 0xE1, 0xF0,
  0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0x71, 0xE1, 0xF0,
  0xF8, 0xF1, 0xE3, 0xE0, 0xF8, 0xF1, 0xE3, 0xE0, 0xF8, 0xE1, 0xE3, 0xE0,
  0xF9, 0xE1, 0xE7, 0xC0, 0xF9, 0xE1, 0xE7, 0xC0, 0xF9, 0xC1, 0xE7, 0xC0,
  0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x80,
  0xFB, 0x81, 0xEF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xDF, 0x83, 0xFF,
  0xFE, 0xFC, 0x0F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFE, 0x7E, 0x00, 0xFF, 0xC3,
  0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7E,
  0x1F, 0xFC, 0x00, 0xF8, 0x7F, 0xFC, 0x01, 0xF1, 0xFF, 0xFC, 0x07, 0xE3,
  0xFF, 0xFC, 0x0F, 0xCF, 0xE3, 0xF8, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x3E,
  0x03, 0xFD, 0xFC, 0x7C, 0x07, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xE3, 0xF0,
  0x07, 0xFF, 0x87, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 15, 43, 35, 11, -43 },
  { 82, 22, 18, 35, 10, -43 },
  { 132, 35, 43, 35, 1, -43 },
  { 321, 32, 59, 35, 2, -51 },
  { 557, 41, 43, 35, -2, -43 },
  { 778, 33, 45, 35, 1, -44 },
  { 964, 9, 18, 35, 16, -43 },
  { 985, 25, 57, 35, 9, -50 },
  { 1164, 25, 57, 35, 3, -50 },
  { 1343, 31, 31, 35, 3, -36 },
  { 1464, 29, 27, 35, 4, -33 },
  { 1562, 16, 18, 35, 5, -9 },
  { 1598, 20, 5, 35, 8, -22 },
  { 1611, 11, 11, 35, 10, -10 },
  { 1627, 37, 55, 35, 0, -49 },
  { 1882, 31, 45, 35, 3, -44 },
  { 2057, 28, 43, 35, 3, -43 },
  { 2208, 32, 44, 35, 2, -44 },
  { 2384, 30, 44, 35, 3, -43 },
  { 2549, 29, 43, 35, 3, -43 },
  { 2705, 31, 44, 35, 3, -43 },
  { 2876, 30, 44, 35, 2, -43 },
  { 3041, 30, 43, 35, 6, -43 },
  { 3203, 30, 45, 35, 3, -44 },
  { 3372, 30, 44, 35, 5, -44 },
  { 3537, 15, 34, 35, 10, -33 },
  { 3601, 19, 42, 35, 6, -33 },
  { 3701, 29, 31, 35, 5, -35 },
  { 3814, 29, 21, 35, 4, -30 },
  { 3891, 29, 31, 35, 3, -35 },
  { 4004, 24, 43, 35, 8, -43 },
  { 4133, 36, 55, 35, 0, -44 },
  { 4381, 30, 43, 35, 0, -43 },
  { 4543, 32, 43, 35, 2, -43 },
  { 4715, 31, 45, 35, 3, -44 },
  { 4890, 32, 43, 35, 2, -43 },
  { 5062, 32, 43, 35, 3, -43 },
  { 5234, 32, 43, 35, 3, -43 },
  { 5406, 31, 45, 35, 3, -44 },
  { 5581, 33, 43, 35, 2, -43 },
  { 5759, 31, 43, 35, 3, -43 },
  { 5926, 33, 44, 35, 1, -43 },
  { 6108, 35, 43, 35, 2, -43 },
  { 6297, 26, 43, 35, 4, -43 },
  { 6437, 35, 43, 35, 1, -43 },
  { 6626, 33, 43, 35, 2, -43 },
  { 6804, 31, 45, 35, 3, -44 },
  { 6979, 34, 43, 35, 2, -43 },
  { 7162, 31, 55, 35, 3, -44 },
  { 7376, 33, 43, 35, 2, -43 },
  { 7554, 32, 45, 35, 2, -44 },
  { 7734, 31, 43, 35, 6, -43 },
  { 7901, 32, 44, 35, 3, -43 },
  { 8077, 30, 43, 35, 7, -43 },
  { 8239, 35, 43, 35, 3, -43 },
  { 8428, 38, 43, 35, -1, -43 },
  { 8633, 32, 43, 35, 6, -43 },
  { 8805, 32, 43, 35, 2, -43 },
  { 8977, 24, 55, 35, 8, -49 },
  { 9142, 19, 55, 35, 9, -49 },
  { 9273, 24, 55, 35, 5, -49 },
  { 9438, 27, 23, 35, 5, -43 },
  { 9516, 29, 6, 35, 0, 1 },
  { 9538, 12, 8, 35, 15, -46 },
  { 9550, 30, 34, 35, 3, -33 },
  { 9678, 30, 44, 35, 2, -43 },
  { 9843, 30, 34, 35, 3, -33 },
  { 9971, 32, 44, 35, 3, -43 },
  { 10147, 29, 34, 35, 3, -33 },
  { 10271, 40, 54, 35, -3, -43 },
  { 10541, 29, 44, 35, 4, -33 },
  { 10701, 30, 43, 35, 2, -43 },
  { 10863, 29, 46, 35, 2, -46 },
  { 11030, 31, 57, 35, 1, -46 },
  { 11251, 32, 43, 35, 3, -43 },
  { 11423, 26, 43, 35, 5, -43 },
  { 11563, 33, 33, 35, 1, -33 },
  { 11700, 30, 33, 35, 2, -33 },
  { 11824, 29, 34, 35, 3, -33 },
  { 11948, 31, 44, 35, 1, -33 },
  { 12119, 30, 44, 35, 3, -33 },
  { 12284, 31, 33, 35, 3, -33 },
  { 12412, 29, 34, 35, 3, -33 },
  { 12536, 28, 41, 35, 5, -41 },
  { 12680, 30, 33, 35, 3, -32 },
  { 12804, 30, 32, 35, 5, -32 },
  { 12924, 32, 32, 35, 4, -32 },
  { 13052, 35, 32, 35, 0, -32 },
  { 13192, 29, 43, 35, 4, -32 },
  { 13348, 30, 32, 35, 2, -32 },
  { 13468, 31, 55, 35, 5, -49 },
  { 13682, 15, 55, 35, 11, -49 },
  { 13786, 31, 55, 35, 1, -49 },
  { 14000, 31, 13, 35, 3, -27 },
};

const GFXfont JetBrainsMono_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_MEDIUMITALIC59PT7B_H_
