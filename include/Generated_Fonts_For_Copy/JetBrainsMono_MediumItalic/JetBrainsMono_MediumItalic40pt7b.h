#ifndef _JETBRAINSMONO_MEDIUMITALIC40PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8,
  0x7C, 0x00, 0x7C, 0x3D, 0xF0, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x7D, 0xE1,
  0xEF, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x38, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E,
  0xFF, 0x83, 0xE6, 0x3E, 0x3E, 0x31, 0xF1, 0xE1, 0x8F, 0x8F, 0x1C, 0x00,
  0x78, 0xE0, 0x03, 0xE7, 0x00, 0x1F, 0x38, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x0C, 0xFC, 0x00, 0x63, 0xE0, 0x03, 0x1F, 0x00, 0x38, 0x79, 0xE1, 0xC3,
  0xCF, 0x0E, 0x3E, 0x7C, 0x61, 0xE3, 0xE3, 0x1F, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x78, 0x1F, 0xF0, 0x07, 0x01, 0xFF, 0xC0, 0x70, 0x0E, 0x0E,
  0x07, 0x80, 0x70, 0x70, 0x78, 0x03, 0x83, 0x87, 0x80, 0x3C, 0x3C, 0x38,
  0x01, 0xE1, 0xE3, 0x80, 0x0E, 0x0E, 0x38, 0x00, 0x78, 0xF3, 0x80, 0x03,
  0xFF, 0x3C, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x7E,
  0x00, 0x01, 0xEF, 0xF8, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0xE7, 0x8F, 0x00,
  0x0E, 0x38, 0x38, 0x00, 0xE3, 0xC1, 0xC0, 0x0E, 0x1E, 0x1E, 0x00, 0xF0,
  0xE0, 0xF0, 0x0F, 0x07, 0x07, 0x00, 0xF0, 0x3C, 0x78, 0x07, 0x01, 0xFF,
  0x80, 0x70, 0x07, 0xFC, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xE1, 0xF0, 0x1E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x7D, 0xF1, 0xE3, 0xE7, 0x87,
  0xCF, 0x1E, 0x0F, 0x78, 0x78, 0x3F, 0xE1, 0xE0, 0x7F, 0x0F, 0x81, 0xF8,
  0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xE0, 0x7F, 0x0F, 0xC7, 0xFC, 0x1F,
  0xFE, 0xF8, 0x7F, 0xF1, 0xE0, 0xFF, 0x07, 0xC0, 0x7D, 0xF7, 0xDE, 0x79,
  0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x10, 0x3C, 0x0D, 0xF0, 0xE3, 0xEF, 0xC6, 0x7F,
  0xFF, 0xB7, 0xF9, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xCE, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xE0, 0x1E, 0x1F, 0x01,
  0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x18, 0x7E, 0x7E, 0xFE, 0xFE,
  0xFE, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x07,
  0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xF0, 0x07,
  0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x38, 0x78, 0xF3,
  0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xC3, 0x8F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xCF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0x3E, 0x07, 0x87, 0x80, 0xE0, 0xF0,
  0x10, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFE, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8,
  0xF8, 0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0xF8,
  0x1E, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x9F, 0xC0, 0x3D, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xEF, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xFB, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xFB, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xCF, 0xE7, 0xE0, 0x3E,
  0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x0F, 0xC7, 0xF3,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x78, 0x01, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xCF, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x07,
  0xC0, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xF0,
  0xF8, 0x07, 0x87, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x1F, 0xCF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x78,
  0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0x9F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x87, 0xF1, 0xFC,
  0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x08, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0B, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x8F, 0x1C, 0x07, 0xEF, 0x1C, 0x1F,
  0xFF, 0x3C, 0x1F, 0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x38,
  0x1E, 0x38, 0x38, 0x1E, 0x38, 0x78, 0x1E, 0x78, 0x78, 0x1E, 0x78, 0x78,
  0x1C, 0x78, 0x78, 0x1C, 0x78, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x70, 0x78,
  0x7C, 0xF0, 0x7F, 0xFC, 0xF0, 0x3F, 0xB8, 0xF0, 0x0E, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0xF9,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x78,
  0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x78, 0x03,
  0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x7C,
  0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F,
  0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x8F,
  0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x78, 0x03,
  0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80,
  0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x1F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xFE, 0x3C, 0x3F, 0xE3,
  0xE1, 0xFF, 0x1F, 0x1F, 0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0xCF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7F, 0x7F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x1E,
  0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x1F,
  0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0x70, 0xFC, 0x0F,
  0xE1, 0xDC, 0x3B, 0x87, 0xB8, 0x77, 0x0F, 0x71, 0xCE, 0x1E, 0xE3, 0xBC,
  0x3D, 0xCF, 0x78, 0x7B, 0x9C, 0xF0, 0xE7, 0x79, 0xC3, 0xC7, 0xE7, 0x87,
  0x8F, 0xCF, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x1E, 0x0F, 0xC0, 0x78, 0x1F, 0x80, 0xF0, 0x3F, 0x01, 0xE0, 0xFE, 0x03,
  0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x3C, 0x0F, 0x70, 0x78,
  0x1C, 0xE0, 0xF0, 0x79, 0xE1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE7, 0x87, 0x83,
  0xC7, 0x1E, 0x07, 0x8E, 0x3C, 0x0F, 0x1E, 0x78, 0x3C, 0x3C, 0xF0, 0x78,
  0x79, 0xE0, 0xF0, 0x73, 0xC1, 0xE0, 0xE7, 0x83, 0xC1, 0xEE, 0x07, 0x83,
  0xFC, 0x0F, 0x07, 0xF8, 0x3C, 0x07, 0xF0, 0x78, 0x0F, 0xE0, 0xF0, 0x1F,
  0xC1, 0xE0, 0x3F, 0x03, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x07,
  0xC0, 0xF8, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x07,
  0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x8F,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF0, 0x3F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFC, 0x3F, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xDF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1F,
  0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x83,
  0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE1,
  0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xFB,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0x81,
  0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x87, 0x80, 0xF0,
  0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x7C, 0xF0, 0x07, 0xCF,
  0x00, 0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0x1E, 0x0F, 0x38, 0x3E, 0x0F, 0x38, 0x3E, 0x0E, 0x38, 0x3E, 0x1E,
  0x78, 0x3E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1C, 0x78, 0x6E, 0x3C,
  0x78, 0xEE, 0x3C, 0x78, 0xEE, 0x38, 0x78, 0xCC, 0x38, 0x78, 0xCC, 0x78,
  0x79, 0xCC, 0x78, 0x79, 0xCC, 0x70, 0x79, 0x8C, 0x70, 0x73, 0x8C, 0xF0,
  0x73, 0x8C, 0xF0, 0x73, 0x0C, 0xE0, 0x73, 0x0D, 0xE0, 0x77, 0x0D, 0xE0,
  0x77, 0x0D, 0xC0, 0x76, 0x1D, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0xC3,
  0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0x7D, 0xE0, 0x03, 0xE7, 0x80, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE0,
  0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78,
  0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xB8, 0x01,
  0xEE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x1C, 0x07, 0x87, 0x03, 0xC1,
  0xE1, 0xE0, 0x78, 0x78, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0xFF, 0x80, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x7C,
  0x3E, 0x1E, 0x1F, 0x03, 0xFC, 0xF0, 0x7F, 0xEF, 0x0F, 0xFE, 0xF1, 0xFC,
  0xEF, 0x1F, 0x03, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0xFC,
  0x7F, 0x3F, 0x87, 0xFF, 0x78, 0x3F, 0xF7, 0x81, 0xFC, 0x78, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE3, 0xF8, 0x1E, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xCF, 0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C, 0xFC, 0x0F,
  0x8F, 0x73, 0xF8, 0xF7, 0xFF, 0x0F, 0x7F, 0xE0, 0xF3, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFE, 0xFE, 0x1F, 0x03, 0xE3,
  0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0x3F, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0xFF, 0x3C, 0x07, 0xFE, 0xF0, 0x3F, 0xFB, 0xC1, 0xFC, 0xEF,
  0x07, 0xC0, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0,
  0x7C, 0x0F, 0xC1, 0xFC, 0xFE, 0x07, 0xFF, 0x78, 0x0F, 0xFD, 0xE0, 0x1F,
  0xC7, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x7E,
  0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7E,
  0x1F, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0xF0, 0x7F, 0xEF, 0x0F, 0xFE, 0xF1, 0xFC, 0xEF, 0x1F, 0x03, 0xF3,
  0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E,
  0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0xC0, 0x7C, 0x7E, 0x1B, 0xC7, 0xFF, 0xFC, 0x3F, 0xF7, 0x81, 0xFE,
  0x78, 0x07, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE3, 0xF8, 0x1E, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xC7, 0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x3F, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0xF8, 0x0F,
  0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x1E, 0xF9, 0xF8, 0x77, 0xEF, 0xE1, 0xDF, 0xFF, 0xC7, 0x8F,
  0x1F, 0x3C, 0x3C, 0x3C, 0xF0, 0xE0, 0xF3, 0xC3, 0x87, 0x8F, 0x0E, 0x1E,
  0x3C, 0x38, 0x78, 0xE0, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1E, 0x1E, 0x78,
  0x70, 0x71, 0xE1, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x1C, 0x3C, 0xF0, 0xF0,
  0xF3, 0xC3, 0xC3, 0xCF, 0x0E, 0x0E, 0x3C, 0x38, 0x78, 0xF0, 0xE1, 0xE3,
  0xC3, 0x87, 0x80, 0x1E, 0x3F, 0x81, 0xEF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC,
  0x7E, 0x3F, 0x03, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x01, 0xFF,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFE, 0xFE, 0x1F, 0x03, 0xE3, 0xE0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C,
  0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0x7F, 0x03, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0x8F, 0xE0, 0x1E, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFC, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87,
  0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xDC, 0xFE, 0x0F, 0x7F, 0xF0,
  0x3D, 0xFF, 0x80, 0xF3, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0xF0, 0x7F, 0xEF, 0x0F, 0xFE, 0xF1, 0xFC, 0xEF, 0x1F,
  0x03, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7,
  0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F,
  0x87, 0xFF, 0x78, 0x3F, 0xF7, 0x81, 0xFC, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0x3F, 0xC0, 0x7B, 0xFF, 0x07, 0xFF, 0xFC, 0x3D, 0x87,
  0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E,
  0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1E, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x80, 0x7C, 0xFC, 0x1F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7,
  0xC0, 0xF8, 0x7F, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07,
  0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0xC1,
  0xE0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C,
  0xF8, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xE0, 0x78, 0x3F, 0x83, 0xE0,
  0xEE, 0x0F, 0x87, 0xB8, 0x3E, 0x1C, 0xE1, 0xF8, 0x73, 0x87, 0xE3, 0xCE,
  0x1B, 0x8F, 0x38, 0xEE, 0x38, 0xE3, 0xB9, 0xE3, 0x8C, 0xE7, 0x8E, 0x73,
  0x9C, 0x39, 0xCE, 0x70, 0xE6, 0x3B, 0xC3, 0x98, 0xEE, 0x0E, 0xE3, 0xB8,
  0x3B, 0x0D, 0xE0, 0xEC, 0x37, 0x03, 0xF0, 0xDC, 0x0F, 0x83, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x3C,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80,
  0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x00,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xF7, 0x81,
  0xFE, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x08, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x79, 0xFF, 0x03, 0xDF, 0xFC, 0x1C, 0xF1, 0xF1, 0xE7, 0x87, 0x8F, 0x78,
  0x3F, 0xF3, 0xC0, 0xFF, 0x9E, 0x03, 0xF0,
};

const GFXglyph JetBrainsMono_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 29, 24, 7, -29 },
  { 38, 14, 12, 24, 7, -29 },
  { 59, 23, 29, 24, 1, -29 },
  { 143, 21, 41, 24, 2, -35 },
  { 251, 29, 29, 24, -2, -29 },
  { 357, 22, 30, 24, 1, -30 },
  { 440, 6, 12, 24, 11, -29 },
  { 449, 17, 39, 24, 6, -34 },
  { 532, 17, 39, 24, 2, -34 },
  { 615, 21, 20, 24, 2, -24 },
  { 668, 19, 19, 24, 3, -23 },
  { 714, 12, 12, 24, 3, -6 },
  { 732, 14, 4, 24, 5, -15 },
  { 739, 8, 7, 24, 7, -7 },
  { 746, 25, 37, 24, 0, -33 },
  { 862, 21, 30, 24, 2, -30 },
  { 941, 19, 29, 24, 2, -29 },
  { 1010, 21, 30, 24, 2, -30 },
  { 1089, 21, 29, 24, 2, -29 },
  { 1166, 20, 29, 24, 2, -29 },
  { 1239, 21, 29, 24, 2, -29 },
  { 1316, 20, 29, 24, 2, -29 },
  { 1389, 20, 29, 24, 4, -29 },
  { 1462, 21, 30, 24, 2, -30 },
  { 1541, 20, 30, 24, 3, -30 },
  { 1616, 10, 22, 24, 7, -22 },
  { 1644, 13, 28, 24, 4, -22 },
  { 1690, 20, 22, 24, 3, -24 },
  { 1745, 19, 14, 24, 3, -20 },
  { 1779, 19, 22, 24, 2, -24 },
  { 1832, 17, 29, 24, 5, -29 },
  { 1894, 24, 37, 24, 0, -30 },
  { 2005, 21, 29, 24, 0, -29 },
  { 2082, 21, 29, 24, 2, -29 },
  { 2159, 21, 30, 24, 2, -30 },
  { 2238, 21, 29, 24, 2, -29 },
  { 2315, 22, 29, 24, 2, -29 },
  { 2395, 22, 29, 24, 2, -29 },
  { 2475, 21, 30, 24, 2, -30 },
  { 2554, 21, 29, 24, 2, -29 },
  { 2631, 21, 29, 24, 2, -29 },
  { 2708, 23, 29, 24, 0, -29 },
  { 2792, 23, 29, 24, 2, -29 },
  { 2876, 17, 29, 24, 3, -29 },
  { 2938, 23, 29, 24, 1, -29 },
  { 3022, 23, 29, 24, 1, -29 },
  { 3106, 21, 30, 24, 2, -30 },
  { 3185, 22, 29, 24, 2, -29 },
  { 3265, 21, 37, 24, 2, -30 },
  { 3363, 22, 29, 24, 2, -29 },
  { 3443, 22, 30, 24, 1, -30 },
  { 3526, 21, 29, 24, 4, -29 },
  { 3603, 22, 29, 24, 2, -29 },
  { 3683, 20, 29, 24, 5, -29 },
  { 3756, 24, 29, 24, 2, -29 },
  { 3843, 25, 29, 24, 0, -29 },
  { 3934, 22, 29, 24, 4, -29 },
  { 4014, 21, 29, 24, 2, -29 },
  { 4091, 17, 37, 24, 5, -33 },
  { 4170, 13, 37, 24, 6, -33 },
  { 4231, 17, 37, 24, 3, -33 },
  { 4310, 18, 15, 24, 3, -29 },
  { 4344, 20, 4, 24, 0, 1 },
  { 4354, 8, 5, 24, 10, -31 },
  { 4359, 20, 22, 24, 2, -22 },
  { 4414, 20, 29, 24, 2, -29 },
  { 4487, 20, 22, 24, 2, -22 },
  { 4542, 22, 29, 24, 2, -29 },
  { 4622, 20, 22, 24, 2, -22 },
  { 4677, 27, 36, 24, -2, -29 },
  { 4799, 20, 29, 24, 2, -22 },
  { 4872, 20, 29, 24, 2, -29 },
  { 4945, 20, 31, 24, 1, -31 },
  { 5023, 22, 38, 24, 0, -31 },
  { 5128, 22, 29, 24, 2, -29 },
  { 5208, 17, 29, 24, 4, -29 },
  { 5270, 22, 22, 24, 1, -22 },
  { 5331, 20, 22, 24, 2, -22 },
  { 5386, 20, 22, 24, 2, -22 },
  { 5441, 22, 29, 24, 0, -22 },
  { 5521, 20, 29, 24, 2, -22 },
  { 5594, 21, 22, 24, 2, -22 },
  { 5652, 20, 22, 24, 2, -22 },
  { 5707, 20, 28, 24, 3, -28 },
  { 5777, 20, 22, 24, 2, -22 },
  { 5832, 20, 22, 24, 4, -22 },
  { 5887, 22, 22, 24, 3, -22 },
  { 5948, 23, 22, 24, 0, -22 },
  { 6012, 20, 29, 24, 2, -22 },
  { 6085, 20, 22, 24, 2, -22 },
  { 6140, 20, 37, 24, 4, -33 },
  { 6233, 11, 37, 24, 7, -33 },
  { 6284, 21, 37, 24, 1, -33 },
  { 6382, 21, 8, 24, 2, -18 },
};

const GFXfont JetBrainsMono_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_MEDIUMITALIC40PT7B_H_
