#ifndef _JETBRAINSMONO_MEDIUMITALIC47PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x80,
  0x3E, 0x0F, 0x9F, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFC, 0xE7, 0xE0, 0x7C, 0x71, 0xF8, 0x7E, 0x38,
  0x7C, 0x3E, 0x1C, 0x3E, 0x1F, 0x0E, 0x1F, 0x0F, 0x86, 0x00, 0x07, 0xC7,
  0x00, 0x03, 0xE3, 0x80, 0x01, 0xF9, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x9F, 0x80, 0x01, 0xC7, 0xE0,
  0x01, 0xC3, 0xF0, 0x00, 0xE1, 0xF8, 0x00, 0x70, 0xFC, 0xF8, 0x38, 0x7C,
  0x7C, 0x1C, 0x3E, 0x3F, 0x0E, 0x3F, 0x1F, 0x86, 0x1F, 0x07, 0xF7, 0x3F,
  0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x7F, 0xF0, 0x03, 0xC0,
  0x7F, 0xF8, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x03, 0xC0, 0x0F, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC1, 0xE0,
  0x03, 0xC1, 0xE1, 0xE0, 0x03, 0xC0, 0xF1, 0xE0, 0x01, 0xE0, 0x79, 0xE0,
  0x00, 0x78, 0xF9, 0xE0, 0x00, 0x3F, 0xF9, 0xE0, 0x00, 0x0F, 0xF8, 0xF0,
  0x00, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x00, 0xF9,
  0xFE, 0x00, 0x00, 0x79, 0xFF, 0x80, 0x00, 0x79, 0xFF, 0xE0, 0x00, 0x79,
  0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x78, 0x00, 0x78, 0x70, 0x3C, 0x00, 0x78,
  0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x07, 0x80, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xE3, 0xE0, 0x3C,
  0x01, 0xFF, 0xE0, 0x3C, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x7C, 0xF8, 0xF8, 0x3E, 0x3E, 0x3F, 0x1F, 0x9F, 0x07, 0xC7, 0xC7,
  0xC1, 0xFB, 0xE1, 0xF0, 0x3F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F, 0x01, 0xFE,
  0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x01,
  0xFE, 0x0F, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7C, 0x0F,
  0xFF, 0x0F, 0x81, 0xFF, 0x03, 0xF0, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F,
  0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x3C, 0x07, 0x3E, 0x0E,
  0x1F, 0xBF, 0xC7, 0x3F, 0xFF, 0xF3, 0x3F, 0xEF, 0xFD, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x01,
  0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x78, 0x07, 0xC0, 0x18, 0x03, 0x80,
  0x04, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1E,
  0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C,
  0x3C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0x0F, 0x8F, 0xCF, 0x87,
  0xC7, 0xC7, 0xC3, 0xE1, 0xC3, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFB, 0xE0, 0x3F, 0xCF, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF0,
  0x0E, 0x07, 0xC0, 0x30, 0x1F, 0x01, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x04, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0x81,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x02, 0x00, 0x1F, 0x3F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3E, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF9, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x1F,
  0x8F, 0xE0, 0x7E, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0xC7, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x0F,
  0xF1, 0xFF, 0x1F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7F, 0x07, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x0F, 0x01, 0xFF, 0x78, 0x78, 0x1F, 0xFB,
  0xC3, 0xC0, 0xFC, 0xFE, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x0F, 0x0F,
  0x83, 0xC0, 0x78, 0x7C, 0x3E, 0x03, 0xC3, 0xC1, 0xF0, 0x3E, 0x1E, 0x0F,
  0x01, 0xF0, 0xF0, 0x78, 0x0F, 0x87, 0x83, 0xC0, 0x78, 0x7C, 0x1E, 0x03,
  0xC3, 0xE1, 0xF0, 0x1E, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x7C, 0x0F, 0x87,
  0x83, 0xF0, 0xFC, 0x3C, 0x0F, 0xFD, 0xC3, 0xE0, 0x7F, 0xDE, 0x1F, 0x01,
  0xFC, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7C, 0x07, 0xF0, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x3F, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0xFE, 0x7C, 0x1F, 0xFC, 0x7C, 0x1F,
  0xFC, 0x7C, 0x1F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x07, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xB8, 0x0F, 0xF0, 0x77, 0x01, 0xFE, 0x0E, 0xF0, 0x7B, 0xC3,
  0xDE, 0x0F, 0x70, 0x7B, 0xC1, 0xDE, 0x0F, 0x78, 0x7B, 0xC1, 0xE7, 0x0E,
  0x78, 0x3C, 0xE3, 0xCF, 0x07, 0x9C, 0x73, 0xE1, 0xF3, 0xDE, 0x78, 0x3E,
  0x7B, 0xCF, 0x07, 0xCF, 0xF1, 0xE0, 0xF9, 0xFE, 0x7C, 0x1E, 0x1F, 0x8F,
  0x83, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x78, 0x1F, 0xC0, 0x3E, 0x0F,
  0xF0, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0xF7, 0x80, 0xF8, 0x3D, 0xE0, 0x3E,
  0x0F, 0x78, 0x0F, 0x03, 0xDE, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x7C, 0xF0,
  0x7C, 0x1F, 0x3C, 0x1F, 0x07, 0xCF, 0x07, 0xC1, 0xF3, 0xC1, 0xE0, 0x78,
  0xF8, 0x78, 0x3E, 0x1E, 0x3E, 0x0F, 0x87, 0x8F, 0x83, 0xE1, 0xE3, 0xE0,
  0xF8, 0x78, 0xF8, 0x3E, 0x1F, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3,
  0xC1, 0xF0, 0x3D, 0xF0, 0x7C, 0x0F, 0x7C, 0x1F, 0x03, 0xFF, 0x07, 0xC0,
  0x7F, 0xC1, 0xE0, 0x1F, 0xE0, 0x78, 0x07, 0xF8, 0x3E, 0x01, 0xFE, 0x0F,
  0x80, 0x7F, 0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xC0, 0x7F, 0x83, 0xE0, 0x07, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7C,
  0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0x83, 0xE0, 0x07, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x7F,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C,
  0x07, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x1E, 0x7C, 0x1F, 0x83, 0xE7,
  0xC1, 0xF8, 0x3E, 0x78, 0x1F, 0x83, 0xC7, 0x83, 0xB8, 0x3C, 0x78, 0x3B,
  0x87, 0xC7, 0x83, 0xB8, 0x78, 0x78, 0x3B, 0x87, 0x87, 0x87, 0x30, 0x78,
  0x78, 0x73, 0x0F, 0x87, 0x87, 0x70, 0xF0, 0x78, 0x77, 0x0F, 0x07, 0x8E,
  0x70, 0xF0, 0x78, 0xE7, 0x1F, 0x07, 0x8E, 0x71, 0xE0, 0x79, 0xC7, 0x1E,
  0x0F, 0x9C, 0x71, 0xE0, 0xF9, 0xC7, 0x3E, 0x0F, 0x9C, 0x73, 0xC0, 0xF3,
  0x87, 0x3C, 0x0F, 0x38, 0x73, 0xC0, 0xF3, 0x87, 0x78, 0x0F, 0x70, 0x77,
  0x80, 0xF7, 0x07, 0x78, 0x0F, 0x70, 0x77, 0x80, 0xF7, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x00,
  0x78, 0xF8, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x00,
  0xFF, 0x1F, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F,
  0xE0, 0xDF, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFE, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F,
  0xFD, 0xF0, 0x0F, 0xF1, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F,
  0xBF, 0xFC, 0x1F, 0x7F, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFB,
  0xFF, 0xF0, 0xFB, 0xFF, 0xE0, 0xF9, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x1F, 0x00, 0x7F, 0xE7, 0xC0, 0x3F,
  0xFD, 0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xE0, 0xDF, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xFB, 0xE0, 0x1F, 0xFD,
  0xF0, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0x80, 0xFC, 0x7C, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C,
  0xFC, 0x01, 0xF1, 0xF0, 0x1F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x3E, 0x07, 0xFE, 0x7C, 0x1F,
  0xFE, 0xF8, 0x7F, 0xFD, 0xF1, 0xFC, 0x1B, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC3,
  0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C, 0x07,
  0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xF0, 0x0F, 0x9F,
  0xF8, 0x0F, 0xBF, 0xFC, 0x1F, 0x7F, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0x3E, 0x1F, 0x03, 0xDF, 0xDF, 0xE1, 0xFF, 0xF7, 0xF8, 0x7F, 0x7F,
  0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xC1, 0xF1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x3E, 0x0F, 0x07, 0x8F, 0x83, 0xC3, 0xE3, 0xE0, 0xE0, 0xF8,
  0xF8, 0x78, 0x3E, 0x3C, 0x1E, 0x0F, 0x8F, 0x07, 0x83, 0xC3, 0xC1, 0xE0,
  0xF1, 0xF0, 0x78, 0x7C, 0x7C, 0x1C, 0x1F, 0x1F, 0x0F, 0x07, 0xC7, 0x83,
  0xC1, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x3E, 0x0F, 0x07, 0x8F,
  0x83, 0xC3, 0xE3, 0xE0, 0xE0, 0xF8, 0xF8, 0x78, 0x3E, 0x3C, 0x1E, 0x0F,
  0x00, 0x0F, 0x8F, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F, 0xBF, 0xFC, 0x1F, 0x7F,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x7C, 0x03, 0xF3,
  0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC7, 0xF8, 0x03, 0xE7,
  0xFE, 0x01, 0xF7, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xF7, 0xFF, 0xE0, 0xFB, 0xFF, 0xE0, 0x7C, 0xFF,
  0xE0, 0x3E, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x01, 0xFF, 0x9F,
  0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F, 0xE0, 0xDF, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF8,
  0x3F, 0xFE, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFD, 0xF0, 0x0F, 0xF1, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x0F, 0x8F, 0xF0, 0x0F, 0x3F, 0xF8, 0x1F, 0x7F, 0xFC, 0x1F, 0x7F, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x0F,
  0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x1E, 0x03, 0xFE,
  0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F,
  0xBC, 0x1F, 0x83, 0xCF, 0x07, 0xE0, 0xF3, 0xC1, 0xB8, 0x3C, 0xF0, 0xEE,
  0x1E, 0x3C, 0x3B, 0x87, 0x8F, 0x0E, 0xE1, 0xE3, 0xC7, 0x38, 0xF0, 0xF1,
  0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x38, 0xE7, 0x83, 0xCE, 0x39, 0xE0,
  0xF3, 0x8E, 0x78, 0x3D, 0xC3, 0xBC, 0x0F, 0x70, 0xEF, 0x03, 0xDC, 0x3B,
  0xC0, 0xFE, 0x0E, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7E,
  0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC3, 0xF8,
  0x7F, 0x87, 0xFF, 0xDF, 0x07, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C, 0x07, 0xF1,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x1F,
  0x3F, 0xF0, 0x1F, 0x7F, 0xF8, 0x1E, 0x7C, 0xFC, 0x1E, 0xF8, 0x7C, 0x3E,
  0xF8, 0x3F, 0x7E, 0xF0, 0x3F, 0xFC, 0xF0, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0,
  0x00, 0x01, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 34, 28, 9, -34 },
  { 48, 17, 14, 28, 8, -34 },
  { 78, 28, 34, 28, 1, -34 },
  { 197, 25, 48, 28, 2, -41 },
  { 347, 33, 35, 28, -2, -35 },
  { 492, 26, 35, 28, 1, -35 },
  { 606, 7, 14, 28, 13, -34 },
  { 619, 20, 46, 28, 7, -40 },
  { 734, 20, 46, 28, 2, -40 },
  { 849, 25, 25, 28, 2, -29 },
  { 928, 23, 23, 28, 3, -27 },
  { 995, 13, 15, 28, 4, -7 },
  { 1020, 17, 5, 28, 6, -18 },
  { 1031, 9, 8, 28, 8, -8 },
  { 1040, 29, 44, 28, 0, -39 },
  { 1200, 25, 35, 28, 2, -35 },
  { 1310, 22, 34, 28, 2, -34 },
  { 1404, 25, 35, 28, 2, -35 },
  { 1514, 25, 34, 28, 2, -34 },
  { 1621, 24, 34, 28, 2, -34 },
  { 1723, 24, 34, 28, 3, -34 },
  { 1825, 23, 34, 28, 2, -34 },
  { 1923, 24, 34, 28, 5, -34 },
  { 2025, 25, 35, 28, 2, -35 },
  { 2135, 24, 35, 28, 4, -35 },
  { 2240, 12, 26, 28, 8, -26 },
  { 2279, 16, 34, 28, 4, -26 },
  { 2347, 23, 25, 28, 4, -28 },
  { 2419, 23, 16, 28, 3, -24 },
  { 2465, 23, 25, 28, 2, -28 },
  { 2537, 20, 34, 28, 6, -34 },
  { 2622, 29, 43, 28, 0, -35 },
  { 2778, 24, 34, 28, 0, -34 },
  { 2880, 25, 34, 28, 2, -34 },
  { 2987, 24, 35, 28, 3, -35 },
  { 3092, 25, 34, 28, 2, -34 },
  { 3199, 26, 34, 28, 2, -34 },
  { 3310, 26, 34, 28, 2, -34 },
  { 3421, 24, 35, 28, 3, -35 },
  { 3526, 26, 34, 28, 2, -34 },
  { 3637, 24, 34, 28, 3, -34 },
  { 3739, 26, 34, 28, 1, -34 },
  { 3850, 28, 34, 28, 2, -34 },
  { 3969, 21, 34, 28, 3, -34 },
  { 4059, 27, 34, 28, 1, -34 },
  { 4174, 26, 34, 28, 2, -34 },
  { 4285, 24, 35, 28, 3, -35 },
  { 4390, 26, 34, 28, 2, -34 },
  { 4501, 25, 43, 28, 2, -35 },
  { 4636, 26, 34, 28, 2, -34 },
  { 4747, 25, 35, 28, 2, -35 },
  { 4857, 24, 34, 28, 5, -34 },
  { 4959, 25, 34, 28, 3, -34 },
  { 5066, 25, 34, 28, 5, -34 },
  { 5173, 28, 34, 28, 3, -34 },
  { 5292, 29, 34, 28, 0, -34 },
  { 5416, 25, 34, 28, 5, -34 },
  { 5523, 25, 34, 28, 2, -34 },
  { 5630, 20, 44, 28, 6, -39 },
  { 5740, 15, 44, 28, 7, -39 },
  { 5823, 19, 44, 28, 4, -39 },
  { 5928, 21, 18, 28, 4, -34 },
  { 5976, 23, 5, 28, 0, 1 },
  { 5991, 9, 7, 28, 12, -37 },
  { 5999, 24, 26, 28, 2, -26 },
  { 6077, 24, 34, 28, 2, -34 },
  { 6179, 23, 26, 28, 3, -26 },
  { 6254, 26, 34, 28, 2, -34 },
  { 6365, 22, 26, 28, 3, -26 },
  { 6437, 32, 42, 28, -2, -34 },
  { 6605, 23, 34, 28, 3, -26 },
  { 6703, 24, 34, 28, 2, -34 },
  { 6805, 23, 37, 28, 2, -37 },
  { 6912, 24, 45, 28, 1, -37 },
  { 7047, 26, 34, 28, 2, -34 },
  { 7158, 21, 34, 28, 4, -34 },
  { 7248, 26, 26, 28, 1, -26 },
  { 7333, 24, 26, 28, 2, -26 },
  { 7411, 22, 26, 28, 3, -26 },
  { 7483, 25, 34, 28, 1, -26 },
  { 7590, 24, 34, 28, 2, -26 },
  { 7692, 24, 26, 28, 3, -26 },
  { 7770, 24, 26, 28, 2, -26 },
  { 7848, 23, 33, 28, 4, -33 },
  { 7943, 23, 26, 28, 3, -26 },
  { 8018, 24, 26, 28, 4, -26 },
  { 8096, 26, 26, 28, 3, -26 },
  { 8181, 28, 26, 28, 0, -26 },
  { 8272, 23, 34, 28, 3, -26 },
  { 8370, 24, 26, 28, 2, -26 },
  { 8448, 24, 44, 28, 4, -39 },
  { 8580, 12, 44, 28, 9, -39 },
  { 8646, 24, 44, 28, 1, -39 },
  { 8778, 24, 11, 28, 3, -22 },
};

const GFXfont JetBrainsMono_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_MEDIUMITALIC47PT7B_H_
