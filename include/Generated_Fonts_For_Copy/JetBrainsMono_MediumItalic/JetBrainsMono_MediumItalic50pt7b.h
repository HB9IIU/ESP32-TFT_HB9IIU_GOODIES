#ifndef _JETBRAINSMONO_MEDIUMITALIC50PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C,
  0x1F, 0x9F, 0x07, 0xE7, 0xC1, 0xFB, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3,
  0xC0, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xB9, 0xFC, 0x0F, 0xC7, 0x1F, 0x81, 0xF0, 0xE1, 0xF0,
  0x7E, 0x1C, 0x3E, 0x0F, 0xC3, 0x87, 0xC1, 0xF8, 0x70, 0x00, 0x3F, 0x1C,
  0x00, 0x07, 0xE3, 0x80, 0x00, 0xFC, 0x70, 0x00, 0x1F, 0xEE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1C, 0xFE, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0xE1, 0xF8, 0x00, 0x1C, 0x1F,
  0x00, 0x03, 0x83, 0xE1, 0xF0, 0x70, 0x7C, 0x7E, 0x0E, 0x1F, 0x8F, 0xC1,
  0xC3, 0xF0, 0xF8, 0x78, 0xFC, 0x1F, 0x8E, 0x3F, 0x83, 0xFF, 0xDF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x07,
  0xFF, 0x80, 0x1F, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xF0,
  0x07, 0x83, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x0F, 0x00, 0x3C, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0xF0, 0x3C, 0x3E, 0x00, 0x1E, 0x07,
  0x87, 0x80, 0x03, 0xC0, 0xF1, 0xE0, 0x00, 0x78, 0x3C, 0x78, 0x00, 0x0F,
  0xFF, 0x9E, 0x00, 0x01, 0xFF, 0xE7, 0x80, 0x00, 0x1F, 0xF9, 0xF0, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00, 0x0F,
  0x1F, 0xE0, 0x00, 0x03, 0xE7, 0xFF, 0x00, 0x00, 0x79, 0xFF, 0xE0, 0x00,
  0x1E, 0x7C, 0x3E, 0x00, 0x07, 0x8F, 0x07, 0xC0, 0x01, 0xE1, 0xE0, 0x78,
  0x00, 0x78, 0x78, 0x1F, 0x00, 0x1F, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x0F, 0x00,
  0xF0, 0x7C, 0x03, 0xC0, 0x1F, 0xBF, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x3E,
  0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0x3F, 0x3F, 0x07, 0xE3, 0xE1, 0xF8,
  0x7C, 0x3E, 0x0F, 0x8F, 0x87, 0xE0, 0xFD, 0xF8, 0x7C, 0x07, 0xDF, 0x07,
  0xC0, 0x7F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0,
  0x7E, 0x1F, 0xFE, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF,
  0xE1, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x3E, 0xFD, 0xFB,
  0xF7, 0xEF, 0x9F, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80,
  0x7C, 0x02, 0x3C, 0x0F, 0x03, 0xC7, 0xE1, 0xE1, 0xFD, 0xFF, 0x1C, 0xFF,
  0xFF, 0xF3, 0x3F, 0xF3, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x00,
  0xC0, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x20, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC7, 0xC7, 0xE7, 0xF1, 0xF1, 0xF0, 0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F,
  0x07, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFD,
  0xF0, 0x07, 0xF9, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x03,
  0xF0, 0x0E, 0x03, 0xE0, 0x08, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x04, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F,
  0x87, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x7C, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x7C,
  0xFF, 0xE0, 0x3E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0x00, 0x0F, 0xDF, 0xF0, 0x0F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFD, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1,
  0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x0F, 0xE7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFB, 0xFC, 0x03, 0xF8,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFE, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F,
  0x80, 0x7F, 0x1F, 0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xEF, 0x80,
  0x7F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x1F, 0xCF, 0x87, 0xC0, 0x7F, 0xDF, 0x0F, 0x81, 0xFF, 0xFC, 0x1F, 0x07,
  0xE1, 0xF8, 0x3C, 0x0F, 0x81, 0xF0, 0x78, 0x1E, 0x03, 0xE1, 0xF0, 0x7C,
  0x07, 0xC3, 0xE0, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x1F, 0x0F, 0x83, 0xC0,
  0x3C, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x3E, 0x03,
  0xE1, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x07, 0xE3, 0xF8, 0x3C, 0x07, 0xFE, 0xF0,
  0xF8, 0x0F, 0xF9, 0xE1, 0xF0, 0x0F, 0xE7, 0xC3, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0x80, 0x7F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x8F, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0x81,
  0xFF, 0x01, 0xF0, 0x07, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x10, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC,
  0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0xF8, 0x3F, 0xFC, 0x7E,
  0x0F, 0xFF, 0x1F, 0x87, 0xFF, 0xC7, 0xC1, 0xFF, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xBC,
  0x1E, 0xE0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x07, 0xBC, 0x1E, 0xF0, 0x7D,
  0xE1, 0xE7, 0x83, 0xEF, 0x0F, 0x7C, 0x1F, 0x78, 0xF3, 0xE0, 0xFB, 0xC7,
  0x9E, 0x07, 0x8E, 0x3C, 0xF0, 0x3C, 0x7B, 0xCF, 0x81, 0xE3, 0xDE, 0x7C,
  0x1F, 0x1F, 0xE3, 0xE0, 0xF8, 0xFF, 0x1F, 0x07, 0xC7, 0xF1, 0xF0, 0x3E,
  0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x7F, 0x80, 0x3E,
  0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3E, 0x07, 0xF8, 0x03, 0xE0, 0x7F,
  0x80, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xBC, 0x07,
  0xC0, 0xFB, 0xC0, 0x7C, 0x0F, 0xBC, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F,
  0xBE, 0x07, 0xC0, 0xFB, 0xE0, 0xF8, 0x1F, 0x1E, 0x0F, 0x81, 0xF1, 0xE0,
  0xF8, 0x1F, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x81,
  0xF0, 0xF0, 0xF8, 0x3E, 0x0F, 0x1F, 0x03, 0xE0, 0xF1, 0xF0, 0x3E, 0x0F,
  0x9F, 0x03, 0xE0, 0xF9, 0xF0, 0x3E, 0x07, 0x9F, 0x03, 0xE0, 0x79, 0xF0,
  0x7E, 0x07, 0x9E, 0x07, 0xC0, 0x7D, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0xC0,
  0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFC,
  0x0F, 0x80, 0x3F, 0xC0, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F,
  0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x17, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x7F, 0x81, 0xF0, 0x03, 0xF8, 0x3E,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x7C, 0xF0,
  0x1F, 0x01, 0xE3, 0xC0, 0x7C, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F,
  0xC0, 0xF1, 0xF0, 0x3F, 0x03, 0xC7, 0xC1, 0xDC, 0x1F, 0x1F, 0x07, 0x70,
  0x7C, 0x7C, 0x1D, 0xC1, 0xE1, 0xF0, 0x77, 0x07, 0x87, 0xC3, 0x9C, 0x3E,
  0x1F, 0x0E, 0x70, 0xF8, 0x7C, 0x39, 0xC3, 0xC1, 0xF1, 0xE7, 0x0F, 0x07,
  0x87, 0x3C, 0x7C, 0x1E, 0x1C, 0xF1, 0xE0, 0x78, 0x73, 0x87, 0x81, 0xE3,
  0xCE, 0x3E, 0x07, 0x8E, 0x38, 0xF8, 0x1E, 0x38, 0xE3, 0xC0, 0x79, 0xE3,
  0x8F, 0x01, 0xE7, 0x0E, 0x7C, 0x07, 0x9C, 0x39, 0xF0, 0x3E, 0x70, 0xE7,
  0x80, 0xFB, 0xC3, 0x9E, 0x03, 0xEE, 0x0E, 0xF8, 0x0F, 0xB8, 0x3B, 0xE0,
  0x3E, 0xE0, 0xEF, 0x00, 0xFF, 0x03, 0xBC, 0x03, 0xDC, 0x0F, 0xF0, 0x0F,
  0x70, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x04, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0, 0x01, 0xF1, 0xF0,
  0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF9, 0xF0, 0x00, 0xF7, 0xE0, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0,
  0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFF, 0x1F, 0xF0,
  0x7F, 0xFE, 0xF8, 0x3F, 0xFF, 0x7C, 0x0F, 0xFF, 0x3E, 0x01, 0xFE, 0x3F,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x03,
  0xF3, 0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0x7F, 0xFC, 0x1F, 0xBF, 0xFC, 0x0F, 0x87, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x1F, 0xF9, 0xF8, 0x0F, 0xFF,
  0x7E, 0x07, 0xFF, 0xDF, 0x83, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xF0, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xBE,
  0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xF3, 0xE0, 0x0F, 0xF1, 0xF8, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7F,
  0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7,
  0xE0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x01,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0,
  0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xFE, 0x7F, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0, 0x1F, 0xFC, 0xF8, 0x07, 0xF8, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x03, 0xF3, 0xFF, 0x01, 0xF3, 0xFF,
  0xC0, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x8F,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x08, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF8, 0x01, 0xF0,
  0x7F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0x9F, 0x07, 0x80, 0xF3, 0xF9, 0xFC, 0x0F,
  0x7F, 0xBF, 0xE0, 0xF7, 0xFB, 0xFE, 0x1F, 0x8F, 0xE3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE1,
  0xF0, 0x78, 0x3E, 0x3E, 0x07, 0x83, 0xE3, 0xE0, 0xF0, 0x3C, 0x3E, 0x0F,
  0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x3C, 0x0F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1E, 0x07, 0x87, 0xC1,
  0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x78, 0x1E, 0x0F,
  0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3C, 0x0F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xFE,
  0x03, 0xE7, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x07, 0xE1, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x7C, 0xFF, 0xF0, 0x1F,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0x83, 0xF8, 0x07, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xBF,
  0xFE, 0x07, 0xEF, 0xFF, 0x01, 0xF0, 0xFF, 0x00, 0x7C, 0x04, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7, 0xE0,
  0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFE, 0xF8, 0x3F, 0xFF, 0x7C, 0x0F,
  0xFF, 0x7E, 0x01, 0xFE, 0x3F, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x83,
  0xF0, 0x03, 0xE3, 0xFF, 0x00, 0xF9, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0,
  0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xF7,
  0x81, 0xF0, 0x1E, 0x78, 0x1F, 0x01, 0xE7, 0x81, 0xF0, 0x3E, 0x78, 0x1F,
  0x03, 0xC7, 0x83, 0xF0, 0x3C, 0x78, 0x3F, 0x03, 0xC7, 0x83, 0xF0, 0x7C,
  0x78, 0x77, 0x07, 0x8F, 0x87, 0x70, 0x78, 0xF8, 0x77, 0x0F, 0x8F, 0x8E,
  0x70, 0xF0, 0xF8, 0xE7, 0x0F, 0x0F, 0x8E, 0x71, 0xF0, 0xF9, 0xC7, 0x1E,
  0x0F, 0x9C, 0x71, 0xE0, 0xF9, 0xC7, 0x3E, 0x0F, 0xB8, 0x73, 0xC0, 0xFB,
  0x87, 0x3C, 0x0F, 0xB8, 0x73, 0xC0, 0xFF, 0x87, 0x78, 0x0F, 0xF0, 0x77,
  0x80, 0xFF, 0x07, 0x78, 0x0F, 0x70, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFB, 0xE0, 0x7F, 0xFD, 0xF0, 0x1F, 0xF8, 0xF8, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF9, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0x8F, 0xFC, 0x03, 0xCF, 0xFF, 0x03, 0xEF, 0xFF, 0x81, 0xF7, 0xC7,
  0xE0, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0xFE, 0xFD, 0xF0, 0x3F, 0xFE, 0xF8,
  0x0F, 0xFE, 0x7C, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 13, 37, 30, 9, -37 },
  { 62, 18, 16, 30, 9, -37 },
  { 98, 30, 37, 30, 1, -37 },
  { 237, 27, 51, 30, 2, -44 },
  { 410, 35, 37, 30, -2, -37 },
  { 572, 28, 38, 30, 1, -37 },
  { 705, 7, 16, 30, 14, -37 },
  { 719, 22, 48, 30, 7, -42 },
  { 851, 20, 48, 30, 3, -42 },
  { 971, 27, 27, 30, 2, -31 },
  { 1063, 25, 23, 30, 3, -28 },
  { 1135, 14, 16, 30, 4, -8 },
  { 1163, 17, 5, 30, 7, -19 },
  { 1174, 9, 9, 30, 9, -8 },
  { 1185, 31, 48, 30, 0, -42 },
  { 1371, 26, 38, 30, 3, -37 },
  { 1495, 24, 37, 30, 2, -37 },
  { 1606, 27, 37, 30, 2, -37 },
  { 1731, 26, 38, 30, 2, -37 },
  { 1855, 25, 37, 30, 3, -37 },
  { 1971, 25, 38, 30, 3, -37 },
  { 2090, 25, 38, 30, 2, -37 },
  { 2209, 26, 37, 30, 5, -37 },
  { 2330, 26, 38, 30, 2, -37 },
  { 2454, 25, 37, 30, 4, -37 },
  { 2570, 12, 29, 30, 9, -28 },
  { 2614, 16, 36, 30, 5, -28 },
  { 2686, 25, 27, 30, 4, -30 },
  { 2771, 25, 17, 30, 3, -25 },
  { 2825, 25, 27, 30, 2, -30 },
  { 2910, 21, 37, 30, 7, -37 },
  { 3008, 31, 46, 30, 0, -37 },
  { 3187, 26, 37, 30, 0, -37 },
  { 3308, 27, 37, 30, 2, -37 },
  { 3433, 26, 38, 30, 3, -37 },
  { 3557, 27, 37, 30, 2, -37 },
  { 3682, 28, 37, 30, 2, -37 },
  { 3812, 28, 37, 30, 2, -37 },
  { 3942, 26, 38, 30, 3, -37 },
  { 4066, 27, 37, 30, 2, -37 },
  { 4191, 26, 37, 30, 3, -37 },
  { 4312, 28, 38, 30, 1, -37 },
  { 4445, 29, 37, 30, 2, -37 },
  { 4580, 22, 37, 30, 3, -37 },
  { 4682, 29, 37, 30, 1, -37 },
  { 4817, 28, 37, 30, 2, -37 },
  { 4947, 26, 38, 30, 3, -37 },
  { 5071, 28, 37, 30, 2, -37 },
  { 5201, 26, 46, 30, 3, -37 },
  { 5351, 27, 37, 30, 2, -37 },
  { 5476, 27, 38, 30, 2, -37 },
  { 5605, 26, 37, 30, 5, -37 },
  { 5726, 27, 38, 30, 3, -37 },
  { 5855, 25, 37, 30, 6, -37 },
  { 5971, 30, 37, 30, 3, -37 },
  { 6110, 32, 37, 30, -1, -37 },
  { 6258, 27, 37, 30, 5, -37 },
  { 6383, 27, 37, 30, 2, -37 },
  { 6508, 20, 48, 30, 7, -42 },
  { 6628, 16, 48, 30, 8, -42 },
  { 6724, 21, 48, 30, 4, -42 },
  { 6850, 23, 20, 30, 4, -37 },
  { 6908, 25, 5, 30, 0, 1 },
  { 6924, 10, 7, 30, 13, -39 },
  { 6933, 25, 29, 30, 3, -28 },
  { 7024, 25, 38, 30, 2, -37 },
  { 7143, 25, 29, 30, 3, -28 },
  { 7234, 26, 38, 30, 3, -37 },
  { 7358, 24, 29, 30, 3, -28 },
  { 7445, 35, 46, 30, -3, -37 },
  { 7647, 25, 37, 30, 3, -28 },
  { 7763, 25, 37, 30, 2, -37 },
  { 7879, 24, 39, 30, 2, -39 },
  { 7996, 26, 48, 30, 1, -39 },
  { 8152, 28, 37, 30, 2, -37 },
  { 8282, 21, 37, 30, 5, -37 },
  { 8380, 28, 28, 30, 1, -28 },
  { 8478, 25, 28, 30, 2, -28 },
  { 8566, 24, 29, 30, 3, -28 },
  { 8653, 26, 37, 30, 1, -28 },
  { 8774, 25, 37, 30, 3, -28 },
  { 8890, 26, 28, 30, 3, -28 },
  { 8981, 25, 29, 30, 2, -28 },
  { 9072, 24, 35, 30, 4, -35 },
  { 9177, 25, 29, 30, 3, -28 },
  { 9268, 25, 28, 30, 5, -28 },
  { 9356, 28, 28, 30, 3, -28 },
  { 9454, 29, 28, 30, 0, -28 },
  { 9556, 25, 37, 30, 3, -28 },
  { 9672, 25, 28, 30, 2, -28 },
  { 9760, 26, 48, 30, 4, -42 },
  { 9916, 13, 48, 30, 9, -42 },
  { 9994, 26, 48, 30, 1, -42 },
  { 10150, 25, 11, 30, 3, -23 },
};

const GFXfont JetBrainsMono_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_MEDIUMITALIC50PT7B_H_
