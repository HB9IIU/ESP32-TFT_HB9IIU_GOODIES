#ifndef _JETBRAINSMONO_MEDIUMITALIC18PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x18, 0x84, 0x20, 0x01, 0xCE, 0x00, 0x6E, 0xDB,
  0x36, 0x6C, 0xC0, 0x06, 0x60, 0x88, 0x33, 0x1F, 0xF3, 0xFE, 0x33, 0x04,
  0x41, 0x88, 0xFF, 0xDF, 0xF1, 0x88, 0x33, 0x04, 0x40, 0x02, 0x03, 0x01,
  0x03, 0xE3, 0xFB, 0x2D, 0x90, 0xD8, 0x38, 0x1F, 0x83, 0xC1, 0x60, 0xB6,
  0xDB, 0xFC, 0xF8, 0x10, 0x08, 0x04, 0x00, 0x1E, 0x19, 0x91, 0x8C, 0x98,
  0x45, 0x83, 0xE8, 0x0E, 0x80, 0x08, 0x00, 0xFC, 0x0D, 0x20, 0xD9, 0x0C,
  0xC8, 0x46, 0xCC, 0x3C, 0x00, 0x0F, 0x86, 0x61, 0x18, 0x40, 0x18, 0x06,
  0x07, 0xC1, 0xB3, 0x67, 0x99, 0xC4, 0x31, 0xBE, 0x7D, 0x80, 0x7B, 0x6C,
  0x06, 0x1C, 0x61, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x18, 0x3C, 0x18, 0x10, 0x78, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x60, 0xC3, 0x0E, 0x78, 0xC0, 0x0C, 0x03, 0x08, 0xC7, 0xAE, 0x7F,
  0x47, 0x03, 0x41, 0x98, 0x67, 0x00, 0x0C, 0x06, 0x03, 0x1F, 0xFF, 0xF8,
  0xC0, 0x60, 0x30, 0x3B, 0x98, 0xCC, 0x60, 0x7F, 0xF8, 0x6E, 0xE0, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x00, 0x1F,
  0x1D, 0xD8, 0x6C, 0x36, 0x1B, 0x4D, 0x77, 0x93, 0xC1, 0x61, 0xB0, 0xDF,
  0xC7, 0xC0, 0x0E, 0x3E, 0x76, 0x46, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0xFF, 0xFF, 0x1F, 0x1D, 0xD8, 0x6C, 0x30, 0x18, 0x18, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x1F, 0xEF, 0xF0, 0x3F, 0x9F, 0xC0, 0xC0, 0xC1, 0xC0,
  0xF0, 0x1C, 0x06, 0x03, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x03, 0x83, 0x83,
  0x81, 0x81, 0x81, 0x8D, 0x8D, 0x86, 0xC3, 0x7F, 0x80, 0xC0, 0x60, 0x60,
  0x3F, 0x9F, 0xC8, 0x0C, 0x06, 0xE3, 0xF9, 0x8C, 0x06, 0x03, 0x01, 0xB0,
  0xDF, 0xC7, 0xC0, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x79, 0xDD, 0x83,
  0xC1, 0xE0, 0xB0, 0xDF, 0xC7, 0xC0, 0xFF, 0xFF, 0xF0, 0xD8, 0x60, 0x60,
  0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x00, 0x1F, 0x1D, 0xD8,
  0x6C, 0x37, 0x31, 0xF0, 0x78, 0xC6, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0,
  0x3E, 0x3B, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0xF8, 0xEC, 0x0C, 0x0C, 0x0C,
  0x06, 0x0E, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x18, 0xF1,
  0x80, 0x00, 0x00, 0x0E, 0x31, 0x86, 0x30, 0xC0, 0x00, 0x81, 0xC3, 0xC7,
  0x87, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x80, 0x7F, 0xBF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF8, 0x40, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x18, 0x38, 0xF0,
  0xE0, 0x40, 0x00, 0x7C, 0x7E, 0x03, 0x03, 0x06, 0x0E, 0x3C, 0x30, 0x20,
  0x40, 0x00, 0x60, 0xE0, 0x0F, 0xC3, 0x1C, 0xC1, 0x90, 0x36, 0x36, 0xCD,
  0xDB, 0x12, 0x62, 0x4C, 0xD9, 0x9B, 0x33, 0x67, 0xEC, 0x01, 0x80, 0x1C,
  0x01, 0xE0, 0x07, 0x03, 0x83, 0x41, 0xA0, 0x90, 0xCC, 0x66, 0x63, 0x3F,
  0xBF, 0xD8, 0x6C, 0x3C, 0x18, 0x3F, 0x1F, 0xD8, 0x6C, 0x36, 0x1B, 0xF9,
  0xFC, 0x86, 0xC1, 0xE0, 0xB0, 0xDF, 0xCF, 0xC0, 0x1F, 0x1D, 0xD8, 0x6C,
  0x36, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x3F,
  0x1F, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0xC3, 0x61, 0xB0, 0xDF,
  0xCF, 0xC0, 0x3F, 0xCF, 0xE2, 0x01, 0x80, 0x60, 0x1F, 0xC7, 0xF1, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF6, 0x01, 0x80,
  0x60, 0x18, 0x07, 0xF1, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x1F, 0x1D, 0xD8, 0x6C, 0x36, 0x03, 0x01, 0xBE, 0x9F, 0xC3, 0x61, 0xB0,
  0xDF, 0xC7, 0xC0, 0x30, 0xCC, 0x66, 0x19, 0x86, 0x61, 0x9F, 0xE7, 0xF9,
  0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x00, 0x3F, 0x9F, 0xC3, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x1F, 0xEF, 0xE0, 0x07,
  0xC1, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0xB0, 0x6E,
  0x31, 0xFC, 0x3E, 0x00, 0x30, 0xC8, 0x66, 0x39, 0x8C, 0x66, 0x1F, 0x87,
  0xC1, 0x98, 0xC6, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0x00, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xFF, 0xFF, 0x38, 0xE7,
  0x1C, 0xE7, 0x14, 0xA2, 0xF4, 0x5D, 0x9B, 0xB3, 0x06, 0x60, 0xCC, 0x11,
  0x86, 0x20, 0xCC, 0x18, 0x30, 0xDE, 0x27, 0x99, 0xE6, 0x79, 0x9A, 0x66,
  0x99, 0x34, 0xCD, 0x33, 0xCC, 0x73, 0x1C, 0xC7, 0x00, 0x1F, 0x1D, 0xD8,
  0x6C, 0x36, 0x1B, 0x0D, 0x86, 0x82, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0,
  0x3F, 0x0F, 0xE6, 0x0D, 0x83, 0x61, 0xD8, 0x67, 0xF1, 0xF8, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x1D, 0xD8, 0x6C, 0x36, 0x1B, 0x0D,
  0x87, 0x83, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x60, 0x30, 0x0C, 0x3F,
  0x0F, 0xE6, 0x19, 0x86, 0x61, 0x98, 0xE7, 0xF1, 0xF0, 0xC6, 0x31, 0x8C,
  0x63, 0x0C, 0xC3, 0x00, 0x1F, 0x1D, 0xD8, 0x6C, 0x06, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x01, 0xB0, 0xDF, 0xE7, 0xC0, 0xFF, 0xFF, 0xC6, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x30, 0xD8,
  0x66, 0x19, 0x86, 0x61, 0x98, 0x66, 0x19, 0x0C, 0xC3, 0x30, 0xCC, 0x33,
  0xF8, 0x7C, 0x00, 0xC1, 0xE0, 0xF0, 0xD8, 0x64, 0x62, 0x31, 0x98, 0xD8,
  0x6C, 0x34, 0x1E, 0x0F, 0x07, 0x00, 0x46, 0x69, 0xC9, 0x3B, 0x66, 0x6D,
  0xC9, 0xA9, 0x35, 0x66, 0xAC, 0xF5, 0x1C, 0xA3, 0x9C, 0x73, 0x8C, 0x60,
  0x30, 0x63, 0x18, 0x66, 0x06, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1B,
  0x06, 0x60, 0xCC, 0x30, 0xCC, 0x18, 0xC1, 0xF0, 0xE6, 0x31, 0x98, 0x66,
  0x0F, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3F,
  0x9F, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x38, 0x1F,
  0xEF, 0xF0, 0x1F, 0x1F, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x78, 0xF8, 0xC6, 0x30, 0x86, 0x31, 0x8C,
  0x31, 0x8C, 0x61, 0x0C, 0x63, 0x18, 0x1F, 0x1F, 0x02, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x78, 0xF8, 0x1C,
  0x14, 0x34, 0x26, 0x66, 0xC2, 0xC3, 0xFF, 0xFF, 0xC0, 0xCC, 0x1D, 0x9F,
  0xD8, 0xEC, 0x34, 0x36, 0x1B, 0x0D, 0x86, 0xFF, 0x3D, 0x80, 0x30, 0x10,
  0x18, 0x0D, 0xE7, 0xF3, 0x0D, 0x86, 0xC6, 0xC3, 0x61, 0xB0, 0xDF, 0xCF,
  0xC0, 0x1F, 0x1F, 0x98, 0x6C, 0x04, 0x06, 0x03, 0x01, 0x86, 0xFE, 0x3E,
  0x00, 0x00, 0xC0, 0x60, 0x18, 0x76, 0x3F, 0x98, 0xE6, 0x19, 0x0C, 0xC3,
  0x30, 0xCC, 0x33, 0xFC, 0x7B, 0x00, 0x1E, 0x1F, 0x98, 0x6C, 0x37, 0xF7,
  0xFB, 0x01, 0x86, 0xE6, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0x00, 0x20,
  0x1F, 0xE3, 0xFE, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0x1D, 0x9F, 0xD8, 0xEC, 0x34, 0x36,
  0x1B, 0x0D, 0xCE, 0x7B, 0x01, 0x81, 0x81, 0xC7, 0xC0, 0x30, 0x10, 0x18,
  0x0D, 0xE7, 0xF3, 0x0D, 0x86, 0xC6, 0xC3, 0x61, 0xB0, 0xD8, 0x6C, 0x30,
  0x06, 0x06, 0x00, 0x00, 0x3E, 0x7C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x63, 0xF0, 0xF8, 0x00,
  0x30, 0x0C, 0x06, 0x01, 0x87, 0x63, 0x98, 0xC6, 0x61, 0xF0, 0xFC, 0x33,
  0x8C, 0x63, 0x1C, 0xC3, 0x00, 0xF9, 0xF0, 0x41, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0xC1, 0x83, 0xF3, 0xE0, 0x2D, 0xCD, 0xB6, 0x6D, 0x93, 0x64, 0xD9,
  0x36, 0xCD, 0x32, 0x4D, 0xB2, 0x60, 0x6F, 0x3F, 0x98, 0x6C, 0x36, 0x36,
  0x1B, 0x0D, 0x86, 0xC3, 0x61, 0x80, 0x1E, 0x1F, 0x98, 0x6C, 0x34, 0x36,
  0x1B, 0x0D, 0x86, 0xFE, 0x3E, 0x00, 0x37, 0x8F, 0xE3, 0x0C, 0xC3, 0x31,
  0x98, 0x66, 0x19, 0x86, 0x7F, 0x1F, 0x86, 0x03, 0x00, 0xC0, 0x00, 0x3D,
  0xBF, 0xD8, 0xEC, 0x34, 0x36, 0x1B, 0x0D, 0x86, 0xFF, 0x3D, 0x81, 0x80,
  0xC0, 0x60, 0x2F, 0x3F, 0xD8, 0x6C, 0x36, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x00, 0x3F, 0x3F, 0xD8, 0x6C, 0x07, 0xC0, 0xF8, 0x0D, 0x86, 0xE7,
  0x3F, 0x00, 0x0C, 0x06, 0x06, 0x0F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x07, 0xE1, 0xF0, 0x61, 0xB0, 0xD8, 0x6C, 0x36, 0x36, 0x1B,
  0x0D, 0x86, 0xFE, 0x3E, 0x00, 0xC3, 0xE1, 0xB0, 0xD8, 0xCC, 0x62, 0x61,
  0xB0, 0xF0, 0x78, 0x38, 0x00, 0xCC, 0xF3, 0x3C, 0xCB, 0x56, 0xD5, 0xB5,
  0x4E, 0x53, 0x9C, 0xE6, 0x31, 0x80, 0x30, 0xE3, 0x30, 0x6E, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x81, 0x98, 0x63, 0x1C, 0x30, 0x61, 0xB0, 0xD8, 0x6C,
  0x34, 0x36, 0x1B, 0x0D, 0xCE, 0x7B, 0x01, 0x81, 0x81, 0xCF, 0xC0, 0x7F,
  0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x7F, 0x80, 0x03,
  0x83, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0xF0, 0x1C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x7C, 0x1C, 0x00, 0x18, 0xC6, 0x63, 0x18, 0xC6,
  0x31, 0x18, 0xC6, 0x31, 0x8C, 0xC0, 0x1C, 0x07, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x38, 0x03, 0xC3, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x81, 0xE0, 0xE0, 0x00, 0x79, 0xEE, 0xF3, 0xE0, 0xC0,
};

const GFXglyph JetBrainsMono_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 7, 5, 11, 3, -13 },
  { 15, 11, 13, 11, 0, -13 },
  { 33, 9, 19, 11, 1, -16 },
  { 55, 13, 13, 11, -1, -13 },
  { 77, 10, 13, 11, 0, -13 },
  { 94, 3, 5, 11, 5, -13 },
  { 96, 7, 17, 11, 3, -15 },
  { 111, 7, 17, 11, 1, -15 },
  { 126, 10, 9, 11, 1, -11 },
  { 138, 9, 8, 11, 1, -10 },
  { 147, 5, 6, 11, 2, -3 },
  { 151, 7, 2, 11, 2, -7 },
  { 153, 4, 3, 11, 3, -3 },
  { 155, 11, 17, 11, 0, -15 },
  { 179, 9, 13, 11, 1, -13 },
  { 194, 8, 13, 11, 1, -13 },
  { 207, 9, 13, 11, 1, -13 },
  { 222, 9, 13, 11, 1, -13 },
  { 237, 9, 13, 11, 1, -13 },
  { 252, 9, 13, 11, 1, -13 },
  { 267, 9, 13, 11, 1, -13 },
  { 282, 9, 13, 11, 2, -13 },
  { 297, 9, 13, 11, 1, -13 },
  { 312, 9, 13, 11, 2, -13 },
  { 327, 5, 10, 11, 3, -10 },
  { 334, 6, 13, 11, 2, -10 },
  { 344, 9, 10, 11, 1, -11 },
  { 356, 9, 6, 11, 1, -9 },
  { 363, 9, 10, 11, 1, -11 },
  { 375, 8, 13, 11, 2, -13 },
  { 388, 11, 16, 11, 0, -13 },
  { 410, 9, 13, 11, 0, -13 },
  { 425, 9, 13, 11, 1, -13 },
  { 440, 9, 13, 11, 1, -13 },
  { 455, 9, 13, 11, 1, -13 },
  { 470, 10, 13, 11, 1, -13 },
  { 487, 10, 13, 11, 1, -13 },
  { 504, 9, 13, 11, 1, -13 },
  { 519, 10, 13, 11, 1, -13 },
  { 536, 9, 13, 11, 1, -13 },
  { 551, 10, 13, 11, 0, -13 },
  { 568, 10, 13, 11, 1, -13 },
  { 585, 8, 13, 11, 1, -13 },
  { 598, 11, 13, 11, 0, -13 },
  { 616, 10, 13, 11, 1, -13 },
  { 633, 9, 13, 11, 1, -13 },
  { 648, 10, 13, 11, 1, -13 },
  { 665, 9, 16, 11, 1, -13 },
  { 683, 10, 13, 11, 1, -13 },
  { 700, 9, 13, 11, 1, -13 },
  { 715, 9, 13, 11, 2, -13 },
  { 730, 10, 13, 11, 1, -13 },
  { 747, 9, 13, 11, 2, -13 },
  { 762, 11, 13, 11, 1, -13 },
  { 780, 11, 13, 11, 0, -13 },
  { 798, 10, 13, 11, 2, -13 },
  { 815, 9, 13, 11, 1, -13 },
  { 830, 8, 17, 11, 2, -15 },
  { 847, 5, 17, 11, 3, -15 },
  { 858, 8, 17, 11, 1, -15 },
  { 875, 8, 7, 11, 2, -13 },
  { 882, 9, 2, 11, 0, 0 },
  { 885, 3, 2, 11, 5, -14 },
  { 886, 9, 10, 11, 1, -10 },
  { 898, 9, 13, 11, 1, -13 },
  { 913, 9, 10, 11, 1, -10 },
  { 925, 10, 13, 11, 1, -13 },
  { 942, 9, 10, 11, 1, -10 },
  { 954, 12, 16, 11, -1, -13 },
  { 978, 9, 13, 11, 1, -10 },
  { 993, 9, 13, 11, 1, -13 },
  { 1008, 8, 14, 11, 1, -14 },
  { 1022, 10, 17, 11, 0, -14 },
  { 1044, 10, 13, 11, 1, -13 },
  { 1061, 7, 13, 11, 2, -13 },
  { 1073, 10, 10, 11, 0, -10 },
  { 1086, 9, 10, 11, 1, -10 },
  { 1098, 9, 10, 11, 1, -10 },
  { 1110, 10, 13, 11, 0, -10 },
  { 1127, 9, 13, 11, 1, -10 },
  { 1142, 9, 10, 11, 1, -10 },
  { 1154, 9, 10, 11, 1, -10 },
  { 1166, 9, 13, 11, 1, -13 },
  { 1181, 9, 10, 11, 1, -10 },
  { 1193, 9, 10, 11, 2, -10 },
  { 1205, 10, 10, 11, 1, -10 },
  { 1218, 11, 10, 11, 0, -10 },
  { 1232, 9, 13, 11, 1, -10 },
  { 1247, 9, 10, 11, 1, -10 },
  { 1259, 9, 17, 11, 2, -15 },
  { 1279, 5, 17, 11, 3, -15 },
  { 1290, 10, 17, 11, 0, -15 },
  { 1312, 9, 4, 11, 1, -8 },
};

const GFXfont JetBrainsMono_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_MEDIUMITALIC18PT7B_H_
