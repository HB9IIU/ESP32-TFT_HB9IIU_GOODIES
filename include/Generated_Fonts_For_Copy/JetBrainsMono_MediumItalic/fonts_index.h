#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &JetBrainsMono_MediumItalic6pt7b, 6, "JetBrainsMono_MediumItalic6pt7b" },
  { &JetBrainsMono_MediumItalic7pt7b, 7, "JetBrainsMono_MediumItalic7pt7b" },
  { &JetBrainsMono_MediumItalic8pt7b, 8, "JetBrainsMono_MediumItalic8pt7b" },
  { &JetBrainsMono_MediumItalic9pt7b, 9, "JetBrainsMono_MediumItalic9pt7b" },
  { &JetBrainsMono_MediumItalic10pt7b, 10, "JetBrainsMono_MediumItalic10pt7b" },
  { &JetBrainsMono_MediumItalic11pt7b, 11, "JetBrainsMono_MediumItalic11pt7b" },
  { &JetBrainsMono_MediumItalic12pt7b, 12, "JetBrainsMono_MediumItalic12pt7b" },
  { &JetBrainsMono_MediumItalic13pt7b, 13, "JetBrainsMono_MediumItalic13pt7b" },
  { &JetBrainsMono_MediumItalic14pt7b, 14, "JetBrainsMono_MediumItalic14pt7b" },
  { &JetBrainsMono_MediumItalic15pt7b, 15, "JetBrainsMono_MediumItalic15pt7b" },
  { &JetBrainsMono_MediumItalic16pt7b, 16, "JetBrainsMono_MediumItalic16pt7b" },
  { &JetBrainsMono_MediumItalic17pt7b, 17, "JetBrainsMono_MediumItalic17pt7b" },
  { &JetBrainsMono_MediumItalic18pt7b, 18, "JetBrainsMono_MediumItalic18pt7b" },
  { &JetBrainsMono_MediumItalic19pt7b, 19, "JetBrainsMono_MediumItalic19pt7b" },
  { &JetBrainsMono_MediumItalic20pt7b, 20, "JetBrainsMono_MediumItalic20pt7b" },
  { &JetBrainsMono_MediumItalic21pt7b, 21, "JetBrainsMono_MediumItalic21pt7b" },
  { &JetBrainsMono_MediumItalic22pt7b, 22, "JetBrainsMono_MediumItalic22pt7b" },
  { &JetBrainsMono_MediumItalic23pt7b, 23, "JetBrainsMono_MediumItalic23pt7b" },
  { &JetBrainsMono_MediumItalic24pt7b, 24, "JetBrainsMono_MediumItalic24pt7b" },
  { &JetBrainsMono_MediumItalic25pt7b, 25, "JetBrainsMono_MediumItalic25pt7b" },
  { &JetBrainsMono_MediumItalic26pt7b, 26, "JetBrainsMono_MediumItalic26pt7b" },
  { &JetBrainsMono_MediumItalic27pt7b, 27, "JetBrainsMono_MediumItalic27pt7b" },
  { &JetBrainsMono_MediumItalic28pt7b, 28, "JetBrainsMono_MediumItalic28pt7b" },
  { &JetBrainsMono_MediumItalic29pt7b, 29, "JetBrainsMono_MediumItalic29pt7b" },
  { &JetBrainsMono_MediumItalic30pt7b, 30, "JetBrainsMono_MediumItalic30pt7b" },
  { &JetBrainsMono_MediumItalic31pt7b, 31, "JetBrainsMono_MediumItalic31pt7b" },
  { &JetBrainsMono_MediumItalic32pt7b, 32, "JetBrainsMono_MediumItalic32pt7b" },
  { &JetBrainsMono_MediumItalic33pt7b, 33, "JetBrainsMono_MediumItalic33pt7b" },
  { &JetBrainsMono_MediumItalic34pt7b, 34, "JetBrainsMono_MediumItalic34pt7b" },
  { &JetBrainsMono_MediumItalic35pt7b, 35, "JetBrainsMono_MediumItalic35pt7b" },
  { &JetBrainsMono_MediumItalic36pt7b, 36, "JetBrainsMono_MediumItalic36pt7b" },
  { &JetBrainsMono_MediumItalic37pt7b, 37, "JetBrainsMono_MediumItalic37pt7b" },
  { &JetBrainsMono_MediumItalic38pt7b, 38, "JetBrainsMono_MediumItalic38pt7b" },
  { &JetBrainsMono_MediumItalic39pt7b, 39, "JetBrainsMono_MediumItalic39pt7b" },
  { &JetBrainsMono_MediumItalic40pt7b, 40, "JetBrainsMono_MediumItalic40pt7b" },
  { &JetBrainsMono_MediumItalic41pt7b, 41, "JetBrainsMono_MediumItalic41pt7b" },
  { &JetBrainsMono_MediumItalic42pt7b, 42, "JetBrainsMono_MediumItalic42pt7b" },
  { &JetBrainsMono_MediumItalic43pt7b, 43, "JetBrainsMono_MediumItalic43pt7b" },
  { &JetBrainsMono_MediumItalic44pt7b, 44, "JetBrainsMono_MediumItalic44pt7b" },
  { &JetBrainsMono_MediumItalic45pt7b, 45, "JetBrainsMono_MediumItalic45pt7b" },
  { &JetBrainsMono_MediumItalic46pt7b, 46, "JetBrainsMono_MediumItalic46pt7b" },
  { &JetBrainsMono_MediumItalic47pt7b, 47, "JetBrainsMono_MediumItalic47pt7b" },
  { &JetBrainsMono_MediumItalic48pt7b, 48, "JetBrainsMono_MediumItalic48pt7b" },
  { &JetBrainsMono_MediumItalic49pt7b, 49, "JetBrainsMono_MediumItalic49pt7b" },
  { &JetBrainsMono_MediumItalic50pt7b, 50, "JetBrainsMono_MediumItalic50pt7b" },
  { &JetBrainsMono_MediumItalic51pt7b, 51, "JetBrainsMono_MediumItalic51pt7b" },
  { &JetBrainsMono_MediumItalic52pt7b, 52, "JetBrainsMono_MediumItalic52pt7b" },
  { &JetBrainsMono_MediumItalic53pt7b, 53, "JetBrainsMono_MediumItalic53pt7b" },
  { &JetBrainsMono_MediumItalic54pt7b, 54, "JetBrainsMono_MediumItalic54pt7b" },
  { &JetBrainsMono_MediumItalic55pt7b, 55, "JetBrainsMono_MediumItalic55pt7b" },
  { &JetBrainsMono_MediumItalic56pt7b, 56, "JetBrainsMono_MediumItalic56pt7b" },
  { &JetBrainsMono_MediumItalic57pt7b, 57, "JetBrainsMono_MediumItalic57pt7b" },
  { &JetBrainsMono_MediumItalic58pt7b, 58, "JetBrainsMono_MediumItalic58pt7b" },
  { &JetBrainsMono_MediumItalic59pt7b, 59, "JetBrainsMono_MediumItalic59pt7b" },
  { &JetBrainsMono_MediumItalic60pt7b, 60, "JetBrainsMono_MediumItalic60pt7b" },
  { &JetBrainsMono_MediumItalic61pt7b, 61, "JetBrainsMono_MediumItalic61pt7b" },
  { &JetBrainsMono_MediumItalic62pt7b, 62, "JetBrainsMono_MediumItalic62pt7b" },
  { &JetBrainsMono_MediumItalic63pt7b, 63, "JetBrainsMono_MediumItalic63pt7b" },
  { &JetBrainsMono_MediumItalic64pt7b, 64, "JetBrainsMono_MediumItalic64pt7b" },
  { &JetBrainsMono_MediumItalic65pt7b, 65, "JetBrainsMono_MediumItalic65pt7b" },
  { &JetBrainsMono_MediumItalic66pt7b, 66, "JetBrainsMono_MediumItalic66pt7b" },
  { &JetBrainsMono_MediumItalic67pt7b, 67, "JetBrainsMono_MediumItalic67pt7b" },
  { &JetBrainsMono_MediumItalic68pt7b, 68, "JetBrainsMono_MediumItalic68pt7b" },
  { &JetBrainsMono_MediumItalic69pt7b, 69, "JetBrainsMono_MediumItalic69pt7b" },
  { &JetBrainsMono_MediumItalic70pt7b, 70, "JetBrainsMono_MediumItalic70pt7b" },
  { &JetBrainsMono_MediumItalic71pt7b, 71, "JetBrainsMono_MediumItalic71pt7b" },
  { &JetBrainsMono_MediumItalic72pt7b, 72, "JetBrainsMono_MediumItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
