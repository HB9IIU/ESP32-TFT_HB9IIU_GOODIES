#ifndef _JETBRAINSMONO_MEDIUMITALIC36PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x7C, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF0, 0xF7, 0x8F, 0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xF7, 0x87, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x0C, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x07, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x99, 0xE0, 0xF1, 0x9E, 0x0F,
  0x38, 0xF1, 0xE3, 0x80, 0x1E, 0x30, 0x01, 0xF3, 0x00, 0x1F, 0x30, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x6F, 0xC0, 0x06, 0x7C, 0x00, 0x63, 0xC0, 0x0E, 0x3C, 0x78, 0xC3,
  0xC7, 0x8C, 0x78, 0x78, 0xC7, 0x87, 0xED, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x07, 0x83, 0xFC, 0x07, 0x83, 0x8F,
  0x03, 0x81, 0xC3, 0x83, 0x81, 0xC1, 0xC3, 0x80, 0xE1, 0xC3, 0x80, 0x70,
  0xE3, 0x80, 0x38, 0x73, 0x80, 0x1C, 0x7B, 0xC0, 0x0F, 0xF9, 0xC0, 0x03,
  0xF9, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0xEF, 0xF0, 0x00, 0xEF, 0xF8, 0x00, 0xE7, 0x0E,
  0x00, 0xE7, 0x07, 0x00, 0xE3, 0x83, 0x80, 0xE1, 0xC3, 0x80, 0xE0, 0xE1,
  0xC0, 0x70, 0x70, 0xE0, 0x70, 0x3D, 0xE0, 0x70, 0x0F, 0xF0, 0x70, 0x03,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x3D, 0xE0, 0xF7, 0x9F, 0x1E, 0x78, 0xF3, 0xC7, 0x07, 0xB8, 0x70,
  0x7F, 0x8F, 0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F,
  0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFE, 0x78, 0x3F, 0x83, 0xC0, 0x7B, 0xDE,
  0xFF, 0xFB, 0xDE, 0xF7, 0x38, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x20, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xC1, 0x9E,
  0x38, 0xFF, 0xF7, 0x7F, 0xFF, 0x5F, 0xC3, 0xFF, 0xC0, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x7C,
  0x1E, 0x07, 0x03, 0x80, 0x40, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x07, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC3,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1C, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C, 0x07,
  0x8F, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xE0, 0x0F,
  0x1C, 0x21, 0xE7, 0x9E, 0x3C, 0xF3, 0xE7, 0x1E, 0x78, 0xE3, 0xC7, 0x3C,
  0x70, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71,
  0xE0, 0x1E, 0x3C, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xF3, 0xC0, 0xF1, 0xE0, 0x60, 0xF0, 0x60, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x83, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83, 0xE0,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1E, 0x1E, 0x07, 0x8F,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x70, 0x0F, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x3F, 0x83, 0xDF, 0xF0, 0xFF, 0xFC, 0x3E, 0x0F, 0x8F, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xEF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x83, 0xE7,
  0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0xC3, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x81,
  0xE1, 0xE0, 0xF8, 0x3E, 0x7C, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x7C, 0xF8, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3E, 0x07, 0x8F, 0x01, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0x9F, 0x0F, 0xC7, 0xFF,
  0xF0, 0xFF, 0x78, 0x0F, 0xBC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x7F,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x20, 0x00, 0x0C, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xC1,
  0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC,
  0x7E, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1C, 0x00, 0x3C, 0x70, 0x08, 0xF3, 0xC1, 0xFB, 0x8F, 0x0F, 0xFE, 0x38,
  0x78, 0x78, 0xE1, 0xE1, 0xE3, 0x87, 0x07, 0x8E, 0x1C, 0x1E, 0x78, 0xF0,
  0x71, 0xE3, 0xC1, 0xC7, 0x0F, 0x07, 0x1C, 0x38, 0x1C, 0x70, 0xE0, 0xF1,
  0xC3, 0xC3, 0xC7, 0x0F, 0xFF, 0x3C, 0x1F, 0xF8, 0xF0, 0x3C, 0xE3, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xE0, 0x0F,
  0x78, 0x03, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x0E,
  0x03, 0x83, 0x81, 0xE0, 0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x70, 0x07, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x81,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0x87, 0x80, 0xF8, 0x78, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0,
  0x7C, 0x3C, 0x07, 0x87, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x4F, 0x00, 0xF1, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xF0, 0x7E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0x79, 0xE0,
  0x1E, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0xFF, 0x9E, 0x1F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3E, 0x07,
  0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80,
  0x78, 0x3C, 0x07, 0xC1, 0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x3C, 0x03, 0xC0, 0xF0, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x83,
  0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83,
  0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xD8, 0x3F, 0x0E, 0xE3, 0xB8, 0x77,
  0x1D, 0xC3, 0xB9, 0xDE, 0x1D, 0xCE, 0xE1, 0xEE, 0xE7, 0x0F, 0x37, 0x38,
  0x79, 0xB3, 0xC3, 0x8F, 0x9E, 0x1C, 0x78, 0xF0, 0xE3, 0xC7, 0x0F, 0x00,
  0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x00, 0x0F, 0xC0, 0x70, 0xFC, 0x0F, 0x0F, 0xC0, 0xF0,
  0xFC, 0x0F, 0x0F, 0xC0, 0xF0, 0xFC, 0x0E, 0x1F, 0xE0, 0xE1, 0xEE, 0x1E,
  0x1E, 0xE1, 0xE1, 0xEE, 0x1E, 0x1C, 0xE1, 0xE1, 0xCF, 0x1C, 0x3C, 0x71,
  0xC3, 0xC7, 0x3C, 0x3C, 0x73, 0xC3, 0xC7, 0x3C, 0x38, 0x7B, 0xC3, 0x83,
  0xB8, 0x38, 0x3B, 0x87, 0x83, 0xB8, 0x78, 0x3B, 0x87, 0x83, 0xF8, 0x78,
  0x1F, 0x87, 0x01, 0xF8, 0x70, 0x1F, 0x0F, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x7C, 0x3C, 0x07, 0x87,
  0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3E, 0x07, 0x83, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1E, 0x07,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF1, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x8F, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x81, 0xE0,
  0xF0, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0xE1, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x3C, 0x1F, 0x0F,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0x80, 0xF0, 0xF0, 0x0E, 0x1E, 0x01, 0xC7, 0x80, 0x38, 0xF0,
  0x07, 0x9C, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x78,
  0x3B, 0xC3, 0xC1, 0xDE, 0x1E, 0x1E, 0xF0, 0xF0, 0xE7, 0x0D, 0x87, 0x38,
  0x6C, 0x39, 0xC3, 0x63, 0xCE, 0x3B, 0x1C, 0x71, 0x98, 0xE3, 0x8C, 0xC7,
  0x1C, 0x66, 0x78, 0xE7, 0x73, 0x87, 0x33, 0x9C, 0x39, 0x9C, 0xE1, 0xDC,
  0xEE, 0x0E, 0xC7, 0x70, 0xF6, 0x33, 0x87, 0xB1, 0xBC, 0x3F, 0x8D, 0xC1,
  0xD8, 0x6E, 0x0E, 0xC3, 0x70, 0x7E, 0x1B, 0x83, 0xF0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C,
  0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0x1E,
  0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x01,
  0xE0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0xC0, 0xF0, 0x01,
  0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3E,
  0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x00,
  0x00, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xBC, 0x07, 0x9C,
  0x0F, 0x1C, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x78, 0x0F,
  0x70, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF8,
  0xF0, 0xF0, 0xF1, 0xE0, 0x03, 0xF3, 0xC3, 0xFE, 0xF1, 0xFF, 0xBC, 0x7C,
  0x7F, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xE0, 0x7C, 0xFC, 0x3F, 0x1F, 0xFB, 0x87, 0xFD, 0xE0, 0x7E,
  0x78, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x8F, 0xC0, 0xF7, 0xFC, 0x1E, 0xFF, 0xC3, 0xF0,
  0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF8, 0x1F, 0x1F, 0x87, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1E, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E,
  0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0xFC, 0xF0, 0x7F, 0xDE, 0x1F, 0xFB, 0xC3, 0xE3, 0xF8,
  0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xFF, 0x70, 0x7F, 0xDE, 0x03,
  0xF3, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3C,
  0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x78, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0x7C, 0x7F,
  0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81,
  0xF1, 0xFF, 0xFC, 0x7F, 0xEF, 0x0F, 0xF3, 0x80, 0xF1, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x8F, 0xC0, 0xF7, 0xFC, 0x1E, 0xFF, 0xC3,
  0xF0, 0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x78,
  0x0F, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x3C,
  0x07, 0xC7, 0x81, 0xF0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x70,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xE1,
  0xE0, 0x38, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x87, 0x80,
  0xF0, 0xF0, 0x1F, 0x1E, 0x01, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x1D, 0xE3,
  0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE3, 0xC7, 0x8E, 0x3C, 0x70, 0xE3, 0x87,
  0x0E, 0x38, 0x70, 0xE3, 0x87, 0x1E, 0x78, 0x71, 0xE7, 0x8E, 0x1E, 0x78,
  0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x3C, 0xF0, 0xE3, 0xCF,
  0x1C, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x78,
  0x0E, 0x3F, 0x03, 0xDF, 0xF0, 0x7B, 0xFF, 0x0F, 0xC3, 0xE1, 0xF0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x7E, 0x3E, 0x07, 0x8F,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x78,
  0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0x1F, 0x80,
  0xF7, 0xFC, 0x0F, 0x7F, 0xE0, 0xFC, 0x3E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0,
  0x7C, 0x3F, 0x0F, 0x83, 0xFF, 0xF0, 0x3D, 0xFE, 0x07, 0x9F, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF3, 0xC3, 0xFE, 0xF1, 0xFF, 0xBC, 0x7C, 0x7F, 0x3E,
  0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xE0, 0x7C, 0xFC, 0x3F, 0x1F, 0xFB, 0x87, 0xFD, 0xE0, 0xFE, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x1E, 0x7E, 0x03, 0xDF, 0xF0, 0x7F, 0xFF, 0x0E, 0xC3, 0xE1, 0xE0,
  0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xF8, 0x3E, 0x3C, 0x07,
  0x8F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF3, 0xC0,
  0x3C, 0xF8, 0x1F, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x81, 0xE0, 0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x70, 0x70,
  0x77, 0x0F, 0x07, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xB0, 0xE7, 0x1B,
  0x1C, 0x71, 0xB1, 0xC7, 0x3B, 0x1C, 0x73, 0x33, 0xC7, 0x33, 0x38, 0x77,
  0x33, 0x87, 0x63, 0x38, 0xF6, 0x37, 0x0F, 0xE3, 0x70, 0xEC, 0x37, 0x0E,
  0xC3, 0xE0, 0xEC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0,
  0x0F, 0x00, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x87, 0x80, 0x3C,
  0x7C, 0x01, 0xE7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x03, 0xEF,
  0x00, 0x1E, 0x7C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x1F,
  0x01, 0xF1, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0xC7, 0xC3, 0xF1, 0xFF, 0xFC, 0x7F, 0xEF, 0x0F, 0xF7, 0x80, 0x21, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x8F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xE0, 0x77, 0xFC, 0x1D, 0xFF, 0x87, 0xF1, 0xF3, 0xFC, 0x3F, 0xEF, 0x07,
  0xFB, 0x80, 0xF8,
};

const GFXglyph JetBrainsMono_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 26, 22, 7, -26 },
  { 31, 13, 11, 22, 6, -26 },
  { 49, 21, 26, 22, 1, -26 },
  { 118, 20, 36, 22, 1, -31 },
  { 208, 25, 26, 22, -1, -26 },
  { 290, 20, 27, 22, 1, -27 },
  { 358, 5, 11, 22, 10, -26 },
  { 365, 16, 35, 22, 5, -30 },
  { 435, 15, 35, 22, 2, -30 },
  { 501, 19, 19, 22, 2, -22 },
  { 547, 18, 17, 22, 2, -20 },
  { 586, 10, 11, 22, 3, -5 },
  { 600, 12, 4, 22, 5, -14 },
  { 606, 7, 6, 22, 6, -6 },
  { 612, 22, 34, 22, 0, -30 },
  { 706, 19, 27, 22, 2, -27 },
  { 771, 17, 26, 22, 2, -26 },
  { 827, 20, 27, 22, 1, -27 },
  { 895, 18, 26, 22, 2, -26 },
  { 954, 18, 26, 22, 2, -26 },
  { 1013, 18, 26, 22, 2, -26 },
  { 1072, 18, 26, 22, 2, -26 },
  { 1131, 18, 26, 22, 4, -26 },
  { 1190, 18, 27, 22, 2, -27 },
  { 1251, 18, 27, 22, 3, -27 },
  { 1312, 9, 20, 22, 6, -20 },
  { 1335, 12, 26, 22, 3, -20 },
  { 1374, 18, 20, 22, 3, -22 },
  { 1419, 18, 12, 22, 2, -18 },
  { 1446, 17, 20, 22, 2, -22 },
  { 1489, 15, 26, 22, 5, -26 },
  { 1538, 22, 33, 22, 0, -27 },
  { 1629, 18, 26, 22, 0, -26 },
  { 1688, 20, 26, 22, 1, -26 },
  { 1753, 19, 27, 22, 2, -27 },
  { 1818, 20, 26, 22, 1, -26 },
  { 1883, 19, 26, 22, 2, -26 },
  { 1945, 20, 26, 22, 2, -26 },
  { 2010, 19, 27, 22, 2, -27 },
  { 2075, 20, 26, 22, 1, -26 },
  { 2140, 19, 26, 22, 2, -26 },
  { 2202, 21, 26, 22, 0, -26 },
  { 2271, 22, 26, 22, 1, -26 },
  { 2343, 16, 26, 22, 2, -26 },
  { 2395, 21, 26, 22, 1, -26 },
  { 2464, 20, 26, 22, 1, -26 },
  { 2529, 19, 27, 22, 2, -27 },
  { 2594, 21, 26, 22, 1, -26 },
  { 2663, 19, 33, 22, 2, -27 },
  { 2742, 20, 26, 22, 1, -26 },
  { 2807, 20, 27, 22, 1, -27 },
  { 2875, 18, 26, 22, 4, -26 },
  { 2934, 19, 26, 22, 2, -26 },
  { 2996, 19, 26, 22, 4, -26 },
  { 3058, 21, 26, 22, 2, -26 },
  { 3127, 23, 26, 22, 0, -26 },
  { 3202, 19, 26, 22, 4, -26 },
  { 3264, 20, 26, 22, 1, -26 },
  { 3329, 15, 34, 22, 5, -30 },
  { 3393, 11, 34, 22, 6, -30 },
  { 3440, 15, 34, 22, 3, -30 },
  { 3504, 16, 14, 22, 3, -26 },
  { 3532, 18, 3, 22, 0, 1 },
  { 3539, 7, 5, 22, 9, -28 },
  { 3544, 18, 20, 22, 2, -20 },
  { 3589, 19, 26, 22, 1, -26 },
  { 3651, 18, 20, 22, 2, -20 },
  { 3696, 19, 26, 22, 2, -26 },
  { 3758, 18, 20, 22, 2, -20 },
  { 3803, 25, 32, 22, -2, -26 },
  { 3903, 18, 26, 22, 2, -20 },
  { 3962, 19, 26, 22, 1, -26 },
  { 4024, 18, 28, 22, 1, -28 },
  { 4087, 19, 34, 22, 0, -28 },
  { 4168, 19, 26, 22, 2, -26 },
  { 4230, 16, 26, 22, 3, -26 },
  { 4282, 20, 20, 22, 1, -20 },
  { 4332, 19, 20, 22, 1, -20 },
  { 4380, 18, 20, 22, 2, -20 },
  { 4425, 20, 26, 22, 0, -20 },
  { 4490, 18, 26, 22, 2, -20 },
  { 4549, 19, 20, 22, 2, -20 },
  { 4597, 18, 20, 22, 2, -20 },
  { 4642, 17, 25, 22, 3, -25 },
  { 4696, 18, 20, 22, 2, -20 },
  { 4741, 18, 20, 22, 3, -20 },
  { 4786, 20, 20, 22, 2, -20 },
  { 4836, 21, 20, 22, 0, -20 },
  { 4889, 18, 26, 22, 2, -20 },
  { 4948, 19, 20, 22, 1, -20 },
  { 4996, 19, 34, 22, 3, -30 },
  { 5077, 9, 34, 22, 7, -30 },
  { 5116, 18, 34, 22, 1, -30 },
  { 5193, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_MEDIUMITALIC36PT7B_H_
