#ifndef _JETBRAINSMONO_MEDIUMITALIC26PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0x00,
  0x00, 0xF3, 0xCE, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0xEE, 0x76, 0x3B, 0x1D,
  0x8C, 0x01, 0x86, 0x01, 0x86, 0x03, 0x8E, 0x03, 0x0C, 0x03, 0x0C, 0x1F,
  0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0x38, 0xE0, 0x30, 0xC0, 0x30, 0xC0, 0x71,
  0xC0, 0x61, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xF0,
  0x3F, 0xE1, 0xFB, 0xC7, 0x67, 0x39, 0x9C, 0xE6, 0x03, 0x98, 0x0F, 0x40,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xDC, 0x03, 0x38, 0x08, 0xEE, 0x23,
  0x39, 0x9C, 0x7E, 0xF1, 0xFF, 0x83, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0xC7, 0xF0, 0x61, 0x8C, 0x30, 0x63, 0x18,
  0x18, 0xCE, 0x0E, 0x37, 0x03, 0x99, 0x80, 0x7E, 0xC0, 0x0C, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x80, 0x0E, 0xF8, 0x07, 0x77, 0x01, 0x98, 0xC0, 0xCE,
  0x30, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0x3F, 0x8E, 0x07, 0xC0, 0x03, 0xF0,
  0x0F, 0xF0, 0x38, 0xE0, 0x70, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0xEE, 0x3B, 0x8E, 0xE7, 0x1F, 0x8E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x71, 0xF0, 0xFF, 0x70, 0xFC, 0xF0, 0x77, 0x76,
  0xEE, 0xEE, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xC0, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x80, 0xF0, 0x06,
  0x00, 0x0C, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x73, 0x1F, 0xE5, 0xF7, 0xFF,
  0x80, 0xC0, 0x07, 0x80, 0x37, 0x01, 0xDC, 0x0E, 0x38, 0x70, 0xE0, 0x41,
  0x00, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x1E, 0x3C, 0x71,
  0xE3, 0x8E, 0x1C, 0x70, 0xFF, 0xFF, 0xBF, 0xC0, 0x7B, 0xDE, 0xF0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x01, 0xCC, 0x06, 0x73, 0xB9, 0xDE, 0xE7, 0x33, 0x9C, 0x0E, 0x60, 0x39,
  0x80, 0xC6, 0x07, 0x18, 0x1C, 0x78, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x01,
  0xE0, 0x7E, 0x0F, 0xE1, 0xCC, 0x39, 0xC2, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xE1, 0xE7, 0x8E, 0x07, 0x38,
  0x1C, 0xC0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0x71, 0xE1, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x39, 0xC1, 0xDE, 0x0C, 0xE0, 0xE7, 0x07, 0x3F, 0xFB, 0xFF,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0x87, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0xE1,
  0xE3, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x18, 0x1C, 0x78,
  0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x98, 0x3F, 0xF1, 0xFF, 0x9C, 0x1E, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xDC, 0x0E, 0x78, 0xE3, 0xFE, 0x0F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEE, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3,
  0x87, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x87, 0x1C, 0x0F, 0xE0, 0x3F,
  0x01, 0xFE, 0x0E, 0x1C, 0x70, 0x71, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0x70,
  0xE1, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0x1E, 0xE0, 0x77,
  0x03, 0xB0, 0x1F, 0x80, 0xFC, 0x07, 0x70, 0x73, 0xFF, 0x9F, 0xF8, 0x3B,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x00,
  0x08, 0x3C, 0xF9, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x8F,
  0x1E, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x30, 0x38, 0x38, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x18,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x30, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x20, 0x01, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x60, 0x00,
  0x3F, 0x07, 0xF8, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x07,
  0xC3, 0xF0, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x01, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x30, 0x77, 0x30, 0xFE, 0x31, 0xCE, 0x73, 0x86, 0x73,
  0x86, 0x63, 0x8E, 0x63, 0x0E, 0x63, 0x0C, 0x63, 0x0C, 0xE3, 0x9C, 0xE3,
  0xEC, 0xE0, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0x98, 0x1C, 0xC0, 0xC6, 0x0E, 0x30, 0x71, 0x87, 0x0E, 0x38, 0x71, 0xFF,
  0x9F, 0xFC, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x06, 0x1F, 0xE0,
  0x7F, 0xE1, 0x87, 0x86, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x1C,
  0x3F, 0xE0, 0xFF, 0x87, 0x0F, 0x1C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x98, 0x1C, 0xE1, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x8F,
  0x1E, 0x70, 0x77, 0x03, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0x9C, 0x1C, 0xF1, 0xC7,
  0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x8E, 0x0F, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x39, 0xC0, 0xC7, 0x07, 0x18, 0x3C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F,
  0xE0, 0xFF, 0x8F, 0x1E, 0x70, 0x77, 0x03, 0xB8, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x1F, 0xB8, 0xFD, 0xCF, 0xEE, 0x07, 0x70, 0x33, 0x83, 0x9C,
  0x1C, 0xF1, 0xC7, 0xFE, 0x0F, 0xC0, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC6,
  0x07, 0x38, 0x1C, 0xE0, 0x63, 0x83, 0x8E, 0x0E, 0x3F, 0xF8, 0xFF, 0xE7,
  0x03, 0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x0E, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0xE1, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x8E, 0x07, 0x18, 0x0E, 0x38, 0x38, 0x78, 0xF0, 0xFF, 0xC0,
  0x7E, 0x00, 0x1C, 0x0E, 0x38, 0x38, 0x60, 0x71, 0xC1, 0xC3, 0x87, 0x07,
  0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xB1,
  0xE3, 0x66, 0xC6, 0xCD, 0x8D, 0xB7, 0x3B, 0x6E, 0x77, 0x98, 0xEF, 0x31,
  0xCE, 0xE3, 0x01, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x18, 0xE0,
  0x71, 0x80, 0xE3, 0x01, 0xC0, 0x1E, 0x0C, 0x78, 0x31, 0xE1, 0xCF, 0x87,
  0x3E, 0x1C, 0xFC, 0x73, 0x71, 0x8C, 0xC6, 0x33, 0x39, 0xCC, 0xE7, 0x3B,
  0x9C, 0xEE, 0x71, 0xB1, 0x86, 0xC6, 0x1B, 0x18, 0x7C, 0xE1, 0xF3, 0x83,
  0xCE, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0x1C, 0x70, 0x77, 0x03, 0xB8,
  0x1D, 0xC0, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x06,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xF3, 0xC7, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF1, 0xC0, 0xE3, 0x80, 0xC7, 0x01, 0x8E, 0x07, 0x1C,
  0x0E, 0x38, 0x38, 0x7F, 0xF1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xE3, 0x8F, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x06,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xC6, 0x07,
  0x1C, 0x1C, 0x79, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x78, 0xFF, 0xC7, 0xFC, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x0E, 0x18, 0x38, 0xE0, 0xE3, 0x81, 0xCE,
  0x07, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0xC7, 0x07, 0x38, 0x1C, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xEE, 0x03, 0x38, 0x1C, 0x78, 0xF1, 0xFF, 0x83, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x30, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x79,
  0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE,
  0x07, 0x30, 0x71, 0x83, 0x8C, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7,
  0x07, 0x30, 0x3B, 0x81, 0xD8, 0x0F, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC6, 0x73, 0xC6, 0x73, 0xCE, 0x72, 0xCC,
  0x62, 0xCC, 0x66, 0xCC, 0x66, 0xDC, 0x64, 0xD8, 0x6C, 0xD8, 0x6C, 0xD8,
  0x6C, 0xB8, 0x68, 0xB0, 0x78, 0xB0, 0x78, 0xB0, 0x70, 0xE0, 0x70, 0xE0,
  0xF0, 0xE0, 0x1C, 0x07, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x07, 0x38,
  0x07, 0x70, 0x03, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x38,
  0x70, 0x38, 0xE0, 0x3C, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x1C, 0x1C, 0x70,
  0xE1, 0xC7, 0x03, 0x1C, 0x0E, 0xE0, 0x3B, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0xE0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x1C,
  0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x03,
  0x80, 0x78, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCE, 0x38, 0xE3, 0x06, 0x70,
  0x6E, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x02, 0x04, 0x3F, 0x61,
  0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x71,
  0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x79, 0xF1, 0xFD, 0xC3, 0xE6, 0x00, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x88, 0x1D, 0xF8, 0xFF, 0xE7, 0x8F,
  0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0xF8, 0xE7, 0xFF, 0x3B, 0xE0, 0x03, 0x01, 0xFE, 0x3F, 0xF7, 0x87,
  0x70, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x0E,
  0xF1, 0xCF, 0xFC, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x02, 0x1C, 0x3F, 0x61, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x79, 0xF1, 0xFD,
  0xC3, 0xE6, 0x00, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0x07, 0x70, 0x7E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xEE, 0x00, 0xC0, 0x0E, 0x0E, 0xE1, 0xCF, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xE0, 0x00, 0x04, 0x08, 0xFD, 0x8F, 0xFC, 0xF1, 0xE7,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0x67, 0x07, 0x38, 0x39, 0xE7,
  0xC7, 0xEE, 0x1E, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC3, 0xFC, 0x3F, 0xC1,
  0xF8, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x88, 0x1D, 0xF8,
  0xFF, 0xE7, 0x8F, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x38,
  0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x18, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x07, 0xF8, 0x3F, 0xC0,
  0xFC, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x27,
  0x03, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x63, 0xC1, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0x70, 0x60, 0xE1, 0xC1, 0xE3,
  0x81, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x01, 0x08, 0x3F, 0x78, 0xFF,
  0xF9, 0xCE, 0x73, 0x98, 0xE6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x71, 0x9C,
  0xE7, 0x39, 0xCC, 0x73, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x38, 0xCE, 0x00,
  0x00, 0x81, 0xDF, 0x8F, 0xFE, 0x78, 0xF3, 0x83, 0x98, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x33, 0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81,
  0x80, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0x8F, 0x70, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xF3, 0xCF, 0xF8, 0x7F, 0x00,
  0x00, 0x40, 0x77, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C, 0x1C, 0x60, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x7C, 0x71, 0xFF,
  0xC7, 0x7C, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x02,
  0x04, 0x3F, 0x61, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x79, 0xF1, 0xFD, 0xC3,
  0xE6, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x81,
  0xBF, 0x1F, 0xFC, 0xF0, 0xE7, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x7F, 0x87, 0xFE, 0x70, 0x73, 0x80, 0x1C, 0x00, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x03, 0x80, 0x1D, 0xC0, 0xEF, 0x0F, 0x3F, 0xF0, 0xFF, 0x00,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xF8, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC7,
  0x07, 0x1E, 0x78, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x3B, 0x01, 0xDC, 0x1C,
  0xE0, 0xE7, 0x0E, 0x38, 0x70, 0xC7, 0x06, 0x38, 0x3B, 0x81, 0xDC, 0x0E,
  0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0xC7, 0x1F, 0x1C, 0x6C, 0x51, 0xB3,
  0x46, 0xCD, 0x33, 0x24, 0xCC, 0x93, 0x36, 0xDC, 0xDB, 0x63, 0x4D, 0x8F,
  0x3E, 0x3C, 0xF0, 0xE3, 0xC3, 0x8F, 0x00, 0x1C, 0x1E, 0x1C, 0x38, 0x38,
  0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1D, 0xC0, 0x73, 0x81, 0xC3, 0x87, 0x87, 0x9E, 0x07, 0x00, 0x70, 0x3B,
  0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x3F, 0xF8, 0xFD, 0xC3, 0xCC, 0x00, 0x60, 0x07, 0x00, 0x38,
  0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF0, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F,
  0xC0, 0xFC, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x0C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xC7, 0x1C,
  0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xE0, 0x1C, 0x00, 0xF8, 0x07, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xF0, 0x1F, 0x83, 0xFC, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x00,
  0x1E, 0x1C, 0xFC, 0x77, 0x71, 0x98, 0xFE, 0x61, 0xF2, 0x01, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 9, 8, 16, 5, -19 },
  { 25, 16, 19, 16, 0, -19 },
  { 63, 14, 27, 16, 1, -23 },
  { 111, 18, 19, 16, -1, -19 },
  { 154, 15, 19, 16, 0, -19 },
  { 190, 4, 8, 16, 7, -19 },
  { 194, 11, 25, 16, 4, -22 },
  { 229, 11, 25, 16, 1, -22 },
  { 264, 14, 14, 16, 1, -16 },
  { 289, 12, 13, 16, 2, -15 },
  { 309, 7, 8, 16, 2, -4 },
  { 316, 9, 3, 16, 4, -10 },
  { 320, 5, 4, 16, 4, -4 },
  { 323, 16, 25, 16, 0, -22 },
  { 373, 14, 19, 16, 1, -19 },
  { 407, 12, 19, 16, 1, -19 },
  { 436, 14, 19, 16, 1, -19 },
  { 470, 14, 19, 16, 1, -19 },
  { 504, 13, 19, 16, 1, -19 },
  { 535, 14, 19, 16, 1, -19 },
  { 569, 13, 19, 16, 1, -19 },
  { 600, 13, 19, 16, 3, -19 },
  { 631, 14, 19, 16, 1, -19 },
  { 665, 13, 19, 16, 2, -19 },
  { 696, 7, 15, 16, 4, -15 },
  { 710, 9, 19, 16, 2, -15 },
  { 732, 13, 14, 16, 2, -16 },
  { 755, 12, 9, 16, 2, -13 },
  { 769, 13, 14, 16, 1, -16 },
  { 792, 11, 19, 16, 3, -19 },
  { 819, 16, 24, 16, 0, -19 },
  { 867, 13, 19, 16, 0, -19 },
  { 898, 14, 19, 16, 1, -19 },
  { 932, 13, 19, 16, 2, -19 },
  { 963, 14, 19, 16, 1, -19 },
  { 997, 14, 19, 16, 1, -19 },
  { 1031, 15, 19, 16, 1, -19 },
  { 1067, 13, 19, 16, 2, -19 },
  { 1098, 14, 19, 16, 1, -19 },
  { 1132, 14, 19, 16, 1, -19 },
  { 1166, 15, 19, 16, 0, -19 },
  { 1202, 15, 19, 16, 1, -19 },
  { 1238, 11, 19, 16, 2, -19 },
  { 1265, 15, 19, 16, 1, -19 },
  { 1301, 14, 19, 16, 1, -19 },
  { 1335, 13, 19, 16, 2, -19 },
  { 1366, 15, 19, 16, 1, -19 },
  { 1402, 14, 24, 16, 1, -19 },
  { 1444, 14, 19, 16, 1, -19 },
  { 1478, 14, 19, 16, 1, -19 },
  { 1512, 13, 19, 16, 3, -19 },
  { 1543, 14, 19, 16, 1, -19 },
  { 1577, 13, 19, 16, 3, -19 },
  { 1608, 16, 19, 16, 1, -19 },
  { 1646, 16, 19, 16, 0, -19 },
  { 1684, 14, 19, 16, 3, -19 },
  { 1718, 14, 19, 16, 1, -19 },
  { 1752, 11, 25, 16, 3, -22 },
  { 1787, 8, 25, 16, 4, -22 },
  { 1812, 11, 25, 16, 2, -22 },
  { 1847, 12, 10, 16, 2, -19 },
  { 1862, 13, 2, 16, 0, 1 },
  { 1866, 5, 3, 16, 7, -20 },
  { 1868, 14, 15, 16, 1, -15 },
  { 1895, 13, 19, 16, 1, -19 },
  { 1926, 12, 15, 16, 2, -15 },
  { 1949, 14, 19, 16, 1, -19 },
  { 1983, 12, 15, 16, 2, -15 },
  { 2006, 17, 24, 16, -1, -19 },
  { 2057, 13, 20, 16, 2, -15 },
  { 2090, 13, 19, 16, 1, -19 },
  { 2121, 13, 20, 16, 1, -20 },
  { 2154, 14, 25, 16, 0, -20 },
  { 2198, 15, 19, 16, 1, -19 },
  { 2234, 12, 19, 16, 2, -19 },
  { 2263, 15, 15, 16, 0, -15 },
  { 2292, 13, 15, 16, 1, -15 },
  { 2317, 12, 15, 16, 2, -15 },
  { 2340, 14, 20, 16, 0, -15 },
  { 2375, 14, 20, 16, 1, -15 },
  { 2410, 13, 15, 16, 2, -15 },
  { 2435, 13, 15, 16, 1, -15 },
  { 2460, 13, 18, 16, 2, -18 },
  { 2490, 14, 14, 16, 1, -14 },
  { 2515, 13, 14, 16, 2, -14 },
  { 2538, 14, 14, 16, 2, -14 },
  { 2563, 15, 14, 16, 0, -14 },
  { 2590, 13, 19, 16, 2, -14 },
  { 2621, 13, 14, 16, 1, -14 },
  { 2644, 14, 25, 16, 2, -22 },
  { 2688, 6, 25, 16, 5, -22 },
  { 2707, 13, 25, 16, 1, -22 },
  { 2748, 14, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_MEDIUMITALIC26PT7B_H_
