#ifndef _JETBRAINSMONO_MEDIUMITALIC44PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x7C, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0,
  0x78, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x1E,
  0x00, 0x1C, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xCE, 0x7E, 0x0F, 0x8E, 0x3E, 0x0F, 0x8E, 0x3E, 0x0F, 0x0E,
  0x3E, 0x1F, 0x0C, 0x00, 0x1F, 0x0C, 0x00, 0x1F, 0x9C, 0x00, 0x1F, 0x9C,
  0x00, 0x0F, 0xDC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x39,
  0xF8, 0x00, 0x38, 0xF8, 0x00, 0x30, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x70,
  0xF8, 0xF8, 0x70, 0xF8, 0xF8, 0x70, 0xF0, 0xFC, 0x71, 0xF0, 0xFE, 0x67,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1E, 0x03,
  0xFF, 0x00, 0x78, 0x0F, 0xFE, 0x01, 0xE0, 0x3E, 0x3C, 0x03, 0x80, 0x78,
  0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0xF0, 0x03, 0x83,
  0xC3, 0xC0, 0x0F, 0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x3C, 0x00, 0x3C, 0x3C,
  0x70, 0x00, 0x3F, 0xF9, 0xC0, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0x7F, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0xF3, 0xFE,
  0x00, 0x03, 0xCF, 0xFE, 0x00, 0x0F, 0x3C, 0x3C, 0x00, 0x3C, 0x70, 0x38,
  0x00, 0xF0, 0xE0, 0x70, 0x01, 0xC3, 0xC1, 0xE0, 0x07, 0x87, 0x83, 0xC0,
  0x1E, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x0E, 0x01, 0xE0, 0x3C, 0x3C, 0x07,
  0x80, 0x3F, 0xF0, 0x0E, 0x00, 0x7F, 0xE0, 0x78, 0x00, 0x7F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0x3E, 0x7C, 0x1F, 0x7C, 0x3E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7C, 0x1F, 0x78, 0x78, 0x1F, 0xF8, 0x78, 0x0F, 0xF0, 0x78,
  0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xFC,
  0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFC, 0xF8, 0x3F, 0xF8, 0xF8, 0x1F,
  0xE0, 0x7C, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x20, 0x1C, 0x02, 0x3C, 0x1C, 0x1E, 0x7F, 0x1C,
  0x7E, 0xFF, 0x99, 0xFF, 0x7F, 0xDF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF,
  0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1C, 0x03, 0x80, 0x08, 0x01, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0x87,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0,
  0x01, 0xF1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x8E, 0x0F, 0x1F, 0x3E,
  0x3E, 0x3C, 0x7E, 0x7C, 0x78, 0xF8, 0xF8, 0xF1, 0xF1, 0xE3, 0xE0, 0xC3,
  0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x07,
  0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0x7C, 0x07, 0xF3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0C,
  0x0F, 0x80, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0,
  0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0xFE, 0x01,
  0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x3E, 0xFF, 0x81,
  0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0x83, 0xF8, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0xC0, 0x3F, 0x1F,
  0x81, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x7E, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xBF, 0x80,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xE0,
  0x0F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3F, 0x00, 0xFC,
  0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x03,
  0x8F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0x30,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x3F, 0xBC, 0x3C, 0x0F, 0xF7, 0x87, 0x83, 0xFF, 0xF0, 0xF0, 0xF8,
  0x3E, 0x3C, 0x1E, 0x07, 0xC7, 0x83, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x1E,
  0x1F, 0x03, 0xC3, 0xC3, 0xC0, 0x78, 0x78, 0x78, 0x0F, 0x1E, 0x0F, 0x01,
  0xE3, 0xC1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0,
  0xF0, 0x7C, 0x3C, 0x1F, 0xFF, 0x8F, 0x83, 0xFE, 0xF1, 0xE0, 0x3F, 0x9E,
  0x3C, 0x00, 0x80, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3C,
  0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0xC0,
  0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F,
  0xE1, 0xF0, 0x0F, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C,
  0x0F, 0xE0, 0xF8, 0x07, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x03,
  0xF1, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC,
  0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1,
  0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01,
  0xF0, 0xF8, 0x07, 0xE1, 0xE0, 0x1F, 0x87, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0xF9, 0xF0, 0xFF, 0xE7, 0xC3,
  0xFF, 0x9E, 0x0F, 0xFC, 0x78, 0x41, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7C,
  0x0F, 0xE0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC1, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x3C, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0x78, 0x3D, 0xC3, 0xDC, 0x0F, 0x70, 0xEF, 0x03, 0x9C, 0x7B,
  0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xEF, 0x3C, 0x1E, 0x7B, 0x9F, 0x07, 0x8E,
  0xE7, 0xC1, 0xE3, 0xF1, 0xE0, 0x78, 0xFC, 0x78, 0x3E, 0x3F, 0x1E, 0x0F,
  0x8F, 0x8F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x1E,
  0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x3E,
  0x1F, 0xF0, 0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C,
  0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x3E, 0x3C, 0x7C, 0x3E, 0x3C, 0x7C,
  0x3E, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x1C, 0x78,
  0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF0, 0x78, 0x1E, 0xF0,
  0x78, 0x0E, 0xF0, 0x78, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0,
  0xF8, 0x0F, 0xE0, 0xF0, 0x0F, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xF0, 0x78, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0xFE,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C,
  0x1E, 0x00, 0xFC, 0x1E, 0x07, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xFC, 0x01, 0xF0, 0xFE, 0x07, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x7C,
  0x3C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x1E,
  0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0x0F, 0x83, 0xE7, 0x81, 0xF0, 0x78, 0xF0, 0x7E, 0x0F, 0x1E, 0x0F,
  0x81, 0xE3, 0xC1, 0xF0, 0x78, 0x78, 0x36, 0x0F, 0x0F, 0x0E, 0xC1, 0xE1,
  0xE1, 0xD8, 0x3C, 0x3C, 0x3B, 0x0F, 0x07, 0x8E, 0xE1, 0xE0, 0xF1, 0xDC,
  0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x86, 0x71, 0xE0, 0xF1, 0xCE, 0x3C, 0x1E,
  0x39, 0xC7, 0x83, 0xC7, 0x39, 0xE0, 0x79, 0xC7, 0x3C, 0x0F, 0x38, 0xE7,
  0x81, 0xE7, 0x1C, 0xF0, 0x3C, 0xC3, 0xBC, 0x07, 0xB8, 0x77, 0x80, 0xF7,
  0x0E, 0xF0, 0x1E, 0xE1, 0xDE, 0x03, 0xD8, 0x3F, 0x80, 0x7F, 0x06, 0xF0,
  0x0F, 0xE0, 0xDE, 0x01, 0xDC, 0x1B, 0x80, 0x3F, 0x03, 0x70, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x10, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03,
  0xC3, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x7C,
  0x0F, 0xFC, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF0, 0x3F, 0x87,
  0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xBC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFD, 0xF0, 0x0F, 0xE3, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0xE0, 0x1F, 0x1F, 0xE0, 0x7D, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x81, 0xF8, 0xFF,
  0xFF, 0xC3, 0xEF, 0xFF, 0x0F, 0xBF, 0xF0, 0x3E, 0x7F, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0x80, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x17, 0xC0, 0x0F, 0x3E, 0x00, 0xF9,
  0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x30, 0x3E, 0x01, 0xFE, 0x3E, 0x03, 0xFF, 0x3C, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFD, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFB,
  0xE0, 0x0F, 0xE3, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xCF, 0xC0, 0x7C, 0x3F,
  0x9F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF9, 0xF0, 0x7F, 0xE7,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFC, 0x0F, 0xE3, 0xE0, 0x1F, 0x8F,
  0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFB, 0xE0, 0xFF, 0xCF, 0x01, 0xFE, 0x7C, 0x00, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0xE0, 0x1F, 0x3F, 0xE0,
  0x7D, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFD, 0xFE, 0x1F, 0x80, 0xF8, 0x7C,
  0x03, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x3F, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x1E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x10, 0x18, 0x1E, 0x7C, 0x7E, 0x1E, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x3E, 0x1E, 0x1F, 0x3E,
  0x1E, 0x1F, 0x3C, 0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3E, 0x78, 0x3C, 0x3C, 0x78,
  0x38, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x78, 0x7C, 0xF8,
  0x78, 0x7C, 0xF0, 0x78, 0x78, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x78, 0xF0,
  0xF0, 0x78, 0x00, 0x03, 0x80, 0x7C, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xF7, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xC7, 0xF8, 0x07,
  0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0xFF, 0xF0, 0x3E,
  0xFF, 0xF0, 0x3E, 0xFF, 0xE0, 0x3E, 0x7F, 0x80, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFC, 0x7C, 0x0F, 0xFC, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF0,
  0x3F, 0x87, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x78, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xBC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFD, 0xF0, 0x0F, 0xE3, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x7C, 0xFF,
  0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1E, 0xF7, 0xF8, 0x7E, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0,
  0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x7C, 0xFC,
  0x03, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x3C, 0xF0, 0xDC, 0x3C, 0xF1, 0xDC, 0x38, 0xF1, 0xDC, 0x78,
  0xF1, 0x9C, 0x78, 0xF3, 0x9C, 0x70, 0xF3, 0x9C, 0xF0, 0xF3, 0x1C, 0xF0,
  0xF7, 0x1C, 0xE0, 0xF7, 0x1D, 0xE0, 0xF6, 0x1D, 0xE0, 0xFE, 0x1D, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C,
  0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0xF0, 0x3F, 0xF3, 0xC0, 0x7F, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x1E, 0x3F, 0xE0, 0x3C, 0xFF, 0xE0, 0xFB, 0xF7, 0xE1, 0xF7, 0x87, 0xC3,
  0xCF, 0x07, 0xFF, 0x9E, 0x0F, 0xFE, 0x3C, 0x0F, 0xF8, 0xF8, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 32, 26, 8, -32 },
  { 45, 16, 13, 26, 8, -32 },
  { 71, 26, 32, 26, 1, -32 },
  { 175, 24, 44, 26, 2, -38 },
  { 307, 31, 32, 26, -2, -32 },
  { 431, 24, 33, 26, 1, -33 },
  { 530, 7, 13, 26, 12, -32 },
  { 542, 18, 43, 26, 7, -37 },
  { 639, 19, 43, 26, 2, -37 },
  { 742, 24, 23, 26, 2, -27 },
  { 811, 21, 21, 26, 3, -25 },
  { 867, 12, 14, 26, 4, -7 },
  { 888, 15, 5, 26, 6, -17 },
  { 898, 8, 7, 26, 8, -7 },
  { 905, 27, 42, 26, 0, -37 },
  { 1047, 23, 33, 26, 2, -33 },
  { 1142, 21, 32, 26, 2, -32 },
  { 1226, 23, 33, 26, 2, -33 },
  { 1321, 23, 32, 26, 2, -32 },
  { 1413, 22, 32, 26, 2, -32 },
  { 1501, 23, 32, 26, 2, -32 },
  { 1593, 22, 32, 26, 2, -32 },
  { 1681, 22, 32, 26, 5, -32 },
  { 1769, 23, 33, 26, 2, -33 },
  { 1864, 22, 33, 26, 4, -33 },
  { 1955, 11, 25, 26, 8, -25 },
  { 1990, 15, 32, 26, 4, -25 },
  { 2050, 21, 23, 26, 4, -26 },
  { 2111, 21, 15, 26, 3, -22 },
  { 2151, 22, 23, 26, 2, -26 },
  { 2215, 18, 32, 26, 6, -32 },
  { 2287, 27, 41, 26, 0, -33 },
  { 2426, 23, 32, 26, 0, -32 },
  { 2518, 23, 32, 26, 2, -32 },
  { 2610, 22, 33, 26, 3, -33 },
  { 2701, 23, 32, 26, 2, -32 },
  { 2793, 24, 32, 26, 2, -32 },
  { 2889, 24, 32, 26, 2, -32 },
  { 2985, 22, 33, 26, 3, -33 },
  { 3076, 24, 32, 26, 2, -32 },
  { 3172, 23, 32, 26, 2, -32 },
  { 3264, 25, 32, 26, 0, -32 },
  { 3364, 26, 32, 26, 2, -32 },
  { 3468, 19, 32, 26, 3, -32 },
  { 3544, 26, 32, 26, 1, -32 },
  { 3648, 24, 32, 26, 2, -32 },
  { 3744, 22, 33, 26, 3, -33 },
  { 3835, 25, 32, 26, 2, -32 },
  { 3935, 23, 41, 26, 2, -33 },
  { 4053, 24, 32, 26, 2, -32 },
  { 4149, 24, 33, 26, 2, -33 },
  { 4248, 22, 32, 26, 5, -32 },
  { 4336, 24, 32, 26, 2, -32 },
  { 4432, 23, 32, 26, 5, -32 },
  { 4524, 27, 32, 26, 2, -32 },
  { 4632, 28, 32, 26, 0, -32 },
  { 4744, 24, 32, 26, 4, -32 },
  { 4840, 24, 32, 26, 2, -32 },
  { 4936, 18, 42, 26, 6, -37 },
  { 5031, 14, 42, 26, 7, -37 },
  { 5105, 18, 42, 26, 4, -37 },
  { 5200, 20, 17, 26, 4, -32 },
  { 5243, 22, 4, 26, 0, 1 },
  { 5254, 9, 7, 26, 11, -35 },
  { 5262, 23, 25, 26, 2, -25 },
  { 5334, 22, 32, 26, 2, -32 },
  { 5422, 21, 25, 26, 3, -25 },
  { 5488, 24, 32, 26, 2, -32 },
  { 5584, 21, 25, 26, 3, -25 },
  { 5650, 30, 40, 26, -2, -32 },
  { 5800, 22, 33, 26, 3, -25 },
  { 5891, 22, 32, 26, 2, -32 },
  { 5979, 22, 34, 26, 1, -34 },
  { 6073, 24, 42, 26, 0, -34 },
  { 6199, 24, 32, 26, 2, -32 },
  { 6295, 19, 32, 26, 4, -32 },
  { 6371, 24, 25, 26, 1, -25 },
  { 6446, 22, 25, 26, 2, -25 },
  { 6515, 21, 25, 26, 3, -25 },
  { 6581, 24, 33, 26, 0, -25 },
  { 6680, 23, 33, 26, 2, -25 },
  { 6775, 22, 25, 26, 3, -25 },
  { 6844, 22, 25, 26, 2, -25 },
  { 6913, 22, 31, 26, 3, -31 },
  { 6999, 23, 24, 26, 2, -24 },
  { 7068, 22, 24, 26, 4, -24 },
  { 7134, 24, 24, 26, 3, -24 },
  { 7206, 26, 24, 26, 0, -24 },
  { 7284, 22, 32, 26, 3, -24 },
  { 7372, 22, 24, 26, 2, -24 },
  { 7438, 23, 42, 26, 4, -37 },
  { 7559, 11, 42, 26, 8, -37 },
  { 7617, 23, 42, 26, 1, -37 },
  { 7738, 23, 9, 26, 2, -20 },
};

const GFXfont JetBrainsMono_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_MEDIUMITALIC44PT7B_H_
