#ifndef _JETBRAINSMONO_MEDIUMITALIC48PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE0,
  0xF9, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xEE, 0xFE, 0x07, 0xE3, 0x9F, 0x81,
  0xF1, 0xC3, 0xE0, 0xF8, 0x70, 0xF8, 0x3E, 0x1C, 0x3E, 0x0F, 0x87, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0x3F, 0x38, 0x00, 0x0F, 0xEE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1C, 0xFE, 0x00, 0x07, 0x1F, 0x80, 0x01, 0xC3, 0xE0, 0x00, 0x70,
  0xF8, 0x00, 0x38, 0x3E, 0x3F, 0x0E, 0x0F, 0x8F, 0xC3, 0x87, 0xE3, 0xF0,
  0xE1, 0xF0, 0x7E, 0x38, 0xFC, 0x1F, 0xCE, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x3F, 0xF0, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0xF0, 0x0F, 0x8F,
  0x80, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x78,
  0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x87, 0xC0, 0x07, 0x81, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x78, 0x00, 0x1E, 0x1F, 0x3C, 0x00,
  0x07, 0xFF, 0x9E, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0xE3, 0xC0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F,
  0x9F, 0xF0, 0x00, 0x03, 0xCF, 0xFE, 0x00, 0x01, 0xE7, 0xFF, 0x80, 0x00,
  0xF3, 0xE1, 0xF0, 0x00, 0x78, 0xF0, 0x3C, 0x00, 0x3C, 0x3C, 0x0F, 0x00,
  0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x07, 0xC7,
  0xC0, 0x3C, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x9F, 0xDF, 0x03, 0xE3, 0xE3, 0xF0,
  0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xE7, 0xC3, 0xE0, 0x7D, 0xF0, 0x7C,
  0x0F, 0xFE, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xF0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xF0, 0xF8,
  0x0F, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x01, 0x00, 0xF0, 0x08, 0xF0, 0x3C, 0x1E, 0x7F, 0x0E, 0x1F,
  0xDF, 0xF3, 0x9F, 0xFF, 0xFE, 0xDF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x1F, 0x00, 0x30, 0x03,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x1F,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x30, 0x7C,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0x7C, 0x01, 0xF8,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0x1C, 0x0F, 0xC0, 0x20, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xF0, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x1F, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0x80, 0xFC, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE3, 0xC0, 0x07, 0xDF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xF3, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7C,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x81, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0xFE,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFD,
  0xF0, 0x0F, 0xFB, 0xE0, 0x01, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x7C, 0x0F, 0xFB, 0xC3, 0xC0, 0xFF, 0xFE,
  0x1E, 0x07, 0xC3, 0xF0, 0xF0, 0x7C, 0x0F, 0x87, 0x83, 0xC0, 0x7C, 0x7C,
  0x1E, 0x03, 0xE3, 0xE0, 0xF0, 0x1F, 0x1E, 0x0F, 0x80, 0xF0, 0xF0, 0x7C,
  0x07, 0x87, 0x83, 0xE0, 0x3C, 0x3C, 0x1E, 0x03, 0xE3, 0xE0, 0xF0, 0x1F,
  0x1F, 0x07, 0x80, 0xF8, 0xF8, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x7C, 0x3C,
  0x0F, 0x87, 0xE1, 0xE0, 0x7F, 0xEF, 0x1F, 0x01, 0xFF, 0x78, 0xF8, 0x07,
  0xE3, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80,
  0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0x7F, 0x07, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x83,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x8F, 0xC3,
  0xFF, 0xC7, 0xC1, 0xFF, 0xE3, 0xE0, 0xFF, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0,
  0x07, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF8, 0x1E, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0x78, 0x1D, 0xE0, 0xF7,
  0x83, 0xDE, 0x0F, 0x38, 0x39, 0xE0, 0xF3, 0x87, 0xBE, 0x0F, 0x38, 0x7B,
  0xC0, 0xF3, 0xCF, 0x3C, 0x0F, 0x3C, 0xF3, 0xC1, 0xF3, 0xDE, 0x7C, 0x1F,
  0x3D, 0xE7, 0xC1, 0xF1, 0xDC, 0x7C, 0x1F, 0x1F, 0xC7, 0x81, 0xF1, 0xF8,
  0x78, 0x1E, 0x1F, 0x8F, 0x81, 0xE1, 0xF0, 0xF8, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x1F,
  0xE0, 0x1F, 0x07, 0xF8, 0x07, 0xC3, 0xFE, 0x01, 0xF0, 0xFF, 0x80, 0x78,
  0x3F, 0xE0, 0x3E, 0x0F, 0x78, 0x0F, 0x83, 0xDF, 0x03, 0xE0, 0xF3, 0xC0,
  0xF8, 0x7C, 0xF0, 0x3E, 0x1F, 0x3C, 0x0F, 0x07, 0xCF, 0x07, 0xC1, 0xF3,
  0xE1, 0xF0, 0x7C, 0x78, 0x7C, 0x1F, 0x1E, 0x1F, 0x07, 0x87, 0x87, 0xC3,
  0xE1, 0xE1, 0xE0, 0xF8, 0x7C, 0xF8, 0x3E, 0x0F, 0x3E, 0x0F, 0x83, 0xCF,
  0x83, 0xE0, 0xF3, 0xE0, 0xF0, 0x3C, 0xF8, 0x7C, 0x0F, 0xBC, 0x1F, 0x03,
  0xEF, 0x07, 0xC0, 0x7B, 0xC1, 0xF0, 0x1E, 0xF0, 0x7C, 0x07, 0xBC, 0x1E,
  0x01, 0xFF, 0x0F, 0x80, 0x7F, 0xC3, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8,
  0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01,
  0xF0, 0xFC, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x01,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x01,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x81,
  0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0xF7, 0xC0, 0xF8, 0x1F, 0x7C, 0x0F, 0x81, 0xF7,
  0xC1, 0xF8, 0x1E, 0x7C, 0x1F, 0x81, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F,
  0x83, 0xC7, 0xC3, 0xB8, 0x3C, 0x78, 0x3B, 0x83, 0xC7, 0x83, 0xB8, 0x7C,
  0x78, 0x7B, 0x87, 0x87, 0x87, 0x38, 0x78, 0x78, 0x73, 0x87, 0x87, 0x87,
  0x38, 0xF8, 0x78, 0xE3, 0x8F, 0x07, 0x8E, 0x38, 0xF0, 0x78, 0xE3, 0x9F,
  0x07, 0x8E, 0x39, 0xF0, 0x79, 0xC7, 0x1E, 0x0F, 0x9C, 0x71, 0xE0, 0xF9,
  0xC7, 0x3E, 0x0F, 0xB8, 0x73, 0xC0, 0xFB, 0x87, 0x3C, 0x0F, 0x38, 0x73,
  0xC0, 0xF3, 0x87, 0x7C, 0x0F, 0x70, 0x77, 0x80, 0xF7, 0x07, 0x78, 0x0F,
  0x70, 0x77, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x03, 0xEF,
  0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0x80,
  0x7C, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xC1, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xEF, 0x80, 0x07,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC7, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x03, 0xFE,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x60, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x83, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFB, 0xFF, 0xE0, 0xF9, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFF, 0x8F,
  0x81, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFC, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x1F, 0xC3, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF0,
  0x1F, 0xFC, 0xF8, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F, 0xC3, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x9F, 0x80, 0x3E, 0x1F, 0x80,
  0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0x1F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x06, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x0F, 0xF1, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x0F, 0x9F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0x60, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x21, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x3F, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1E, 0x0F, 0x01, 0xEF, 0xE7,
  0xF0, 0x3D, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3E, 0x1E, 0x0F, 0x07,
  0xC7, 0xC1, 0xE0, 0xF8, 0xF8, 0x3C, 0x1F, 0x1F, 0x07, 0x83, 0xC3, 0xE0,
  0xF0, 0x78, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x7C,
  0x7C, 0x1E, 0x0F, 0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x3E, 0x0E,
  0x0F, 0x87, 0x83, 0xC1, 0xF0, 0xF0, 0x78, 0x3E, 0x3E, 0x0F, 0x07, 0xC7,
  0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0xC3, 0xC1, 0xE0,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x9F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x60, 0x7F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x1F,
  0x80, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE3, 0xFE, 0x01,
  0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7D, 0x81, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xF0, 0x3E,
  0x7F, 0xF0, 0x1F, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xC7, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x03, 0xFE, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x9F, 0xF8, 0x0F, 0xBF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0x7F, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xF9, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xF8,
  0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7B, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83,
  0xCF, 0x83, 0xF0, 0x79, 0xF0, 0xEE, 0x1F, 0x3E, 0x1D, 0xC3, 0xC7, 0xC3,
  0xB8, 0x78, 0xF8, 0xE7, 0x0F, 0x1F, 0x1C, 0xE3, 0xC3, 0xC3, 0x9C, 0x78,
  0x78, 0xE3, 0x8F, 0x0F, 0x1C, 0x73, 0xC1, 0xE3, 0x8E, 0x78, 0x3C, 0xE1,
  0xCF, 0x07, 0x9C, 0x3B, 0xC0, 0xF3, 0x87, 0x78, 0x1E, 0x60, 0xEF, 0x03,
  0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xF8, 0x0F, 0x70, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x9E, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFD, 0xF0, 0x1F, 0xF9, 0xF0, 0x0F, 0xE1, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0x1F, 0xF0, 0x0F, 0x3F, 0xF8, 0x1F,
  0x7F, 0xFC, 0x1F, 0x7C, 0x7C, 0x1F, 0xF8, 0x7E, 0x3E, 0xF8, 0x3F, 0xFE,
  0xF8, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF0,
};

const GFXglyph JetBrainsMono_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 35, 29, 9, -35 },
  { 54, 18, 14, 29, 8, -35 },
  { 86, 28, 35, 29, 1, -35 },
  { 209, 26, 49, 29, 2, -42 },
  { 369, 34, 35, 29, -2, -35 },
  { 518, 27, 36, 29, 1, -36 },
  { 640, 7, 14, 29, 13, -35 },
  { 653, 21, 47, 29, 7, -41 },
  { 777, 20, 47, 29, 2, -41 },
  { 895, 26, 25, 29, 2, -29 },
  { 977, 24, 22, 29, 3, -27 },
  { 1043, 13, 15, 29, 4, -7 },
  { 1068, 16, 5, 29, 7, -18 },
  { 1078, 9, 8, 29, 8, -8 },
  { 1087, 30, 45, 29, 0, -40 },
  { 1256, 26, 36, 29, 2, -36 },
  { 1373, 23, 35, 29, 2, -35 },
  { 1474, 25, 36, 29, 2, -36 },
  { 1587, 25, 35, 29, 2, -35 },
  { 1697, 24, 35, 29, 2, -35 },
  { 1802, 24, 35, 29, 3, -35 },
  { 1907, 24, 35, 29, 2, -35 },
  { 2012, 24, 35, 29, 5, -35 },
  { 2117, 25, 36, 29, 2, -36 },
  { 2230, 24, 36, 29, 4, -36 },
  { 2338, 12, 27, 29, 8, -27 },
  { 2379, 16, 35, 29, 5, -27 },
  { 2449, 23, 26, 29, 4, -29 },
  { 2524, 24, 16, 29, 3, -24 },
  { 2572, 24, 26, 29, 2, -29 },
  { 2650, 20, 35, 29, 6, -35 },
  { 2738, 29, 45, 29, 0, -36 },
  { 2902, 25, 35, 29, 0, -35 },
  { 3012, 26, 35, 29, 2, -35 },
  { 3126, 25, 36, 29, 3, -36 },
  { 3239, 25, 35, 29, 2, -35 },
  { 3349, 27, 35, 29, 2, -35 },
  { 3468, 27, 35, 29, 2, -35 },
  { 3587, 25, 36, 29, 3, -36 },
  { 3700, 26, 35, 29, 2, -35 },
  { 3814, 25, 35, 29, 3, -35 },
  { 3924, 27, 35, 29, 1, -35 },
  { 4043, 28, 35, 29, 2, -35 },
  { 4166, 21, 35, 29, 3, -35 },
  { 4258, 28, 35, 29, 1, -35 },
  { 4381, 26, 35, 29, 2, -35 },
  { 4495, 24, 36, 29, 3, -36 },
  { 4603, 27, 35, 29, 2, -35 },
  { 4722, 26, 45, 29, 2, -36 },
  { 4869, 26, 35, 29, 2, -35 },
  { 4983, 26, 36, 29, 2, -36 },
  { 5100, 25, 35, 29, 5, -35 },
  { 5210, 25, 35, 29, 3, -35 },
  { 5320, 24, 35, 29, 6, -35 },
  { 5425, 28, 35, 29, 3, -35 },
  { 5548, 30, 35, 29, 0, -35 },
  { 5680, 26, 35, 29, 5, -35 },
  { 5794, 26, 35, 29, 2, -35 },
  { 5908, 20, 45, 29, 6, -40 },
  { 6021, 16, 45, 29, 7, -40 },
  { 6111, 20, 45, 29, 4, -40 },
  { 6224, 22, 19, 29, 4, -35 },
  { 6277, 24, 5, 29, 0, 1 },
  { 6292, 10, 7, 29, 12, -38 },
  { 6301, 25, 27, 29, 2, -27 },
  { 6386, 24, 35, 29, 2, -35 },
  { 6491, 23, 27, 29, 3, -27 },
  { 6569, 25, 35, 29, 3, -35 },
  { 6679, 23, 27, 29, 3, -27 },
  { 6757, 32, 44, 29, -2, -35 },
  { 6933, 24, 36, 29, 3, -27 },
  { 7041, 24, 35, 29, 2, -35 },
  { 7146, 23, 38, 29, 2, -38 },
  { 7256, 25, 47, 29, 1, -38 },
  { 7403, 27, 35, 29, 2, -35 },
  { 7522, 21, 35, 29, 4, -35 },
  { 7614, 27, 27, 29, 1, -27 },
  { 7706, 24, 27, 29, 2, -27 },
  { 7787, 23, 27, 29, 3, -27 },
  { 7865, 25, 36, 29, 1, -27 },
  { 7978, 25, 36, 29, 2, -27 },
  { 8091, 24, 27, 29, 3, -27 },
  { 8172, 24, 27, 29, 2, -27 },
  { 8253, 23, 34, 29, 4, -34 },
  { 8351, 24, 26, 29, 3, -26 },
  { 8429, 24, 26, 29, 4, -26 },
  { 8507, 27, 26, 29, 3, -26 },
  { 8595, 28, 26, 29, 0, -26 },
  { 8686, 24, 35, 29, 3, -26 },
  { 8791, 24, 26, 29, 2, -26 },
  { 8869, 25, 45, 29, 4, -40 },
  { 9010, 12, 45, 29, 9, -40 },
  { 9078, 25, 45, 29, 1, -40 },
  { 9219, 24, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_MEDIUMITALIC48PT7B_H_
