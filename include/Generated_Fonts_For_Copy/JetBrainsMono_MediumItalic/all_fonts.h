#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/JetBrainsMono_MediumItalic
// Headers: 67

#include "JetBrainsMono_MediumItalic6pt7b.h"
#include "JetBrainsMono_MediumItalic7pt7b.h"
#include "JetBrainsMono_MediumItalic8pt7b.h"
#include "JetBrainsMono_MediumItalic9pt7b.h"
#include "JetBrainsMono_MediumItalic10pt7b.h"
#include "JetBrainsMono_MediumItalic11pt7b.h"
#include "JetBrainsMono_MediumItalic12pt7b.h"
#include "JetBrainsMono_MediumItalic13pt7b.h"
#include "JetBrainsMono_MediumItalic14pt7b.h"
#include "JetBrainsMono_MediumItalic15pt7b.h"
#include "JetBrainsMono_MediumItalic16pt7b.h"
#include "JetBrainsMono_MediumItalic17pt7b.h"
#include "JetBrainsMono_MediumItalic18pt7b.h"
#include "JetBrainsMono_MediumItalic19pt7b.h"
#include "JetBrainsMono_MediumItalic20pt7b.h"
#include "JetBrainsMono_MediumItalic21pt7b.h"
#include "JetBrainsMono_MediumItalic22pt7b.h"
#include "JetBrainsMono_MediumItalic23pt7b.h"
#include "JetBrainsMono_MediumItalic24pt7b.h"
#include "JetBrainsMono_MediumItalic25pt7b.h"
#include "JetBrainsMono_MediumItalic26pt7b.h"
#include "JetBrainsMono_MediumItalic27pt7b.h"
#include "JetBrainsMono_MediumItalic28pt7b.h"
#include "JetBrainsMono_MediumItalic29pt7b.h"
#include "JetBrainsMono_MediumItalic30pt7b.h"
#include "JetBrainsMono_MediumItalic31pt7b.h"
#include "JetBrainsMono_MediumItalic32pt7b.h"
#include "JetBrainsMono_MediumItalic33pt7b.h"
#include "JetBrainsMono_MediumItalic34pt7b.h"
#include "JetBrainsMono_MediumItalic35pt7b.h"
#include "JetBrainsMono_MediumItalic36pt7b.h"
#include "JetBrainsMono_MediumItalic37pt7b.h"
#include "JetBrainsMono_MediumItalic38pt7b.h"
#include "JetBrainsMono_MediumItalic39pt7b.h"
#include "JetBrainsMono_MediumItalic40pt7b.h"
#include "JetBrainsMono_MediumItalic41pt7b.h"
#include "JetBrainsMono_MediumItalic42pt7b.h"
#include "JetBrainsMono_MediumItalic43pt7b.h"
#include "JetBrainsMono_MediumItalic44pt7b.h"
#include "JetBrainsMono_MediumItalic45pt7b.h"
#include "JetBrainsMono_MediumItalic46pt7b.h"
#include "JetBrainsMono_MediumItalic47pt7b.h"
#include "JetBrainsMono_MediumItalic48pt7b.h"
#include "JetBrainsMono_MediumItalic49pt7b.h"
#include "JetBrainsMono_MediumItalic50pt7b.h"
#include "JetBrainsMono_MediumItalic51pt7b.h"
#include "JetBrainsMono_MediumItalic52pt7b.h"
#include "JetBrainsMono_MediumItalic53pt7b.h"
#include "JetBrainsMono_MediumItalic54pt7b.h"
#include "JetBrainsMono_MediumItalic55pt7b.h"
#include "JetBrainsMono_MediumItalic56pt7b.h"
#include "JetBrainsMono_MediumItalic57pt7b.h"
#include "JetBrainsMono_MediumItalic58pt7b.h"
#include "JetBrainsMono_MediumItalic59pt7b.h"
#include "JetBrainsMono_MediumItalic60pt7b.h"
#include "JetBrainsMono_MediumItalic61pt7b.h"
#include "JetBrainsMono_MediumItalic62pt7b.h"
#include "JetBrainsMono_MediumItalic63pt7b.h"
#include "JetBrainsMono_MediumItalic64pt7b.h"
#include "JetBrainsMono_MediumItalic65pt7b.h"
#include "JetBrainsMono_MediumItalic66pt7b.h"
#include "JetBrainsMono_MediumItalic67pt7b.h"
#include "JetBrainsMono_MediumItalic68pt7b.h"
#include "JetBrainsMono_MediumItalic69pt7b.h"
#include "JetBrainsMono_MediumItalic70pt7b.h"
#include "JetBrainsMono_MediumItalic71pt7b.h"
#include "JetBrainsMono_MediumItalic72pt7b.h"
