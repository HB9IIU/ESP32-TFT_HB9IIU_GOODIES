#ifndef _JETBRAINSMONO_MEDIUMITALIC37PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x3C, 0x3C, 0xF1, 0xF7,
  0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0xF1,
  0xC3, 0xCF, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x38, 0x38, 0x01, 0xE0,
  0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x0E, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3C,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xDB, 0xF0, 0xF9, 0x8F, 0x0F, 0x18, 0xF0, 0xF1,
  0x8F, 0x1F, 0x38, 0x01, 0xF3, 0x80, 0x0F, 0x30, 0x00, 0xFB, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x06, 0x7C, 0x00, 0x63, 0xC0, 0x06, 0x3C, 0x00, 0x63, 0xC7, 0x8E, 0x3C,
  0x78, 0xE3, 0xC7, 0x8C, 0x78, 0x7E, 0xDF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xC1, 0xFE, 0x01, 0xC0, 0xFF,
  0xC0, 0xF0, 0x38, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x07, 0x07, 0x0E, 0x01,
  0xC1, 0xC7, 0x00, 0x70, 0xF3, 0x80, 0x1C, 0x39, 0xC0, 0x07, 0xFE, 0xF0,
  0x00, 0xFF, 0x38, 0x00, 0x1F, 0x9C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0xF7, 0xFC, 0x00,
  0x3B, 0xEF, 0x00, 0x1C, 0xE1, 0xC0, 0x0E, 0x38, 0x70, 0x07, 0x0E, 0x1C,
  0x03, 0x87, 0x07, 0x01, 0xE1, 0xC1, 0xC0, 0x70, 0x70, 0xE0, 0x38, 0x1F,
  0xF8, 0x1C, 0x03, 0xFC, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x7C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xF0, 0xF7, 0x8F, 0x1E,
  0x78, 0xFB, 0xC7, 0x87, 0xBC, 0x70, 0x3F, 0x8F, 0x03, 0xF0, 0xF0, 0x1F,
  0x0F, 0x01, 0xE0, 0xF0, 0x3F, 0x0F, 0x87, 0xF8, 0xFF, 0xF7, 0x87, 0xFE,
  0x7C, 0x3F, 0xC3, 0xC0, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0xBC, 0xF3, 0xCF,
  0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0,
  0x03, 0x80, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x04, 0x07, 0x02, 0x78, 0x70, 0xE7, 0xC6,
  0x7E, 0xFF, 0x6F, 0xF7, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x73, 0x80, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x07,
  0xC1, 0xF0, 0x38, 0x0C, 0x01, 0x00, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0B,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0,
  0x3C, 0xFD, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xF1, 0xF0, 0x3E, 0x3C,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x1C, 0x71, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0x9E, 0x7C, 0xF3, 0xC7,
  0x1E, 0x78, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF,
  0xC1, 0xFB, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x20, 0x78, 0x20, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xC3, 0xE1,
  0xF0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x04, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x3C,
  0x07, 0xC7, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9C, 0x01, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xCF,
  0x80, 0xF7, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x0F, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF3, 0x80, 0x7B, 0xFC, 0x3F, 0xFF, 0x8F,
  0xEF, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x80, 0xF3, 0xF0, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0x80, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xE7,
  0x80, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE1, 0xF0, 0x3E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0,
  0x7C, 0x3E, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0xF8, 0xF8, 0x3C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x03, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0x87, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x03, 0xC7, 0xC0, 0xF8,
  0xFE, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0xF0, 0x07, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x03,
  0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C,
  0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xE1, 0xFF, 0x83, 0xFE, 0x07,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03, 0xE0,
  0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x1F, 0x38, 0xF0, 0x7F, 0x71, 0xE1, 0xFF, 0xE3, 0xC3,
  0x83, 0xC7, 0x0F, 0x07, 0x0E, 0x1C, 0x0E, 0x1C, 0x38, 0x1C, 0x78, 0x70,
  0x38, 0xF0, 0xE0, 0xF1, 0xE3, 0xC1, 0xE3, 0x87, 0x83, 0xC7, 0x0F, 0x07,
  0x0E, 0x1E, 0x1E, 0x3C, 0x3F, 0xFC, 0x78, 0x3F, 0xB8, 0xF0, 0x3E, 0x71,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80,
  0x3C, 0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x07, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x7B, 0xE0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0x07, 0xF1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xC0, 0x7C, 0x78, 0x07, 0x8F,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x79, 0xE0, 0x0F, 0x3C,
  0x03, 0xC7, 0x83, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xF1, 0xF0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xCF,
  0x00, 0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE1, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78,
  0x78, 0x0F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC3, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0xFF, 0x9E, 0x1F, 0xF3, 0xC3, 0xFE, 0x78, 0x03, 0xCF, 0x00, 0xF1,
  0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xE1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x1E, 0x0F,
  0xC3, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0x80,
  0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x80, 0x78,
  0x3C, 0x01, 0xE1, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1F, 0x0F, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1B, 0x03, 0xF1, 0xDC, 0x3B,
  0x8E, 0xE1, 0xFC, 0x77, 0x1D, 0xC3, 0xB8, 0xEE, 0x1D, 0xCE, 0x70, 0xE6,
  0x77, 0x8F, 0x3B, 0xBC, 0x79, 0xF9, 0xE3, 0xCF, 0xCE, 0x1E, 0x7C, 0x70,
  0xF3, 0xE7, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0x07, 0xC0,
  0x78, 0x7E, 0x03, 0xC3, 0xF0, 0x1C, 0x1F, 0x80, 0xE0, 0xFE, 0x0F, 0x07,
  0xF0, 0x78, 0x3B, 0x83, 0xC3, 0xDC, 0x1E, 0x1E, 0xE0, 0xF0, 0xF7, 0x07,
  0x07, 0xBC, 0x78, 0x3C, 0xE3, 0xC1, 0xC7, 0x1E, 0x1E, 0x38, 0xF0, 0xF1,
  0xC7, 0x87, 0x8F, 0x38, 0x3C, 0x39, 0xC1, 0xE1, 0xDE, 0x0E, 0x0E, 0xF0,
  0x70, 0x77, 0x87, 0x83, 0xFC, 0x3C, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F, 0x03,
  0xF0, 0x70, 0x1F, 0x83, 0x80, 0xFC, 0x3C, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xC7,
  0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xF0,
  0x1E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x7E,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xF1, 0xF0,
  0x3E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x7C, 0x3C, 0x07, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0xC3, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0xC3,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x83, 0xC0, 0x70, 0x78, 0x0E, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x3C, 0x3D, 0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0x9E, 0x1F,
  0x0E, 0x78, 0x78, 0x79, 0xE3, 0xE1, 0xE7, 0x8D, 0x87, 0x1C, 0x36, 0x1C,
  0x70, 0xD8, 0xF1, 0xC7, 0x63, 0xC7, 0x19, 0x8E, 0x1C, 0x66, 0x38, 0x73,
  0x99, 0xE1, 0xCC, 0x67, 0x07, 0x31, 0x9C, 0x1C, 0xC6, 0x70, 0x77, 0x1B,
  0xC1, 0xD8, 0x6E, 0x0F, 0x61, 0xB8, 0x3F, 0x8E, 0xE0, 0xFE, 0x3F, 0x83,
  0xF0, 0xFC, 0x0E, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1F,
  0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0xF8, 0x00, 0xF1, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0xF8, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xF0, 0x1F,
  0x01, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x80, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x78, 0x01, 0xEF, 0x80, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3B,
  0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x1E, 0x78, 0x1E, 0x1C, 0x0E, 0x0E, 0x0F,
  0x07, 0x0F, 0x03, 0xC7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x00, 0xE0,
  0x00, 0xFF, 0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x7C, 0x78, 0x0F,
  0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78,
  0xF8, 0x1F, 0x0F, 0x87, 0xE1, 0xFF, 0xBC, 0x1F, 0xF7, 0x81, 0xF8, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC7, 0x80, 0x7B, 0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7,
  0xC0, 0x3C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x0F,
  0x7F, 0xC3, 0xE7, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x7B, 0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE1, 0xE0, 0x7F,
  0x9E, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1E, 0x07, 0xC3, 0xC0, 0x7C, 0x3C,
  0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x8F, 0x80, 0xF0,
  0xF8, 0x1F, 0x07, 0xC3, 0xF0, 0x7F, 0xEF, 0x03, 0xFE, 0xF0, 0x1F, 0x8F,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x07,
  0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x1F, 0x07, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C,
  0x78, 0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3,
  0xE0, 0xF8, 0x7F, 0xFF, 0x07, 0xFD, 0xE0, 0xFF, 0x3C, 0x03, 0x87, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0x00,
  0x7B, 0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x0F, 0x8F, 0x81, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x11, 0xE0, 0x1E, 0x1E, 0x03, 0xE3, 0xC0,
  0x7C, 0x3C, 0x0F, 0x83, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C,
  0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x78, 0xF8, 0x07,
  0x87, 0x80, 0x78, 0x7C, 0x0F, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xE1, 0xC1, 0xDF, 0x3E, 0x3F, 0xF7, 0xF3, 0xE7, 0xCF,
  0x3C, 0x78, 0xF3, 0xC7, 0x0F, 0x38, 0x70, 0xF3, 0x87, 0x0F, 0x38, 0x70,
  0xE7, 0x87, 0x0E, 0x78, 0x71, 0xE7, 0x8F, 0x1E, 0x78, 0xE1, 0xE7, 0x0E,
  0x1E, 0x70, 0xE1, 0xCF, 0x0E, 0x1C, 0xF0, 0xE1, 0xCF, 0x0E, 0x3C, 0xF1,
  0xC3, 0xCE, 0x1C, 0x3C, 0xE1, 0xC3, 0x80, 0x00, 0x0C, 0x01, 0xEF, 0xF0,
  0x7B, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x78, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x07, 0xCF, 0x01, 0xF3, 0xC0,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7B, 0xE0, 0x3C, 0xF8, 0x1F, 0x1F,
  0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x7B, 0xFC, 0x0F, 0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0,
  0x3C, 0x3E, 0x03, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0x83, 0xDF, 0xF0, 0x3C,
  0xFC, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x3C,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xE0, 0xFC, 0x78, 0x0F, 0x8F, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF8, 0x1F, 0x0F,
  0x87, 0xE1, 0xFF, 0xBC, 0x1F, 0xF7, 0x81, 0xF8, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x0F, 0xFF, 0xE1,
  0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFF, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0xF0, 0x0F, 0x3E, 0x07, 0xCF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x3E, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x1F,
  0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x0E, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xC7, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xE0, 0xE0, 0xFE, 0x1E, 0x0E, 0xE1, 0xE0, 0xEE, 0x1E,
  0x1E, 0xE3, 0xE1, 0xCE, 0x36, 0x1C, 0xE3, 0x63, 0xCE, 0x76, 0x38, 0xE6,
  0x63, 0x8E, 0x66, 0x78, 0xE6, 0x67, 0x0E, 0xC6, 0x70, 0xEC, 0x67, 0x0E,
  0xC6, 0xE0, 0xFC, 0x6E, 0x0F, 0x86, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x7C, 0x0F, 0x07, 0x80, 0x0F, 0x80, 0xFC, 0x1E, 0x03, 0xC0, 0x7C,
  0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x07, 0xBE, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x78, 0xF0, 0x03, 0xC3,
  0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF8,
  0x3E, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC3,
  0xFF, 0xF8, 0x3F, 0xEF, 0x03, 0xF9, 0xE0, 0x18, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x88, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xE7,
  0xF8, 0x3D, 0xFF, 0x87, 0xBC, 0xF0, 0xFF, 0x0F, 0x3D, 0xE1, 0xFF, 0xBC,
  0x1F, 0xE7, 0x81, 0xF0,
};

const GFXglyph JetBrainsMono_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 14, 11, 22, 6, -27 },
  { 52, 22, 27, 22, 1, -27 },
  { 127, 20, 37, 22, 1, -32 },
  { 220, 26, 27, 22, -1, -27 },
  { 308, 20, 27, 22, 1, -27 },
  { 376, 6, 11, 22, 10, -27 },
  { 385, 15, 36, 22, 6, -31 },
  { 453, 15, 36, 22, 2, -31 },
  { 521, 20, 20, 22, 2, -23 },
  { 571, 19, 18, 22, 2, -21 },
  { 614, 10, 12, 22, 3, -6 },
  { 629, 13, 4, 22, 5, -14 },
  { 636, 7, 6, 22, 6, -6 },
  { 642, 23, 35, 22, 0, -31 },
  { 743, 19, 27, 22, 2, -27 },
  { 808, 17, 27, 22, 2, -27 },
  { 866, 19, 27, 22, 2, -27 },
  { 931, 19, 27, 22, 2, -27 },
  { 996, 18, 27, 22, 2, -27 },
  { 1057, 19, 27, 22, 2, -27 },
  { 1122, 18, 27, 22, 2, -27 },
  { 1183, 19, 27, 22, 4, -27 },
  { 1248, 19, 27, 22, 2, -27 },
  { 1313, 19, 27, 22, 3, -27 },
  { 1378, 10, 21, 22, 6, -21 },
  { 1405, 13, 27, 22, 3, -21 },
  { 1449, 18, 20, 22, 3, -22 },
  { 1494, 18, 13, 22, 2, -19 },
  { 1524, 18, 20, 22, 2, -22 },
  { 1569, 15, 27, 22, 5, -27 },
  { 1620, 23, 34, 22, 0, -27 },
  { 1718, 19, 27, 22, 0, -27 },
  { 1783, 19, 27, 22, 2, -27 },
  { 1848, 19, 27, 22, 2, -27 },
  { 1913, 20, 27, 22, 1, -27 },
  { 1981, 20, 27, 22, 2, -27 },
  { 2049, 20, 27, 22, 2, -27 },
  { 2117, 19, 27, 22, 2, -27 },
  { 2182, 20, 27, 22, 2, -27 },
  { 2250, 19, 27, 22, 2, -27 },
  { 2315, 21, 27, 22, 0, -27 },
  { 2386, 22, 27, 22, 1, -27 },
  { 2461, 17, 27, 22, 2, -27 },
  { 2519, 21, 27, 22, 1, -27 },
  { 2590, 21, 27, 22, 1, -27 },
  { 2661, 19, 27, 22, 2, -27 },
  { 2726, 21, 27, 22, 1, -27 },
  { 2797, 19, 34, 22, 2, -27 },
  { 2878, 21, 27, 22, 1, -27 },
  { 2949, 21, 27, 22, 1, -27 },
  { 3020, 19, 27, 22, 4, -27 },
  { 3085, 20, 27, 22, 2, -27 },
  { 3153, 19, 27, 22, 4, -27 },
  { 3218, 22, 27, 22, 2, -27 },
  { 3293, 23, 27, 22, 0, -27 },
  { 3371, 20, 27, 22, 4, -27 },
  { 3439, 20, 27, 22, 1, -27 },
  { 3507, 15, 35, 22, 5, -31 },
  { 3573, 11, 35, 22, 6, -31 },
  { 3622, 15, 35, 22, 3, -31 },
  { 3688, 17, 14, 22, 3, -27 },
  { 3718, 18, 3, 22, 0, 1 },
  { 3725, 8, 5, 22, 9, -29 },
  { 3730, 19, 21, 22, 2, -21 },
  { 3780, 19, 27, 22, 1, -27 },
  { 3845, 18, 21, 22, 2, -21 },
  { 3893, 20, 27, 22, 2, -27 },
  { 3961, 18, 21, 22, 2, -21 },
  { 4009, 25, 34, 22, -2, -27 },
  { 4116, 19, 28, 22, 2, -21 },
  { 4183, 19, 27, 22, 1, -27 },
  { 4248, 18, 29, 22, 1, -29 },
  { 4314, 20, 36, 22, 0, -29 },
  { 4404, 20, 27, 22, 2, -27 },
  { 4472, 16, 27, 22, 3, -27 },
  { 4526, 20, 21, 22, 1, -21 },
  { 4579, 19, 21, 22, 1, -21 },
  { 4629, 18, 21, 22, 2, -21 },
  { 4677, 20, 28, 22, 0, -21 },
  { 4747, 19, 28, 22, 2, -21 },
  { 4814, 19, 21, 22, 2, -21 },
  { 4864, 18, 21, 22, 2, -21 },
  { 4912, 18, 26, 22, 3, -26 },
  { 4971, 19, 20, 22, 2, -20 },
  { 5019, 19, 20, 22, 3, -20 },
  { 5067, 20, 20, 22, 3, -20 },
  { 5117, 22, 20, 22, 0, -20 },
  { 5172, 19, 27, 22, 2, -20 },
  { 5237, 19, 20, 22, 1, -20 },
  { 5285, 19, 35, 22, 3, -31 },
  { 5369, 9, 35, 22, 7, -31 },
  { 5409, 19, 35, 22, 1, -31 },
  { 5493, 19, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_MEDIUMITALIC37PT7B_H_
