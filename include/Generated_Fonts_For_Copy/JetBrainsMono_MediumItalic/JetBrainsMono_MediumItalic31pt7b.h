#ifndef _JETBRAINSMONO_MEDIUMITALIC31PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3,
  0x87, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x8F, 0x9F, 0x3C, 0x00, 0x78, 0xF7,
  0x8E, 0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x61, 0xCE,
  0x1C, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x06, 0x0C, 0x03, 0x87,
  0x00, 0xE1, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0x83, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x93, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0E, 0x1C, 0x03, 0x06, 0x01, 0xC3, 0x80, 0x60, 0xE0,
  0x18, 0x30, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x1E, 0xDE, 0x1E, 0x67,
  0x8E, 0x33, 0xC7, 0x18, 0x03, 0x98, 0x01, 0xEC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x67, 0x80, 0x31, 0xC0,
  0x18, 0xE3, 0x8C, 0x73, 0xC6, 0x78, 0xF3, 0x78, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xF8, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x1C, 0x1F, 0x80, 0xE0, 0xFF, 0x07, 0x07, 0x1C, 0x38, 0x1C, 0x70,
  0xC0, 0x61, 0xC6, 0x01, 0x87, 0x30, 0x06, 0x19, 0xC0, 0x1F, 0xEE, 0x00,
  0x7F, 0x70, 0x00, 0x33, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xBF, 0x00, 0x1D, 0xFC, 0x00, 0xEE, 0x38, 0x07, 0x38, 0xE0, 0x38, 0xC3,
  0x80, 0xC3, 0x0E, 0x06, 0x0C, 0x30, 0x38, 0x39, 0xC1, 0xC0, 0xFE, 0x0E,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xE3, 0xC0,
  0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xF0, 0x07, 0xB8, 0x7B, 0x9E, 0x7B, 0xC7, 0xB9, 0xE1,
  0xF8, 0xE0, 0xFC, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x1F, 0x0F, 0xFF, 0xC3,
  0xFE, 0xE0, 0xFC, 0x38, 0x7F, 0xFF, 0xFE, 0xEE, 0xEC, 0x00, 0x18, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x0C, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0x01, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC1, 0xF1, 0x8F, 0xFD,
  0xBF, 0xFF, 0x7E, 0x1F, 0xF0, 0x03, 0x80, 0x0E, 0xC0, 0x1C, 0xE0, 0x3C,
  0xF0, 0x78, 0xF0, 0x70, 0x78, 0x20, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x0F, 0x1F, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3D, 0xF7, 0xDF, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x73, 0x8E, 0x73, 0xCE, 0x73, 0x9E, 0xF1, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xFF, 0xF0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xF7, 0x83,
  0x8E, 0x06, 0x1C, 0x10, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xF0,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x38,
  0x0F, 0x1C, 0x07, 0x0F, 0x07, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x71, 0xE0, 0xE7, 0x81,
  0xDE, 0x03, 0xB8, 0x0F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x39, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0xE0, 0x38, 0xF0, 0x78,
  0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0xF8, 0x1D, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x0F,
  0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x70, 0x0E,
  0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0,
  0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1E, 0x0E, 0x07, 0x9E, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xF1, 0xE0, 0xE0, 0x78, 0xF0, 0x1C,
  0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x8F, 0x07, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0x81,
  0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF7,
  0xC7, 0xC7, 0xFF, 0x87, 0xEE, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x7C, 0x7C, 0xFC, 0x78, 0x07, 0xC1, 0xF0, 0xFC, 0x1E, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC1, 0xE0, 0x78,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x10, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x3E, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0x80,
  0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x3E,
  0xC7, 0x0F, 0xD8, 0xE3, 0xCF, 0x1C, 0x70, 0xE7, 0x0C, 0x1C, 0xE3, 0x83,
  0x9C, 0x70, 0x73, 0x8E, 0x0C, 0x71, 0xC3, 0x8E, 0x38, 0x71, 0x87, 0x1E,
  0x70, 0xFF, 0xCE, 0x0F, 0xB9, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xDC,
  0x01, 0xDC, 0x03, 0xDC, 0x03, 0x9E, 0x03, 0x8E, 0x07, 0x0E, 0x07, 0x0E,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x0E,
  0x38, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0x0F, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x78, 0xE0, 0x3C, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x07,
  0x1C, 0x07, 0x8E, 0x07, 0x87, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x80, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x38,
  0x0F, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0xF0,
  0x38, 0xF0, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x83, 0xC7, 0xE1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C,
  0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x01, 0xE3, 0x80,
  0xF1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x0F, 0x1C,
  0x07, 0x0E, 0x0F, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F,
  0x38, 0x0F, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x71, 0xFE,
  0x71, 0xFE, 0x71, 0xFC, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C,
  0xF0, 0x38, 0xF0, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0E,
  0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x87, 0x01, 0xE1, 0xE0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x0E, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x0F,
  0x07, 0x07, 0x81, 0xC1, 0xE0, 0x70, 0xF0, 0x1C, 0x78, 0x0F, 0x1E, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0E, 0x3C, 0x03, 0x87, 0x01, 0xE1,
  0xE0, 0x78, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x1C,
  0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03,
  0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x1B, 0x0D, 0x8E, 0xC7, 0xE3,
  0xB1, 0xB8, 0xEC, 0xEE, 0x3B, 0xB3, 0x8E, 0xFD, 0xC3, 0xBE, 0x71, 0xE7,
  0x9C, 0x71, 0xC7, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E,
  0x01, 0xC0, 0x0F, 0x03, 0x87, 0x81, 0xC7, 0xC0, 0xE3, 0xF0, 0x71, 0xF8,
  0x38, 0xFC, 0x3C, 0x7E, 0x1C, 0x3B, 0x0E, 0x3D, 0xC7, 0x1C, 0xE3, 0x8E,
  0x71, 0xC7, 0x39, 0xE3, 0x8C, 0xE1, 0xC6, 0x71, 0xE3, 0xB8, 0xE1, 0xDC,
  0x70, 0xEE, 0x38, 0x77, 0x1C, 0x1B, 0x0E, 0x0F, 0x87, 0x07, 0xC7, 0x83,
  0xE3, 0x81, 0xF0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70,
  0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xE0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x78, 0x7E, 0x1E, 0x07,
  0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x01, 0xE3,
  0xC0, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E,
  0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xFF, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x0F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xF1,
  0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x07,
  0x8F, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x80, 0xE3, 0xC0, 0xF0,
  0xE0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x87, 0x03, 0xC7,
  0x80, 0xE3, 0xC0, 0x78, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE1,
  0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0x8F, 0x07, 0x87, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xE0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC0, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x38, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xE0, 0x70,
  0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x73, 0x80, 0x77,
  0x00, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70,
  0xE1, 0xDC, 0x38, 0x77, 0x1E, 0x1D, 0xC7, 0x8E, 0x71, 0xE3, 0x98, 0x58,
  0xE6, 0x36, 0x39, 0x8D, 0x9C, 0xE3, 0x67, 0x39, 0x99, 0xCE, 0x66, 0x63,
  0x99, 0xB8, 0xE6, 0x6E, 0x3B, 0x1B, 0x8E, 0xC4, 0xC3, 0xB3, 0x70, 0xF8,
  0xDC, 0x3E, 0x37, 0x0F, 0x8D, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C,
  0x0F, 0x0F, 0x00, 0x0E, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x03, 0x83,
  0xC0, 0x78, 0x78, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x1E, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x0F, 0x3C, 0x01, 0xC3, 0x80, 0x78, 0x70,
  0x1E, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0xF0, 0x07,
  0xF8, 0x03, 0x9C, 0x03, 0xCE, 0x03, 0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0xE0,
  0xE0, 0x78, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE2, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x3E, 0x01, 0xF8, 0x0E, 0x60, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x38,
  0x31, 0xE0, 0xE7, 0x03, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF1, 0xE3, 0x8F, 0x0F, 0xCE, 0x3F, 0xDC, 0xFF, 0xB9, 0xE1, 0xF7, 0x81,
  0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x01, 0xEE, 0x03, 0x9E, 0x0F, 0x3F, 0xFE, 0x3F, 0xDC, 0x3F, 0x78, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0xFC, 0x1D, 0xFE, 0x1F, 0xFE, 0x3E, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x7F, 0xF8, 0xFF, 0xF8, 0xF7, 0xE0, 0x07, 0xF8, 0x3F,
  0xF8, 0xFF, 0xF1, 0xE0, 0xF7, 0x81, 0xEE, 0x03, 0xDC, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x01, 0xEF, 0x03, 0xDE, 0x0F, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0xCE, 0x1F, 0xEE, 0x3F, 0xEE, 0x3C,
  0x3E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xFF, 0xF8, 0x7F,
  0xB8, 0x3F, 0x78, 0x07, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xC0, 0xE7, 0x81,
  0xEE, 0x03, 0xDC, 0x07, 0x3F, 0xFE, 0xFF, 0xFD, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x0F, 0x1F, 0x7C, 0x3F, 0xF0, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xFF,
  0xB9, 0xE0, 0xF7, 0x81, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x1D,
  0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x87, 0x8F, 0xFF, 0x1F, 0xEE, 0x0F,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x87, 0xFE, 0x0F, 0xF8,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0xFC, 0x1D, 0xFE, 0x1F, 0xFE, 0x3E, 0x0F, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x1E, 0x38, 0x1E, 0x1C, 0x0E, 0x1E, 0x0F, 0x0F,
  0x0F, 0x07, 0x8F, 0x03, 0x8F, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x78, 0xF0, 0x3C, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x03, 0xC3, 0x81,
  0xE3, 0xC0, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x1D, 0xE7, 0x87, 0xFB, 0xE1, 0xCF, 0x3C,
  0x71, 0x8F, 0x38, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x30, 0xE7, 0x8C, 0x71, 0xC3, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0xF1, 0x8F, 0x00, 0x1C, 0xFC, 0x1D, 0xFE,
  0x1F, 0xFE, 0x3E, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1,
  0xE0, 0xE7, 0x81, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0,
  0x3B, 0xC0, 0xF7, 0x01, 0xEE, 0x03, 0x9E, 0x0F, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xC0, 0x0E, 0x7E, 0x07, 0x7F, 0x83, 0xFF, 0xC3, 0xE0, 0xF1, 0xE0,
  0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7B, 0xF0, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xFF, 0xB9, 0xC1, 0xF7, 0x81,
  0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x01, 0xEE, 0x03, 0x9E, 0x0F, 0x3F, 0xEE, 0x3F, 0xDC, 0x3F, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x3D,
  0xFC, 0x3B, 0xFE, 0x3F, 0xFE, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x78,
  0x0E, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0x3F, 0x1C, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x70,
  0x1C, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x3B, 0xC0, 0xF7, 0x81,
  0xEE, 0x03, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x3B, 0xC0, 0xF7,
  0x01, 0xEF, 0x03, 0x9E, 0x0F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0xE0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x77, 0x81, 0xE7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C,
  0x38, 0x78, 0x78, 0xE0, 0xF3, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07,
  0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0xF0, 0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x36, 0x33, 0x9B, 0x39, 0xCD, 0x9C,
  0xEC, 0xCC, 0x76, 0x6E, 0x3B, 0x37, 0x1F, 0x1B, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0x1E, 0x03, 0xC3, 0xC1,
  0xE0, 0xF0, 0xF0, 0x1E, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x0F,
  0x38, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x0F, 0x00, 0x38,
  0x0E, 0x70, 0x1D, 0xE0, 0x3B, 0xC0, 0xF7, 0x01, 0xEE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF, 0x8F, 0x8F,
  0xF7, 0x1F, 0xEE, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x07, 0x7F, 0x0E, 0xF7, 0x8E,
  0xE3, 0xCE, 0xE1, 0xFC, 0xE0, 0xF8,
};

const GFXglyph JetBrainsMono_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 12, 10, 19, 5, -23 },
  { 37, 18, 23, 19, 1, -23 },
  { 89, 17, 31, 19, 1, -27 },
  { 155, 22, 23, 19, -1, -23 },
  { 219, 17, 23, 19, 1, -23 },
  { 268, 4, 10, 19, 9, -23 },
  { 273, 13, 30, 19, 5, -26 },
  { 322, 13, 30, 19, 2, -26 },
  { 371, 16, 16, 19, 2, -19 },
  { 403, 15, 15, 19, 2, -18 },
  { 432, 8, 10, 19, 3, -5 },
  { 442, 11, 3, 19, 4, -12 },
  { 447, 6, 5, 19, 5, -5 },
  { 451, 19, 29, 19, 0, -26 },
  { 520, 16, 23, 19, 2, -23 },
  { 566, 15, 23, 19, 1, -23 },
  { 610, 17, 23, 19, 1, -23 },
  { 659, 17, 23, 19, 1, -23 },
  { 708, 15, 23, 19, 2, -23 },
  { 752, 16, 23, 19, 2, -23 },
  { 798, 16, 23, 19, 1, -23 },
  { 844, 16, 23, 19, 3, -23 },
  { 890, 17, 23, 19, 1, -23 },
  { 939, 15, 23, 19, 3, -23 },
  { 983, 8, 17, 19, 5, -17 },
  { 1000, 10, 22, 19, 3, -17 },
  { 1028, 16, 17, 19, 2, -19 },
  { 1062, 15, 11, 19, 2, -16 },
  { 1083, 16, 17, 19, 1, -19 },
  { 1117, 13, 23, 19, 4, -23 },
  { 1155, 19, 29, 19, 0, -23 },
  { 1224, 16, 23, 19, 0, -23 },
  { 1270, 17, 23, 19, 1, -23 },
  { 1319, 16, 23, 19, 2, -23 },
  { 1365, 17, 23, 19, 1, -23 },
  { 1414, 16, 23, 19, 2, -23 },
  { 1460, 18, 23, 19, 1, -23 },
  { 1512, 16, 23, 19, 2, -23 },
  { 1558, 17, 23, 19, 1, -23 },
  { 1607, 16, 23, 19, 2, -23 },
  { 1653, 18, 23, 19, 0, -23 },
  { 1705, 18, 23, 19, 1, -23 },
  { 1757, 14, 23, 19, 2, -23 },
  { 1798, 18, 23, 19, 1, -23 },
  { 1850, 17, 23, 19, 1, -23 },
  { 1899, 16, 23, 19, 2, -23 },
  { 1945, 18, 23, 19, 1, -23 },
  { 1997, 16, 29, 19, 2, -23 },
  { 2055, 17, 23, 19, 1, -23 },
  { 2104, 17, 23, 19, 1, -23 },
  { 2153, 16, 23, 19, 3, -23 },
  { 2199, 16, 23, 19, 2, -23 },
  { 2245, 16, 23, 19, 4, -23 },
  { 2291, 18, 23, 19, 2, -23 },
  { 2343, 19, 23, 19, 0, -23 },
  { 2398, 17, 23, 19, 3, -23 },
  { 2447, 17, 23, 19, 1, -23 },
  { 2496, 13, 29, 19, 4, -26 },
  { 2544, 10, 29, 19, 5, -26 },
  { 2581, 12, 29, 19, 3, -26 },
  { 2625, 14, 12, 19, 3, -23 },
  { 2646, 15, 3, 19, 0, 1 },
  { 2652, 6, 4, 19, 8, -24 },
  { 2655, 15, 17, 19, 2, -17 },
  { 2687, 16, 23, 19, 1, -23 },
  { 2733, 15, 17, 19, 2, -17 },
  { 2765, 16, 23, 19, 2, -23 },
  { 2811, 15, 17, 19, 2, -17 },
  { 2843, 22, 29, 19, -2, -23 },
  { 2923, 15, 23, 19, 2, -17 },
  { 2967, 16, 23, 19, 1, -23 },
  { 3013, 15, 24, 19, 1, -24 },
  { 3058, 17, 30, 19, 0, -24 },
  { 3122, 17, 23, 19, 1, -23 },
  { 3171, 13, 23, 19, 3, -23 },
  { 3209, 18, 17, 19, 0, -17 },
  { 3248, 16, 17, 19, 1, -17 },
  { 3282, 15, 17, 19, 2, -17 },
  { 3314, 17, 23, 19, 0, -17 },
  { 3363, 15, 23, 19, 2, -17 },
  { 3407, 16, 17, 19, 2, -17 },
  { 3441, 16, 17, 19, 1, -17 },
  { 3475, 16, 22, 19, 2, -22 },
  { 3519, 15, 17, 19, 2, -17 },
  { 3551, 15, 17, 19, 3, -17 },
  { 3583, 17, 17, 19, 2, -17 },
  { 3620, 18, 17, 19, 0, -17 },
  { 3659, 15, 23, 19, 2, -17 },
  { 3703, 16, 17, 19, 1, -17 },
  { 3737, 16, 29, 19, 3, -26 },
  { 3795, 8, 29, 19, 6, -26 },
  { 3824, 16, 29, 19, 1, -26 },
  { 3882, 16, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_MEDIUMITALIC31PT7B_H_
