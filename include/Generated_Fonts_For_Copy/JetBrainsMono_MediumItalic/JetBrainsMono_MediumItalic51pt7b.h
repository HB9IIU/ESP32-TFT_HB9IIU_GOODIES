#ifndef _JETBRAINSMONO_MEDIUMITALIC51PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x07,
  0xE0, 0x00, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xDD,
  0xFE, 0x03, 0xF1, 0xCF, 0xE0, 0x7E, 0x3C, 0x7E, 0x07, 0xC3, 0x87, 0xE0,
  0xFC, 0x38, 0x7E, 0x0F, 0xC3, 0x80, 0x00, 0xFC, 0x38, 0x00, 0x0F, 0xC3,
  0x80, 0x00, 0xFC, 0x78, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xE7, 0xF0, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0xE1, 0xF8, 0x00,
  0x1E, 0x1F, 0x80, 0x01, 0xC1, 0xF8, 0x7C, 0x1C, 0x1F, 0x8F, 0xC1, 0xC1,
  0xF0, 0xFC, 0x1C, 0x3F, 0x07, 0xE1, 0xC3, 0xF0, 0x7F, 0x3C, 0xFE, 0x07,
  0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x0F,
  0xFE, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x3C, 0x00, 0x78, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0xF8, 0x00, 0x78,
  0x1E, 0x1F, 0x00, 0x07, 0x81, 0xE1, 0xE0, 0x00, 0x78, 0x1E, 0x3C, 0x00,
  0x07, 0xC7, 0xC7, 0x80, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x03, 0xFF, 0x9E,
  0x00, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0xFF, 0x80, 0x00, 0x0F, 0x9F,
  0xFC, 0x00, 0x01, 0xF3, 0xFF, 0xE0, 0x00, 0x1E, 0x7C, 0x3E, 0x00, 0x03,
  0xC7, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xF0,
  0x3E, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3C, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x11, 0xFB, 0xF0, 0x3F, 0x1F, 0x8F, 0xC1,
  0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x7E, 0x07, 0xCF, 0x83,
  0xF0, 0x3F, 0xF8, 0x1F, 0x00, 0xFF, 0xC0, 0xF8, 0x07, 0xFC, 0x07, 0xC0,
  0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xE1, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x78, 0x0E, 0x3F, 0x07, 0x83, 0xE3, 0xF8, 0x70, 0xFE, 0x7F,
  0xE7, 0x3F, 0xFF, 0xFF, 0x6F, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0x00, 0x78, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x04, 0x0F, 0xC7, 0xF9, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFC, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x1E, 0x0F,
  0x8F, 0x8F, 0xC3, 0xE3, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x1F, 0x07, 0x87, 0xC7, 0xC0, 0x41, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFD, 0xF8, 0x07, 0xF1, 0xF0, 0x07, 0xE1, 0xF0,
  0x07, 0x81, 0xF0, 0x07, 0x03, 0xF0, 0x0C, 0x03, 0xF0, 0x08, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x81,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xC7,
  0xF0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE7, 0xFC, 0x01, 0xFB, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF,
  0xF0, 0x0F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xE0,
  0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF3, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0xDF, 0x80,
  0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xE0,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0x87, 0xC0,
  0x3F, 0xCF, 0x0F, 0x80, 0xFF, 0xDE, 0x1F, 0x03, 0xFF, 0xBC, 0x3E, 0x0F,
  0xC1, 0xF8, 0x7C, 0x1F, 0x01, 0xF0, 0xF0, 0x3C, 0x03, 0xE3, 0xE0, 0xF8,
  0x07, 0x87, 0xC1, 0xF0, 0x0F, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x07, 0xC0,
  0x7C, 0x3E, 0x0F, 0x80, 0xF8, 0x78, 0x1E, 0x01, 0xF0, 0xF0, 0x3C, 0x03,
  0xC3, 0xE0, 0xF8, 0x07, 0x87, 0xC1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x3E,
  0x1F, 0x07, 0xC0, 0xFC, 0x3C, 0x0F, 0xE7, 0xF8, 0x78, 0x0F, 0xFD, 0xE1,
  0xF0, 0x0F, 0xFB, 0xC3, 0xE0, 0x0F, 0xC7, 0x87, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9E,
  0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0x80, 0x1F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xF0, 0x3E, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xE0, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x3F, 0xFE, 0x3E, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC7, 0xE0, 0xFF, 0xF1,
  0xF8, 0x40, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xF3, 0xFE, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xCF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xB8, 0x07, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x81, 0xEF, 0x07, 0xBE, 0x07, 0xBC, 0x1E, 0xF8, 0x3E, 0xF0, 0x7B, 0xC0,
  0xFB, 0xC3, 0xCF, 0x03, 0xE7, 0x0F, 0x7C, 0x0F, 0x9E, 0x79, 0xF0, 0x3E,
  0x79, 0xE7, 0xC0, 0xF9, 0xEF, 0x1F, 0x03, 0xC7, 0xBC, 0xF8, 0x1F, 0x1E,
  0xE3, 0xE0, 0x7C, 0x7F, 0x8F, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0xC3, 0xF0,
  0xF8, 0x1F, 0x0F, 0xC7, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x1F,
  0x07, 0xF8, 0x01, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xFC, 0x03, 0xE0, 0x7F,
  0xC0, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0x7B, 0xC0, 0x3E, 0x0F, 0xBC, 0x03,
  0xE0, 0xFB, 0xE0, 0x7E, 0x0F, 0xBE, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F,
  0x9E, 0x07, 0xC0, 0xF9, 0xE0, 0x7C, 0x1F, 0x9F, 0x07, 0xC1, 0xF1, 0xF0,
  0x7C, 0x1F, 0x1F, 0x0F, 0xC1, 0xF0, 0xF0, 0xF8, 0x1F, 0x0F, 0x0F, 0x81,
  0xF0, 0xF8, 0xF8, 0x3F, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x07,
  0x9F, 0x83, 0xE0, 0x79, 0xF0, 0x3E, 0x07, 0x9F, 0x03, 0xE0, 0x7D, 0xF0,
  0x3E, 0x07, 0xDF, 0x07, 0xE0, 0x3D, 0xF0, 0x7C, 0x03, 0xDF, 0x07, 0xC0,
  0x3D, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE,
  0x0F, 0xC0, 0x1F, 0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x1F, 0xC0, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x7C,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x81,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7C, 0xF0, 0x1F, 0x81, 0xF3,
  0xC0, 0x7E, 0x07, 0x8F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0,
  0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x1F, 0x07, 0x70, 0x7C, 0x7C, 0x1D,
  0xC1, 0xF1, 0xF0, 0x77, 0x07, 0xC7, 0xC3, 0xDC, 0x1E, 0x1F, 0x0E, 0x70,
  0xF8, 0x7C, 0x39, 0xC3, 0xE1, 0xF0, 0xE7, 0x0F, 0x07, 0xC7, 0x9C, 0x3C,
  0x1F, 0x1C, 0x71, 0xF0, 0x78, 0x71, 0xC7, 0xC1, 0xE3, 0xC7, 0x1E, 0x07,
  0x8E, 0x1C, 0x78, 0x1E, 0x38, 0x73, 0xE0, 0x78, 0xE3, 0xCF, 0x81, 0xE7,
  0x8F, 0x3C, 0x07, 0x9C, 0x3C, 0xF0, 0x1E, 0x70, 0xF7, 0xC0, 0xFB, 0xC3,
  0x9F, 0x03, 0xEE, 0x0E, 0x78, 0x0F, 0xB8, 0x39, 0xE0, 0x3E, 0xE0, 0xEF,
  0x80, 0xFF, 0x83, 0xBC, 0x03, 0xFC, 0x0E, 0xF0, 0x0F, 0x70, 0x3B, 0xC0,
  0x3D, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x3F, 0xFC,
  0xF8, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0xEF, 0x83, 0xFC, 0x7F, 0xE1, 0xFC,
  0x07, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x8F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xF3, 0xE0, 0x0F, 0xF0,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xC0, 0x03, 0xF1,
  0xFF, 0x00, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x0F, 0xBF, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0x7F, 0xFE, 0x0F, 0xDF, 0xFF, 0x03, 0xF3,
  0xFF, 0x80, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x08,
  0x0F, 0xC0, 0x1F, 0xF1, 0xF0, 0x0F, 0xFF, 0x3E, 0x03, 0xFF, 0xF7, 0xC0,
  0xFF, 0xFE, 0xF8, 0x1F, 0xE3, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFC, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x8F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFB, 0xE0, 0x1F, 0xFE, 0x7C, 0x00, 0xFF, 0x0F, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x3F, 0xFC, 0xF8, 0x1F, 0xFF,
  0xBE, 0x0F, 0xFF, 0xEF, 0x83, 0xFC, 0x7F, 0xE1, 0xFC, 0x07, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xFF, 0xF7, 0xC0, 0xFF, 0xFD, 0xF0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF, 0x3F,
  0x00, 0x7F, 0x8F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xC0, 0x03, 0xF1, 0xFF,
  0x00, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x0F, 0xBF, 0xFF, 0x83, 0xFE,
  0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF0, 0x7F, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F,
  0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x04, 0x01, 0x00, 0xF9, 0xF8,
  0xFC, 0x0F, 0xBF, 0x9F, 0xE0, 0xF7, 0xFF, 0xFF, 0x0F, 0x7F, 0xFF, 0xF1,
  0xF8, 0x7C, 0x1F, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x1F, 0x07,
  0x81, 0xF1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xE0, 0x78, 0x3E,
  0x3E, 0x07, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x03, 0xE3, 0xE0,
  0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0x07,
  0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xE0, 0x7C, 0x7C,
  0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0xF8, 0x1E, 0x0F, 0x8F, 0x81, 0xE0,
  0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xC0, 0xF8, 0xF8, 0x3C, 0x1F, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0xF1, 0xFF, 0x00, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFC, 0x0F, 0xBF, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFC, 0x7F, 0xC0, 0x1F, 0x9F, 0xFC, 0x03, 0xF7, 0xFF, 0xC0, 0x7D,
  0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xDF, 0xFF,
  0x81, 0xFB, 0xFF, 0xE0, 0x3F, 0x3F, 0xF8, 0x07, 0xE3, 0xFE, 0x00, 0xFC,
  0x04, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE3,
  0xF0, 0x3F, 0xFC, 0xF8, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0xE1, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0x7F, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xF3,
  0xE0, 0x0F, 0xF0, 0xF8, 0x00, 0x60, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x40, 0x03, 0xF1, 0xFF, 0x00, 0xF9, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0x0F,
  0xBF, 0xFF, 0x83, 0xFE, 0x1F, 0xE1, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7F,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1,
  0xF8, 0x01, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03,
  0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0x81, 0xEF, 0x03, 0xF0, 0x7D,
  0xE0, 0xEE, 0x0F, 0xBC, 0x1D, 0xC1, 0xE7, 0x83, 0xB8, 0x3C, 0xF0, 0xE7,
  0x0F, 0x9E, 0x1C, 0xE1, 0xE3, 0xC3, 0x9C, 0x3C, 0x78, 0xF3, 0x8F, 0x8F,
  0x1C, 0x71, 0xE1, 0xE3, 0x8E, 0x3C, 0x3C, 0xF1, 0xCF, 0x87, 0x9C, 0x39,
  0xE0, 0xF3, 0x87, 0x3C, 0x1E, 0x70, 0xE7, 0x83, 0xDC, 0x1D, 0xE0, 0x7B,
  0x83, 0xBC, 0x0F, 0x70, 0x77, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x8F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFF, 0xFB, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF8, 0x1F, 0xFC, 0xFC, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x02, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x01,
  0xF1, 0xFF, 0x80, 0x7C, 0xFF, 0xF0, 0x1F, 0x7F, 0xFE, 0x07, 0xDF, 0x1F,
  0xC3, 0xEF, 0x83, 0xF0, 0xFB, 0xE0, 0x7F, 0xFE, 0xF8, 0x0F, 0xFF, 0x3E,
  0x03, 0xFF, 0x8F, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -37 },
  { 62, 18, 15, 31, 9, -37 },
  { 96, 30, 37, 31, 1, -37 },
  { 235, 28, 51, 31, 2, -44 },
  { 414, 36, 37, 31, -2, -37 },
  { 581, 29, 39, 31, 1, -38 },
  { 723, 8, 15, 31, 14, -37 },
  { 738, 21, 49, 31, 8, -43 },
  { 867, 21, 49, 31, 3, -43 },
  { 996, 28, 26, 31, 2, -31 },
  { 1087, 25, 24, 31, 3, -29 },
  { 1162, 15, 16, 31, 4, -8 },
  { 1192, 18, 5, 31, 7, -19 },
  { 1204, 10, 10, 31, 9, -9 },
  { 1217, 32, 48, 31, 0, -42 },
  { 1409, 26, 39, 31, 3, -38 },
  { 1536, 24, 37, 31, 2, -37 },
  { 1647, 27, 38, 31, 2, -38 },
  { 1776, 27, 38, 31, 2, -37 },
  { 1905, 25, 37, 31, 3, -37 },
  { 2021, 26, 38, 31, 3, -37 },
  { 2145, 26, 38, 31, 2, -37 },
  { 2269, 25, 37, 31, 6, -37 },
  { 2385, 27, 39, 31, 2, -38 },
  { 2517, 26, 38, 31, 4, -38 },
  { 2641, 13, 30, 31, 9, -29 },
  { 2690, 17, 37, 31, 5, -29 },
  { 2769, 25, 28, 31, 4, -31 },
  { 2857, 25, 18, 31, 3, -26 },
  { 2914, 25, 28, 31, 2, -31 },
  { 3002, 21, 37, 31, 7, -37 },
  { 3100, 31, 47, 31, 0, -38 },
  { 3283, 26, 37, 31, 0, -37 },
  { 3404, 27, 37, 31, 2, -37 },
  { 3529, 26, 39, 31, 3, -38 },
  { 3656, 27, 37, 31, 2, -37 },
  { 3781, 27, 37, 31, 3, -37 },
  { 3906, 29, 37, 31, 2, -37 },
  { 4041, 26, 39, 31, 3, -38 },
  { 4168, 28, 37, 31, 2, -37 },
  { 4298, 26, 37, 31, 3, -37 },
  { 4419, 28, 38, 31, 1, -37 },
  { 4552, 30, 37, 31, 2, -37 },
  { 4691, 23, 37, 31, 3, -37 },
  { 4798, 30, 37, 31, 1, -37 },
  { 4937, 28, 37, 31, 2, -37 },
  { 5067, 26, 39, 31, 3, -38 },
  { 5194, 29, 37, 31, 2, -37 },
  { 5329, 26, 47, 31, 3, -38 },
  { 5482, 28, 37, 31, 2, -37 },
  { 5612, 28, 39, 31, 2, -38 },
  { 5749, 27, 37, 31, 5, -37 },
  { 5874, 27, 38, 31, 3, -37 },
  { 6003, 26, 37, 31, 6, -37 },
  { 6124, 30, 37, 31, 3, -37 },
  { 6263, 33, 37, 31, -1, -37 },
  { 6416, 28, 37, 31, 5, -37 },
  { 6546, 28, 37, 31, 2, -37 },
  { 6676, 21, 48, 31, 7, -42 },
  { 6802, 16, 48, 31, 8, -42 },
  { 6898, 21, 48, 31, 4, -42 },
  { 7024, 23, 20, 31, 4, -37 },
  { 7082, 25, 5, 31, 0, 1 },
  { 7098, 10, 7, 31, 13, -40 },
  { 7107, 26, 30, 31, 3, -29 },
  { 7205, 26, 38, 31, 2, -37 },
  { 7329, 25, 30, 31, 3, -29 },
  { 7423, 27, 38, 31, 3, -37 },
  { 7552, 25, 30, 31, 3, -29 },
  { 7646, 35, 46, 31, -3, -37 },
  { 7848, 26, 38, 31, 3, -29 },
  { 7972, 26, 37, 31, 2, -37 },
  { 8093, 25, 40, 31, 2, -40 },
  { 8218, 26, 49, 31, 1, -40 },
  { 8378, 28, 37, 31, 2, -37 },
  { 8508, 22, 37, 31, 5, -37 },
  { 8610, 28, 29, 31, 1, -29 },
  { 8712, 26, 29, 31, 2, -29 },
  { 8807, 25, 30, 31, 3, -29 },
  { 8901, 27, 38, 31, 1, -29 },
  { 9030, 26, 38, 31, 3, -29 },
  { 9154, 26, 29, 31, 3, -29 },
  { 9249, 26, 30, 31, 2, -29 },
  { 9347, 25, 36, 31, 4, -36 },
  { 9460, 26, 29, 31, 3, -28 },
  { 9555, 25, 28, 31, 5, -28 },
  { 9643, 27, 28, 31, 4, -28 },
  { 9738, 30, 28, 31, 0, -28 },
  { 9843, 25, 37, 31, 3, -28 },
  { 9959, 26, 28, 31, 2, -28 },
  { 10050, 27, 48, 31, 4, -42 },
  { 10212, 13, 48, 31, 9, -42 },
  { 10290, 26, 48, 31, 1, -42 },
  { 10446, 26, 12, 31, 3, -24 },
};

const GFXfont JetBrainsMono_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_MEDIUMITALIC51PT7B_H_
