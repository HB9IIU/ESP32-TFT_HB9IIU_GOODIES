#ifndef _JETBRAINSMONO_MEDIUMITALIC60PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x81, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF9, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFD, 0xDF, 0xF0, 0x07, 0xF8, 0xE3, 0xFC, 0x03, 0xF8,
  0xF0, 0xFE, 0x03, 0xF8, 0x78, 0x7F, 0x01, 0xF8, 0x3C, 0x1F, 0x80, 0xFC,
  0x1E, 0x0F, 0xC0, 0xFE, 0x0E, 0x00, 0x00, 0x7F, 0x07, 0x00, 0x00, 0x3F,
  0x87, 0x80, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x07,
  0xFC, 0xF0, 0x00, 0x01, 0xFF, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0x78, 0xFF,
  0x00, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x0F, 0x07,
  0xF0, 0x00, 0x07, 0x03, 0xF0, 0x7F, 0x07, 0x81, 0xF8, 0x3F, 0x03, 0xC0,
  0xFC, 0x1F, 0xC1, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x7E, 0x07, 0xF0, 0x78,
  0x7F, 0x03, 0xFC, 0x38, 0x7F, 0x00, 0xFF, 0xFD, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xFE,
  0x00, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC7, 0xC0, 0x00, 0x1F,
  0xC7, 0xE3, 0xE0, 0x00, 0x03, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x00, 0x07, 0xC7, 0xFF, 0xF0,
  0x00, 0x03, 0xE3, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x03, 0xC0, 0x00, 0x7E, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0xBF, 0x80,
  0xFE, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xC0,
  0x3F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7E,
  0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF8,
  0x07, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3,
  0xF8, 0x0F, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0xFE, 0xFE, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x20, 0x03, 0xF0, 0x02, 0x3C, 0x03, 0xE0, 0x0E, 0x3F, 0x03,
  0xE0, 0x7E, 0x7F, 0xC3, 0xC1, 0xFE, 0x7F, 0xE3, 0xC7, 0xFF, 0xFF, 0xF9,
  0xDF, 0xFF, 0x7F, 0xFD, 0xBF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x83,
  0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xF8, 0x3F, 0x0F, 0xF1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x03, 0x81, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0x7F,
  0xE7, 0xF0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x78, 0x0F, 0xE0, 0x06, 0x00, 0xFE, 0x00, 0xC0, 0x0F, 0xE0, 0x08,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE7,
  0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x07,
  0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFC, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x60, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x01, 0xFE, 0x7E, 0x0F, 0xC0, 0x3F, 0xF9, 0xF0, 0x7C,
  0x03, 0xFF, 0xCF, 0x03, 0xE0, 0x1F, 0xFF, 0x78, 0x1F, 0x01, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x3E, 0x00, 0xFC, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xF8,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x0F,
  0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xC0, 0x7F, 0xFF, 0xF0, 0x3E, 0x01, 0xFF, 0xEF, 0x81,
  0xF0, 0x07, 0xFF, 0x7C, 0x1F, 0x80, 0x1F, 0xE3, 0xE0, 0xFC, 0x00, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFF,
  0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x81, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0xF8,
  0x3F, 0x83, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xF8,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3E, 0xF0, 0x1F,
  0x78, 0x07, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x0F, 0x9F, 0x03, 0xF7, 0xC1, 0xF7, 0xE0, 0x7E, 0xF8, 0x3C,
  0xF8, 0x0F, 0xCF, 0x0F, 0x9F, 0x01, 0xF1, 0xE1, 0xE3, 0xE0, 0x3E, 0x3C,
  0x7C, 0xFC, 0x07, 0xC7, 0xCF, 0x9F, 0x80, 0xF8, 0xFB, 0xE3, 0xF0, 0x3F,
  0x1F, 0x7C, 0x7C, 0x07, 0xE3, 0xEF, 0x1F, 0x80, 0xFC, 0x3F, 0xE3, 0xF0,
  0x1F, 0x87, 0xF8, 0x7E, 0x03, 0xF0, 0xFF, 0x0F, 0xC0, 0x7E, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x80,
  0x0F, 0xC0, 0x7F, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0xF0,
  0x01, 0xF8, 0x1F, 0xF8, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0xFC, 0x07, 0xFF,
  0x00, 0x7E, 0x03, 0xEF, 0x80, 0x3F, 0x01, 0xF7, 0xC0, 0x1F, 0x80, 0xFB,
  0xE0, 0x0F, 0xC0, 0xFD, 0xF0, 0x07, 0xE0, 0x7E, 0xFC, 0x07, 0xF0, 0x3F,
  0x3E, 0x03, 0xF0, 0x1F, 0x9F, 0x01, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0x07,
  0xE7, 0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x81,
  0xF8, 0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x07, 0xE0,
  0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF0, 0xFC,
  0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE0, 0x7C, 0x7E, 0x03, 0xF0, 0x3F, 0x3F,
  0x01, 0xF8, 0x1F, 0x9F, 0x80, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0x03, 0xE7,
  0xE0, 0x7E, 0x01, 0xF3, 0xF0, 0x3F, 0x00, 0xFD, 0xF0, 0x1F, 0x80, 0x7E,
  0xF8, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xE0, 0x0F, 0xFE, 0x07, 0xE0, 0x07,
  0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xF8, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x7F, 0xC0, 0x7E, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0xF0, 0x3F, 0x00,
  0x0F, 0xF8, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0xC0, 0x3E, 0x3F, 0x01, 0xFC,
  0x07, 0xE3, 0xF0, 0x1D, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x07, 0xC3, 0xF0,
  0x3F, 0xC0, 0x7C, 0x3F, 0x03, 0xFC, 0x0F, 0xC3, 0xF0, 0x3B, 0xC0, 0xFC,
  0x3F, 0x07, 0xBC, 0x0F, 0x83, 0xF0, 0x7B, 0xC0, 0xF8, 0x3E, 0x07, 0xBC,
  0x1F, 0x83, 0xE0, 0x73, 0xC1, 0xF0, 0x3E, 0x0F, 0x3C, 0x1F, 0x03, 0xE0,
  0xF3, 0xC3, 0xF0, 0x3E, 0x0F, 0x3C, 0x3F, 0x03, 0xE1, 0xE3, 0xC3, 0xE0,
  0x3E, 0x1E, 0x3C, 0x3E, 0x03, 0xE1, 0xE3, 0xC7, 0xE0, 0x3E, 0x1C, 0x38,
  0x7E, 0x07, 0xE3, 0xC3, 0x87, 0xC0, 0x7E, 0x3C, 0x38, 0x7C, 0x07, 0xE3,
  0xC3, 0x8F, 0xC0, 0x7E, 0x78, 0x38, 0xF8, 0x07, 0xE7, 0x83, 0x8F, 0x80,
  0x7E, 0x78, 0x38, 0xF8, 0x07, 0xC7, 0x87, 0x9F, 0x80, 0x7C, 0xF0, 0x79,
  0xF0, 0x07, 0xCF, 0x07, 0x9F, 0x00, 0x7C, 0xF0, 0x79, 0xF0, 0x07, 0xCE,
  0x07, 0xBF, 0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00,
  0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xE1, 0xFC, 0x03, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF,
  0xE7, 0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x07,
  0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF,
  0xEF, 0xE0, 0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC, 0x3F, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x00, 0x1F, 0x87, 0xFE,
  0x00, 0x7F, 0x3F, 0xFE, 0x00, 0xFE, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFE,
  0x03, 0xF7, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7E, 0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFE, 0x01, 0xF8, 0xFF, 0xF8,
  0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0xFF, 0xF8,
  0xFC, 0x01, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xEF,
  0xC0, 0x3F, 0xFF, 0xCF, 0xC0, 0x1F, 0xFF, 0xDF, 0xC0, 0x0F, 0xFF, 0x9F,
  0xC0, 0x07, 0xFE, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xF0, 0x0F,
  0xFF, 0x9F, 0x80, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0,
  0x3F, 0xFF, 0xDF, 0x80, 0x7F, 0xFE, 0x7E, 0x00, 0xFF, 0xE3, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F,
  0x87, 0xFE, 0x00, 0x7F, 0x3F, 0xFE, 0x00, 0xFE, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0x80, 0x18, 0x03, 0xF3, 0xF8, 0x7F, 0x01, 0xF3,
  0xFC, 0x7F, 0xC0, 0xFB, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x07, 0xE3,
  0xF0, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF8,
  0x7E, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3F,
  0x1F, 0x80, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F,
  0xC3, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x81,
  0xF8, 0x7C, 0x07, 0x80, 0xFC, 0x7E, 0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xE0,
  0x7E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7C,
  0x0F, 0xC3, 0xE0, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x03, 0xE1, 0xF8, 0x1F,
  0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x80, 0x3F,
  0xBF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xF8, 0x7F, 0xE0, 0x03, 0xF9, 0xFF, 0xF0, 0x03,
  0xFB, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x7F, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0x80, 0x3F, 0x1F, 0xFF, 0x00, 0x7F,
  0x0F, 0xFC, 0x00, 0x7F, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0xE1, 0xFC, 0x03, 0xFF, 0xE3, 0xF0, 0x0F,
  0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0x07, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x0E, 0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F,
  0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC, 0x3F, 0x00, 0x01,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xE1,
  0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFE,
  0x03, 0xF0, 0x0F, 0xBF, 0x01, 0xF8, 0x07, 0xDF, 0x80, 0xFC, 0x03, 0xEF,
  0xC0, 0xFE, 0x03, 0xE7, 0xE0, 0x7F, 0x01, 0xF3, 0xE0, 0x3B, 0x80, 0xF9,
  0xF0, 0x3D, 0xC0, 0xFC, 0xF8, 0x1E, 0xE0, 0x7C, 0x7C, 0x0E, 0x70, 0x3E,
  0x3E, 0x0F, 0x38, 0x3F, 0x1F, 0x07, 0x9C, 0x1F, 0x0F, 0x83, 0x8E, 0x0F,
  0x87, 0xC3, 0xC7, 0x07, 0xC3, 0xE1, 0xE3, 0x87, 0xC1, 0xF0, 0xF1, 0xC3,
  0xE0, 0xF8, 0x70, 0xE1, 0xF0, 0x7C, 0x78, 0x71, 0xF0, 0x3E, 0x3C, 0x38,
  0xF8, 0x1F, 0x1C, 0x1C, 0x7C, 0x0F, 0x9E, 0x0E, 0x7C, 0x07, 0xCF, 0x07,
  0x3E, 0x03, 0xE7, 0x03, 0x9F, 0x01, 0xF7, 0x81, 0xDF, 0x00, 0xFB, 0xC0,
  0xEF, 0x80, 0x7D, 0xC0, 0x77, 0xC0, 0x3F, 0xE0, 0x3B, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x3F, 0x01, 0xFF, 0xF1, 0xF8, 0x07, 0xFE,
  0x1F, 0xC0, 0x03, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x01, 0xF8, 0xFF, 0xFC,
  0x03, 0xF3, 0xFF, 0xFC, 0x07, 0xE7, 0xF7, 0xF8, 0x0F, 0x9F, 0x83, 0xF8,
  0x3F, 0x3F, 0x03, 0xF8, 0x7E, 0x7E, 0x07, 0xFF, 0xFC, 0xF8, 0x07, 0xFF,
  0xF1, 0xF0, 0x07, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0x0F, 0xC0, 0x07, 0xF8,
  0x00,
};

const GFXglyph JetBrainsMono_MediumItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 15, 44, 36, 11, -44 },
  { 84, 22, 18, 36, 10, -44 },
  { 134, 36, 44, 36, 1, -44 },
  { 332, 33, 60, 36, 2, -52 },
  { 580, 42, 44, 36, -2, -44 },
  { 811, 34, 45, 36, 1, -44 },
  { 1003, 8, 18, 36, 17, -44 },
  { 1021, 26, 59, 36, 9, -51 },
  { 1213, 25, 59, 36, 3, -51 },
  { 1398, 32, 32, 36, 3, -37 },
  { 1526, 29, 28, 36, 4, -34 },
  { 1628, 17, 19, 36, 5, -9 },
  { 1669, 21, 6, 36, 8, -23 },
  { 1685, 12, 11, 36, 10, -10 },
  { 1702, 37, 57, 36, 0, -50 },
  { 1966, 32, 45, 36, 3, -44 },
  { 2146, 28, 44, 36, 3, -44 },
  { 2300, 32, 44, 36, 2, -44 },
  { 2476, 31, 45, 36, 3, -44 },
  { 2651, 30, 44, 36, 3, -44 },
  { 2816, 31, 45, 36, 3, -44 },
  { 2991, 30, 45, 36, 3, -44 },
  { 3160, 30, 44, 36, 7, -44 },
  { 3325, 31, 45, 36, 3, -44 },
  { 3500, 30, 44, 36, 5, -44 },
  { 3665, 16, 35, 36, 10, -34 },
  { 3735, 20, 44, 36, 6, -34 },
  { 3845, 29, 32, 36, 5, -36 },
  { 3961, 29, 20, 36, 4, -30 },
  { 4034, 29, 32, 36, 3, -36 },
  { 4150, 25, 44, 36, 8, -44 },
  { 4288, 37, 55, 36, 0, -44 },
  { 4543, 31, 44, 36, 0, -44 },
  { 4714, 33, 44, 36, 2, -44 },
  { 4896, 32, 45, 36, 3, -44 },
  { 5076, 32, 44, 36, 2, -44 },
  { 5252, 33, 44, 36, 3, -44 },
  { 5434, 33, 44, 36, 3, -44 },
  { 5616, 32, 45, 36, 3, -44 },
  { 5796, 33, 44, 36, 2, -44 },
  { 5978, 31, 44, 36, 3, -44 },
  { 6149, 33, 45, 36, 1, -44 },
  { 6335, 36, 44, 36, 2, -44 },
  { 6533, 26, 44, 36, 4, -44 },
  { 6676, 35, 44, 36, 1, -44 },
  { 6869, 33, 44, 36, 2, -44 },
  { 7051, 31, 45, 36, 3, -44 },
  { 7226, 34, 44, 36, 2, -44 },
  { 7413, 32, 55, 36, 3, -44 },
  { 7633, 33, 44, 36, 2, -44 },
  { 7815, 33, 45, 36, 2, -44 },
  { 8001, 31, 44, 36, 6, -44 },
  { 8172, 32, 45, 36, 3, -44 },
  { 8352, 31, 44, 36, 7, -44 },
  { 8523, 36, 44, 36, 3, -44 },
  { 8721, 39, 44, 36, -1, -44 },
  { 8936, 33, 44, 36, 6, -44 },
  { 9118, 33, 44, 36, 2, -44 },
  { 9300, 25, 57, 36, 8, -50 },
  { 9479, 19, 57, 36, 9, -50 },
  { 9615, 25, 57, 36, 5, -50 },
  { 9794, 27, 24, 36, 5, -44 },
  { 9875, 30, 6, 36, 0, 1 },
  { 9898, 12, 8, 36, 15, -47 },
  { 9910, 31, 35, 36, 3, -34 },
  { 10046, 31, 45, 36, 2, -44 },
  { 10221, 30, 35, 36, 3, -34 },
  { 10353, 32, 45, 36, 3, -44 },
  { 10533, 30, 35, 36, 3, -34 },
  { 10665, 41, 55, 36, -3, -44 },
  { 10947, 30, 45, 36, 4, -34 },
  { 11116, 31, 44, 36, 2, -44 },
  { 11287, 30, 47, 36, 2, -47 },
  { 11464, 31, 58, 36, 1, -47 },
  { 11689, 33, 44, 36, 3, -44 },
  { 11871, 26, 44, 36, 6, -44 },
  { 12014, 33, 34, 36, 1, -34 },
  { 12155, 31, 34, 36, 2, -34 },
  { 12287, 30, 35, 36, 3, -34 },
  { 12419, 32, 45, 36, 1, -34 },
  { 12599, 31, 45, 36, 3, -34 },
  { 12774, 31, 34, 36, 3, -34 },
  { 12906, 30, 35, 36, 3, -34 },
  { 13038, 29, 42, 36, 5, -42 },
  { 13191, 31, 34, 36, 3, -33 },
  { 13323, 30, 33, 36, 6, -33 },
  { 13447, 33, 33, 36, 4, -33 },
  { 13584, 35, 33, 36, 0, -33 },
  { 13729, 29, 44, 36, 4, -33 },
  { 13889, 31, 33, 36, 2, -33 },
  { 14017, 31, 57, 36, 5, -50 },
  { 14238, 15, 57, 36, 11, -50 },
  { 14345, 31, 57, 36, 1, -50 },
  { 14566, 31, 13, 36, 3, -28 },
};

const GFXfont JetBrainsMono_MediumItalic60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_MEDIUMITALIC60PT7B_H_
