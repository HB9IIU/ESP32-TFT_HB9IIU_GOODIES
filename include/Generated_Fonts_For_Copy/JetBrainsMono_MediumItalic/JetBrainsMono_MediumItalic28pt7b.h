#ifndef _JETBRAINSMONO_MEDIUMITALIC28PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x86, 0x00, 0x00, 0x00, 0xF3, 0xE7, 0x80, 0x71, 0xDC, 0xFF, 0x3B, 0x8E,
  0xE3, 0xB8, 0xEE, 0x3B, 0x0C, 0x00, 0xC3, 0x80, 0xE1, 0x80, 0x61, 0xC0,
  0x30, 0xC0, 0x38, 0x60, 0xFF, 0xFC, 0x7F, 0xFE, 0x0E, 0x18, 0x06, 0x1C,
  0x03, 0x0C, 0x03, 0x06, 0x01, 0x87, 0x00, 0xC3, 0x03, 0xFF, 0xF3, 0xFF,
  0xF8, 0x70, 0xC0, 0x30, 0x60, 0x18, 0x70, 0x1C, 0x30, 0x0C, 0x38, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x7F, 0xC1, 0xFF, 0x87,
  0xB7, 0x8E, 0x67, 0x3C, 0xCE, 0x71, 0x00, 0xF6, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0x3C, 0x06, 0x38, 0x0C, 0x77,
  0x19, 0xCF, 0x33, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0xFC, 0x0E, 0x1F, 0xE0,
  0xC1, 0x86, 0x18, 0x18, 0xE3, 0x01, 0x8E, 0x60, 0x38, 0xCE, 0x01, 0x9D,
  0xC0, 0x1F, 0x98, 0x00, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xDF, 0x00, 0x3B, 0xF8, 0x07, 0x71, 0x80, 0x66, 0x18, 0x0C, 0x61, 0x81,
  0x86, 0x38, 0x30, 0x63, 0x07, 0x07, 0xF0, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0x1E, 0x0E, 0x0E, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3B, 0x87, 0x79, 0xCE,
  0x71, 0xFC, 0x70, 0xFC, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF8, 0x79, 0xF8,
  0x7F, 0xDC, 0x3F, 0x1E, 0x7F, 0xEE, 0xEE, 0xEC, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x07,
  0x00, 0x10, 0x08, 0x00, 0x70, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x01, 0xF0, 0x7C, 0x07, 0x80, 0x60, 0x08, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x07, 0x18, 0xEF, 0xB7, 0xFF, 0xDF, 0x87, 0xF8, 0x03,
  0x80, 0x1D, 0x80, 0x73, 0x81, 0xE7, 0x87, 0x87, 0x06, 0x0C, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x1E,
  0x1E, 0x3C, 0x38, 0x38, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0C, 0x77, 0x39, 0xCF, 0x73, 0x9C, 0xE7, 0x11, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xF3, 0xC1, 0xFF, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x3D, 0xC1, 0x8E, 0x18, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0xF0, 0x78, 0xF3,
  0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x1C, 0x70, 0x73, 0x83,
  0x9C, 0x0E, 0x70, 0x39, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x1F, 0xFC, 0xFF, 0xF3, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1D, 0xF8, 0x7F, 0xF1, 0xE1, 0xE7, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0xEF, 0x87,
  0xFC, 0x0F, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x90, 0x1F, 0xF8, 0xFF, 0xE7, 0x83, 0xDC, 0x07,
  0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xFC, 0x0E, 0x70, 0x79, 0xF3, 0xC3, 0xFE,
  0x07, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0x03, 0xF8, 0x0E, 0xE0, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE3, 0x81,
  0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x38, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x83,
  0xC7, 0x8F, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xF3,
  0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F,
  0x78, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x8F,
  0x9F, 0xFC, 0x1F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x7C, 0xF9, 0xE1, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E, 0x78, 0x07, 0x07, 0xC3, 0xE1,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF,
  0xF7, 0xFF, 0x80, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC7, 0xF0, 0xFC, 0x1C, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xC0, 0xF1, 0xC0, 0x38, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x67, 0x30, 0xFF, 0x98, 0xF3, 0x9C, 0x71, 0xCE, 0x30, 0x67,
  0x18, 0x73, 0x9C, 0x39, 0x8E, 0x1C, 0xC7, 0x0C, 0x63, 0x8E, 0x71, 0xFF,
  0x38, 0x7D, 0x9C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x18, 0x38, 0x60,
  0xE1, 0x87, 0x07, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCE, 0x07, 0x78, 0x1D,
  0xC0, 0x77, 0x01, 0xF8, 0x07, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x78, 0xE0,
  0x71, 0xC0, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70,
  0x78, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0xE0,
  0x73, 0x83, 0xCF, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0x3F, 0xF8,
  0x70, 0xF0, 0xE0, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E,
  0x38, 0x1C, 0x70, 0x71, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xFF,
  0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x3F, 0xBC, 0xFE, 0xE3, 0xFB, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73,
  0x83, 0xCF, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF3, 0xC1, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x73, 0x81, 0xC7, 0x03, 0x80, 0x1F, 0xFC, 0xFF,
  0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x03, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x1C, 0x07, 0x8E, 0x07, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0x81, 0xC3,
  0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0E,
  0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x3C, 0x38, 0x0E, 0x1C, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x36, 0x36, 0x36,
  0x76, 0x37, 0x6E, 0x33, 0x6E, 0x73, 0xCE, 0x73, 0xCC, 0x73, 0x9C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0x1E, 0x07, 0x1E, 0x0E, 0x1F, 0x0E, 0x1F,
  0x0E, 0x3B, 0x0E, 0x3B, 0x0E, 0x3B, 0x0C, 0x3B, 0x9C, 0x3B, 0x9C, 0x39,
  0x9C, 0x31, 0x9C, 0x71, 0x9C, 0x71, 0xD8, 0x71, 0xD8, 0x71, 0xD8, 0x70,
  0xF8, 0x60, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF0, 0x01, 0xC0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x83, 0xCF, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1C, 0x1E, 0x1C, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1,
  0xF7, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x78, 0xE0, 0x71, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x3C, 0x7F, 0xF0, 0xFF, 0xC3,
  0xFE, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0xE3, 0x81, 0xE7, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0,
  0xF1, 0xC0, 0xE7, 0x81, 0xCE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0xE0,
  0x39, 0xE0, 0x71, 0xF7, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x1E, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0xF1, 0xF7, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x1F,
  0xC0, 0x3B, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38,
  0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x06, 0x70,
  0x0C, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x61, 0xC7, 0x63, 0xC7, 0xE3, 0xC6, 0xE3, 0xC6, 0xE2, 0xCE, 0xE6, 0xCE,
  0xE6, 0xCC, 0xE6, 0xCC, 0xEC, 0x9C, 0xEC, 0x9C, 0xEC, 0x98, 0xC8, 0x98,
  0xD8, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0, 0xD1, 0xB0, 0xF1, 0xF0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xE1, 0xE0, 0x1E, 0x07, 0xC3, 0x81, 0xC0, 0xF0, 0xE0, 0x1C,
  0x78, 0x07, 0x1C, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x03, 0xDC, 0x00,
  0xE7, 0x00, 0x70, 0xE0, 0x3C, 0x38, 0x1E, 0x0F, 0x07, 0x01, 0xC3, 0xC0,
  0x78, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x07, 0x1C,
  0x0E, 0x38, 0x1C, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x7F, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0xF8, 0xFE, 0x1F, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x0C, 0xC0, 0xE6, 0x0E, 0x38,
  0x71, 0xC7, 0x06, 0x30, 0x37, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1,
  0xC3, 0x8F, 0x03, 0x80, 0x1F, 0xDC, 0x7F, 0xF1, 0xE1, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x07, 0x8F, 0xBF, 0x1F, 0xFC, 0x1F, 0xB8, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x60, 0xEF, 0xE3, 0xBF, 0xCF, 0x0F, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x79, 0xF3, 0xCE, 0xFE, 0x39, 0xF0, 0x03, 0xC0, 0xFF, 0x8F, 0xFE,
  0x70, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0xEE, 0x0F, 0x7C, 0xF1, 0xFF, 0x07, 0xF0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x38, 0xE1, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x78, 0xFB, 0xF1, 0xFF, 0xC1, 0xFB, 0x80, 0x03,
  0x80, 0x7F, 0x0F, 0xFC, 0x70, 0xF7, 0x03, 0xB8, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x78, 0xF1, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0x9E, 0x1E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x3C, 0xFF, 0xF1,
  0xFD, 0xC3, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0xEF,
  0xE3, 0xBF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x07, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x07, 0xB8,
  0x1C, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x01, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x38, 0x38,
  0x78, 0x38, 0xF0, 0x39, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x71, 0xC0, 0x71,
  0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xFF,
  0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xFF, 0x1F, 0xF0, 0xFE, 0x01, 0x8C, 0x1B, 0xDE, 0x1F, 0xFF, 0x38,
  0xC7, 0x38, 0xC7, 0x38, 0xC7, 0x38, 0xC6, 0x31, 0xC6, 0x31, 0xCE, 0x71,
  0x8E, 0x71, 0x8E, 0x71, 0x8E, 0x71, 0x8E, 0x73, 0x8C, 0x63, 0x9C, 0xE3,
  0x1C, 0x04, 0xE0, 0xEF, 0xE3, 0xBF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xDE, 0x07, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xEE, 0x07, 0xB8, 0x1C, 0x03, 0x80, 0xFF, 0x0F, 0xFC, 0x70, 0xF7,
  0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x0F, 0x7D, 0xF1, 0xFF, 0x07, 0xF0, 0x02, 0x30, 0x3B, 0xF8, 0x77,
  0xF8, 0xF0, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x07, 0x38, 0x1E,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC6, 0xCF, 0x1D, 0xFC, 0x39,
  0xF0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xE1, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x07,
  0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8F,
  0xB7, 0x1F, 0xFC, 0x1F, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0xC0, 0xEF, 0xE3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D,
  0xC0, 0x77, 0x03, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x3F, 0xE1, 0xFF,
  0xCF, 0x07, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xE0, 0x03, 0x80, 0x0E, 0xF0, 0x39, 0xE1, 0xE7, 0xFF, 0x0F, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xF8, 0x78, 0x1D,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xFB, 0xE1, 0xFF, 0x03, 0xF8,
  0x00, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0xE1, 0xC3, 0x87,
  0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x70, 0x0D, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0xC3, 0x8F, 0x87, 0x1F, 0x1E, 0x36, 0x3C, 0x6C,
  0x59, 0xD9, 0xB3, 0x33, 0x66, 0x66, 0xDC, 0xD9, 0xB1, 0xB3, 0x63, 0x67,
  0xC6, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x00, 0x1E, 0x0F, 0x0E,
  0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1C, 0x70, 0x3C, 0x38, 0x78,
  0x3C, 0xF0, 0x1C, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xCF, 0x0F, 0x3F, 0xFC,
  0x7F, 0x70, 0xF3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xC0, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xE0, 0x21, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xE1, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xC0, 0x00, 0x3C, 0x1D, 0xF8, 0x7F, 0xF1, 0xF9, 0xEE, 0xC3, 0xFB,
  0x07, 0xC0,
};

const GFXglyph JetBrainsMono_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 10, 8, 17, 5, -20 },
  { 29, 17, 20, 17, 0, -20 },
  { 72, 15, 28, 17, 1, -24 },
  { 125, 20, 21, 17, -1, -21 },
  { 178, 16, 21, 17, 0, -21 },
  { 220, 4, 8, 17, 8, -20 },
  { 224, 12, 28, 17, 4, -24 },
  { 266, 12, 28, 17, 1, -24 },
  { 308, 15, 14, 17, 1, -17 },
  { 335, 14, 13, 17, 2, -16 },
  { 358, 8, 8, 17, 2, -4 },
  { 366, 9, 3, 17, 4, -11 },
  { 370, 5, 5, 17, 5, -5 },
  { 374, 17, 26, 17, 0, -23 },
  { 430, 15, 21, 17, 1, -21 },
  { 470, 13, 20, 17, 1, -20 },
  { 503, 15, 21, 17, 1, -21 },
  { 543, 15, 20, 17, 1, -20 },
  { 581, 14, 20, 17, 1, -20 },
  { 616, 14, 20, 17, 2, -20 },
  { 651, 14, 20, 17, 1, -20 },
  { 686, 14, 20, 17, 3, -20 },
  { 721, 15, 21, 17, 1, -21 },
  { 761, 14, 21, 17, 2, -21 },
  { 798, 7, 16, 17, 5, -16 },
  { 812, 9, 20, 17, 3, -16 },
  { 835, 14, 15, 17, 2, -17 },
  { 862, 13, 10, 17, 2, -14 },
  { 879, 14, 15, 17, 1, -17 },
  { 906, 11, 20, 17, 4, -20 },
  { 934, 17, 26, 17, 0, -21 },
  { 990, 14, 20, 17, 0, -20 },
  { 1025, 15, 20, 17, 1, -20 },
  { 1063, 14, 21, 17, 2, -21 },
  { 1100, 15, 20, 17, 1, -20 },
  { 1138, 16, 20, 17, 1, -20 },
  { 1178, 16, 20, 17, 1, -20 },
  { 1218, 14, 21, 17, 2, -21 },
  { 1255, 15, 20, 17, 1, -20 },
  { 1293, 14, 20, 17, 2, -20 },
  { 1328, 16, 20, 17, 0, -20 },
  { 1368, 17, 20, 17, 1, -20 },
  { 1411, 12, 20, 17, 2, -20 },
  { 1441, 16, 20, 17, 1, -20 },
  { 1481, 16, 20, 17, 1, -20 },
  { 1521, 14, 21, 17, 2, -21 },
  { 1558, 16, 20, 17, 1, -20 },
  { 1598, 15, 26, 17, 1, -21 },
  { 1647, 15, 20, 17, 1, -20 },
  { 1685, 15, 21, 17, 1, -21 },
  { 1725, 14, 20, 17, 3, -20 },
  { 1760, 15, 20, 17, 2, -20 },
  { 1798, 15, 20, 17, 3, -20 },
  { 1836, 16, 20, 17, 2, -20 },
  { 1876, 18, 20, 17, 0, -20 },
  { 1921, 15, 20, 17, 3, -20 },
  { 1959, 15, 20, 17, 1, -20 },
  { 1997, 11, 26, 17, 4, -23 },
  { 2033, 9, 26, 17, 4, -23 },
  { 2063, 12, 26, 17, 2, -23 },
  { 2102, 13, 10, 17, 2, -20 },
  { 2119, 14, 2, 17, 0, 1 },
  { 2123, 6, 4, 17, 7, -22 },
  { 2126, 15, 16, 17, 1, -16 },
  { 2156, 14, 20, 17, 1, -20 },
  { 2191, 13, 16, 17, 2, -16 },
  { 2217, 15, 20, 17, 1, -20 },
  { 2255, 13, 16, 17, 2, -16 },
  { 2281, 19, 25, 17, -1, -20 },
  { 2341, 14, 21, 17, 2, -16 },
  { 2378, 14, 20, 17, 1, -20 },
  { 2413, 14, 22, 17, 1, -22 },
  { 2452, 15, 27, 17, 0, -22 },
  { 2503, 16, 20, 17, 1, -20 },
  { 2543, 12, 20, 17, 3, -20 },
  { 2573, 16, 16, 17, 0, -16 },
  { 2605, 14, 16, 17, 1, -16 },
  { 2633, 13, 16, 17, 2, -16 },
  { 2659, 15, 21, 17, 0, -16 },
  { 2699, 15, 21, 17, 1, -16 },
  { 2739, 14, 16, 17, 2, -16 },
  { 2767, 14, 16, 17, 1, -16 },
  { 2795, 14, 20, 17, 2, -20 },
  { 2830, 14, 15, 17, 2, -15 },
  { 2857, 14, 15, 17, 3, -15 },
  { 2884, 15, 15, 17, 2, -15 },
  { 2913, 16, 15, 17, 0, -15 },
  { 2943, 14, 20, 17, 2, -15 },
  { 2978, 14, 15, 17, 1, -15 },
  { 3005, 15, 26, 17, 2, -23 },
  { 3054, 7, 26, 17, 5, -23 },
  { 3077, 14, 26, 17, 1, -23 },
  { 3123, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_MEDIUMITALIC28PT7B_H_
