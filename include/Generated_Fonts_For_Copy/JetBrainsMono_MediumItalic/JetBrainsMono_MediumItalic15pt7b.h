#ifndef _JETBRAINSMONO_MEDIUMITALIC15PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x44, 0x0C, 0xC0, 0xDE, 0xE7, 0x29, 0x00, 0x08,
  0x84, 0x86, 0x4F, 0xF1, 0x21, 0x90, 0x99, 0xFE, 0x64, 0x26, 0x12, 0x00,
  0x08, 0x08, 0x3E, 0x6E, 0x6B, 0x68, 0x70, 0x3C, 0x1E, 0x16, 0x96, 0xDC,
  0x78, 0x20, 0x20, 0x1C, 0x64, 0x98, 0x92, 0x12, 0x83, 0xA0, 0x08, 0x03,
  0xE0, 0xF6, 0x14, 0xC4, 0x93, 0x0E, 0x00, 0x1E, 0x19, 0x8C, 0xC6, 0x01,
  0x03, 0xC5, 0x2C, 0x9C, 0xC6, 0x67, 0x1E, 0xC0, 0x7F, 0x80, 0x02, 0x18,
  0x61, 0x82, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x06, 0x07, 0x04, 0x00,
  0x20, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x84, 0x33, 0x88, 0x00,
  0x18, 0x18, 0xD3, 0xFE, 0x18, 0x68, 0xCC, 0x48, 0x18, 0x33, 0xFF, 0xF1,
  0x06, 0x0C, 0x00, 0x32, 0x6C, 0xFF, 0xC0, 0x7C, 0x01, 0x80, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x00,
  0x3E, 0x66, 0x43, 0x42, 0xC2, 0xDA, 0xC6, 0xC6, 0x86, 0xCC, 0x78, 0x1C,
  0x79, 0x34, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x23, 0xF8, 0x3E, 0x66, 0x42,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xFC, 0x7E, 0x04, 0x30, 0xC1,
  0xC5, 0xC1, 0x83, 0x87, 0x99, 0xE0, 0x06, 0x18, 0x60, 0x83, 0x0C, 0xF1,
  0xFF, 0xFC, 0x08, 0x30, 0x7F, 0x7E, 0x60, 0x60, 0x5C, 0x66, 0x06, 0x06,
  0xC6, 0xCC, 0x78, 0x0C, 0x30, 0x61, 0x87, 0xCF, 0xF1, 0xC3, 0x87, 0x99,
  0xE0, 0xFF, 0xFE, 0x10, 0x60, 0x83, 0x0C, 0x18, 0x60, 0x83, 0x00, 0x3E,
  0x66, 0x62, 0x66, 0x6C, 0x38, 0x64, 0xC6, 0x86, 0xCC, 0x78, 0x3E, 0x66,
  0x43, 0xC3, 0xC2, 0x6E, 0x34, 0x0C, 0x18, 0x30, 0x60, 0x6C, 0x00, 0x36,
  0x18, 0xC0, 0x00, 0x04, 0xC4, 0x66, 0x00, 0x03, 0x0E, 0x38, 0xE0, 0xC0,
  0x70, 0x1E, 0x04, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x40, 0xE0, 0x70,
  0x30, 0xE7, 0x38, 0x40, 0x79, 0xF0, 0xC3, 0x0D, 0xE6, 0x10, 0x03, 0x0C,
  0x00, 0x1F, 0x18, 0xC8, 0x2C, 0x14, 0xEA, 0x4D, 0x27, 0xB2, 0xD9, 0x67,
  0xB0, 0x18, 0x07, 0x81, 0xC0, 0x0E, 0x0E, 0x0E, 0x1A, 0x12, 0x32, 0x22,
  0x7E, 0x62, 0x43, 0xC3, 0x7E, 0x66, 0x63, 0x42, 0x46, 0xFC, 0xC6, 0xC6,
  0xC6, 0x8C, 0xF8, 0x3E, 0x76, 0x63, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC6,
  0xCC, 0x78, 0x7C, 0x7E, 0x62, 0x42, 0x42, 0xC6, 0xC6, 0xC6, 0xC6, 0x9C,
  0xF8, 0x7F, 0x60, 0x60, 0x60, 0x40, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC,
  0x7F, 0x7F, 0x60, 0x40, 0x40, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x3E,
  0x76, 0x63, 0x40, 0x40, 0xDE, 0xDE, 0xC6, 0xC6, 0xCC, 0x78, 0x63, 0x63,
  0x62, 0x42, 0x46, 0xFE, 0xC6, 0xC6, 0xC4, 0x84, 0x8C, 0x7F, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0xFC, 0x0F, 0x87, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0xC2, 0x33, 0x1F, 0x00, 0x63, 0x62, 0x66,
  0x4C, 0x4C, 0xF8, 0xC8, 0xCC, 0xCC, 0x84, 0x86, 0x20, 0xC1, 0x83, 0x06,
  0x08, 0x10, 0x20, 0xC1, 0x87, 0xF0, 0x31, 0x99, 0xCC, 0xE7, 0xF6, 0xD3,
  0x69, 0x84, 0x86, 0x43, 0x21, 0xB0, 0x80, 0x63, 0x73, 0x72, 0x52, 0x52,
  0xD2, 0xDE, 0xDE, 0x8E, 0x8C, 0x8C, 0x3E, 0x76, 0x62, 0x42, 0x42, 0xC6,
  0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x7E, 0x7F, 0x63, 0x43, 0x43, 0xFE, 0xF8,
  0xC0, 0xC0, 0x80, 0x80, 0x3E, 0x76, 0x63, 0x42, 0xC2, 0xC6, 0xC6, 0xC6,
  0xC6, 0xCC, 0x78, 0x18, 0x08, 0x0C, 0x7E, 0x66, 0x63, 0x43, 0x46, 0xFC,
  0xF8, 0xC8, 0xCC, 0x8C, 0x86, 0x3E, 0x66, 0x63, 0x60, 0x60, 0x3C, 0x0E,
  0x06, 0x86, 0xCC, 0x78, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60,
  0xC1, 0x80, 0x63, 0x63, 0x62, 0x42, 0x42, 0xC6, 0xC6, 0xC6, 0xC4, 0xCC,
  0x78, 0x83, 0x0F, 0x16, 0x6C, 0xD9, 0x36, 0x68, 0x70, 0xE1, 0x80, 0xC9,
  0xEC, 0xB6, 0x5B, 0x6D, 0xB5, 0x52, 0xA9, 0x5C, 0xCC, 0x66, 0x33, 0x00,
  0x31, 0x98, 0x84, 0xC3, 0xC1, 0xC0, 0x60, 0x70, 0x68, 0x26, 0x31, 0x30,
  0xC0, 0x83, 0xC6, 0xCC, 0x48, 0x78, 0x70, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x7F, 0x7E, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x40, 0xC0, 0xFC, 0x3C,
  0xC2, 0x08, 0x61, 0x86, 0x18, 0x41, 0x04, 0x30, 0xF3, 0xC0, 0xC2, 0x18,
  0xC6, 0x10, 0x86, 0x30, 0x84, 0x31, 0x8C, 0x3C, 0x30, 0xC3, 0x0C, 0x20,
  0x82, 0x18, 0x61, 0x84, 0xF3, 0xC0, 0x08, 0x38, 0xD1, 0x26, 0x78, 0xC0,
  0xFF, 0xFC, 0xCC, 0x7A, 0xCF, 0x1E, 0x3C, 0x78, 0xB3, 0x3E, 0x60, 0xC1,
  0x82, 0xF6, 0x78, 0xF1, 0xE3, 0xC7, 0x9A, 0xE0, 0x3E, 0xCF, 0x1E, 0x0C,
  0x18, 0xF3, 0x3C, 0x03, 0x03, 0x02, 0x7A, 0x66, 0xC6, 0xC6, 0xC6, 0xC4,
  0xCC, 0x7C, 0x3C, 0x8F, 0x1F, 0xFC, 0x18, 0x33, 0x3C, 0x03, 0xC1, 0x80,
  0x40, 0x11, 0x3F, 0x83, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0xF8, 0x38, 0x00, 0x7A, 0xCF, 0x1E, 0x3C, 0x78, 0xBF, 0x02, 0x0D, 0xFB,
  0xC0, 0x60, 0xC1, 0x82, 0xF6, 0x78, 0xF1, 0xE3, 0xC7, 0x0A, 0x30, 0x06,
  0x06, 0x00, 0x00, 0x3C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0xFF, 0x03,
  0x03, 0x00, 0x00, 0x3E, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0xF8, 0xF0, 0x60, 0x60, 0x60, 0x47, 0x46, 0x4C, 0xF8, 0xD8, 0xCC, 0xCC,
  0x86, 0x79, 0xF0, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x60, 0xF8, 0x7B,
  0x36, 0xDA, 0x49, 0x24, 0x92, 0x5B, 0x6D, 0xB6, 0x7E, 0xCF, 0x1E, 0x3C,
  0x78, 0xE1, 0x46, 0x3C, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0x3C, 0x3F, 0x33,
  0x63, 0x63, 0x63, 0x63, 0x66, 0x5C, 0x40, 0xC0, 0xC0, 0x7A, 0xCF, 0x1E,
  0x3C, 0x78, 0xB3, 0x3A, 0x0C, 0x18, 0x30, 0x7E, 0x66, 0x42, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0x7E, 0x8D, 0x03, 0xC0, 0xE0, 0xF3, 0x7E, 0x18, 0x10,
  0x11, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x20, 0x30, 0x3C, 0x62, 0x87, 0x1E,
  0x3C, 0x78, 0xB3, 0x3C, 0xC3, 0x46, 0x46, 0x6C, 0x6C, 0x68, 0x38, 0x30,
  0x99, 0x9B, 0x9A, 0xAA, 0xAE, 0xAC, 0xCC, 0xCC, 0x33, 0x99, 0x07, 0x83,
  0x81, 0xC1, 0xA1, 0x99, 0x86, 0x42, 0x8F, 0x1E, 0x3C, 0x79, 0xBD, 0x02,
  0x0D, 0xFB, 0xC0, 0x7E, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x7E, 0x07, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0xF0, 0x18, 0x18, 0x18, 0x10, 0x10, 0x1C, 0x0C,
  0x32, 0x26, 0x66, 0x64, 0x4C, 0xCC, 0xC8, 0x3C, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x0F, 0x18, 0x18, 0x10, 0x10, 0x10, 0xF0, 0xC0, 0x73, 0xD2, 0x9E,
};

const GFXglyph JetBrainsMono_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 5, 9, 3, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 8, 15, 9, 1, -13 },
  { 39, 11, 11, 9, -1, -11 },
  { 55, 9, 11, 9, 0, -11 },
  { 68, 2, 5, 9, 4, -11 },
  { 70, 7, 15, 9, 2, -13 },
  { 84, 6, 15, 9, 1, -13 },
  { 96, 8, 8, 9, 1, -9 },
  { 104, 7, 7, 9, 1, -8 },
  { 111, 4, 4, 9, 1, -2 },
  { 113, 5, 2, 9, 2, -6 },
  { 115, 2, 3, 9, 3, -3 },
  { 116, 9, 14, 9, 0, -12 },
  { 132, 8, 11, 9, 1, -11 },
  { 143, 7, 11, 9, 1, -11 },
  { 153, 8, 11, 9, 1, -11 },
  { 164, 7, 11, 9, 1, -11 },
  { 174, 7, 11, 9, 1, -11 },
  { 184, 8, 11, 9, 1, -11 },
  { 195, 7, 11, 9, 1, -11 },
  { 205, 7, 11, 9, 2, -11 },
  { 215, 8, 11, 9, 1, -11 },
  { 226, 8, 11, 9, 1, -11 },
  { 237, 3, 8, 9, 3, -8 },
  { 240, 5, 10, 9, 1, -8 },
  { 247, 8, 8, 9, 1, -9 },
  { 255, 7, 6, 9, 1, -8 },
  { 261, 7, 8, 9, 1, -9 },
  { 268, 6, 11, 9, 2, -11 },
  { 277, 9, 14, 9, 0, -11 },
  { 293, 8, 11, 9, 0, -11 },
  { 304, 8, 11, 9, 1, -11 },
  { 315, 8, 11, 9, 1, -11 },
  { 326, 8, 11, 9, 1, -11 },
  { 337, 8, 11, 9, 1, -11 },
  { 348, 8, 11, 9, 1, -11 },
  { 359, 8, 11, 9, 1, -11 },
  { 370, 8, 11, 9, 1, -11 },
  { 381, 8, 11, 9, 1, -11 },
  { 392, 9, 11, 9, 0, -11 },
  { 405, 8, 11, 9, 1, -11 },
  { 416, 7, 11, 9, 1, -11 },
  { 426, 9, 11, 9, 0, -11 },
  { 439, 8, 11, 9, 1, -11 },
  { 450, 8, 11, 9, 1, -11 },
  { 461, 8, 11, 9, 1, -11 },
  { 472, 8, 14, 9, 1, -11 },
  { 486, 8, 11, 9, 1, -11 },
  { 497, 8, 11, 9, 1, -11 },
  { 508, 7, 11, 9, 2, -11 },
  { 518, 8, 11, 9, 1, -11 },
  { 529, 7, 11, 9, 2, -11 },
  { 539, 9, 11, 9, 1, -11 },
  { 552, 9, 11, 9, 0, -11 },
  { 565, 8, 11, 9, 2, -11 },
  { 576, 8, 11, 9, 1, -11 },
  { 587, 6, 14, 9, 2, -12 },
  { 598, 5, 14, 9, 2, -12 },
  { 607, 6, 14, 9, 1, -12 },
  { 618, 7, 6, 9, 1, -11 },
  { 624, 7, 2, 9, 0, 0 },
  { 626, 3, 2, 9, 4, -12 },
  { 627, 7, 8, 9, 1, -8 },
  { 634, 7, 11, 9, 1, -11 },
  { 644, 7, 8, 9, 1, -8 },
  { 651, 8, 11, 9, 1, -11 },
  { 662, 7, 8, 9, 1, -8 },
  { 669, 10, 14, 9, -1, -11 },
  { 687, 7, 11, 9, 1, -8 },
  { 697, 7, 11, 9, 1, -11 },
  { 707, 8, 12, 9, 0, -12 },
  { 719, 8, 15, 9, 0, -12 },
  { 734, 8, 11, 9, 1, -11 },
  { 745, 7, 11, 9, 1, -11 },
  { 755, 9, 8, 9, 0, -8 },
  { 764, 7, 8, 9, 1, -8 },
  { 771, 7, 8, 9, 1, -8 },
  { 778, 8, 11, 9, 0, -8 },
  { 789, 7, 11, 9, 1, -8 },
  { 799, 8, 8, 9, 1, -8 },
  { 807, 7, 8, 9, 1, -8 },
  { 814, 8, 11, 9, 1, -11 },
  { 825, 7, 8, 9, 1, -8 },
  { 832, 8, 8, 9, 1, -8 },
  { 840, 8, 8, 9, 1, -8 },
  { 848, 9, 8, 9, 0, -8 },
  { 857, 7, 11, 9, 1, -8 },
  { 867, 7, 8, 9, 1, -8 },
  { 874, 8, 14, 9, 1, -12 },
  { 888, 4, 14, 9, 3, -12 },
  { 895, 8, 14, 9, 0, -12 },
  { 909, 8, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_MEDIUMITALIC15PT7B_H_
