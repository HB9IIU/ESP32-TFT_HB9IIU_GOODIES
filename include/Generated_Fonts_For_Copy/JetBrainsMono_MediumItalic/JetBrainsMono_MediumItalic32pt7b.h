#ifndef _JETBRAINSMONO_MEDIUMITALIC32PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0,
  0x71, 0xFE, 0x3F, 0xC7, 0xF8, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1E, 0xE3,
  0x80, 0x00, 0xE1, 0xC0, 0x38, 0x30, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38,
  0x30, 0x07, 0x0E, 0x4F, 0xFF, 0xF1, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0xC1,
  0xC0, 0x38, 0x30, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x30, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x30,
  0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3E, 0xFE, 0x0E, 0x67, 0x87, 0x98, 0xE1, 0xC6, 0x38, 0x71, 0x80, 0x1E,
  0x60, 0x07, 0xD8, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0x3C, 0x01, 0x8F, 0x00, 0x63, 0xC7, 0x18, 0xF1,
  0xC6, 0x38, 0x79, 0x9E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0x80, 0x70, 0xFF, 0x03, 0x87, 0x1C, 0x1C, 0x1C, 0x30, 0xE0, 0x71, 0xC7,
  0x01, 0x87, 0x18, 0x06, 0x1C, 0xE0, 0x1C, 0xE7, 0x00, 0x7F, 0xB8, 0x00,
  0xF9, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x84, 0x00, 0x0E,
  0xFC, 0x00, 0x77, 0xF8, 0x03, 0x98, 0x60, 0x1C, 0xE1, 0x80, 0xE3, 0x86,
  0x03, 0x0E, 0x38, 0x18, 0x30, 0xE0, 0xE0, 0xE7, 0x87, 0x03, 0xFC, 0x38,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3E, 0x7C, 0x0E,
  0x0F, 0x03, 0x83, 0xC1, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x83, 0xDE, 0xF1, 0xE7, 0x1E, 0x73,
  0xC7, 0xB8, 0xF0, 0xFE, 0x3C, 0x1F, 0x0E, 0x07, 0x83, 0x81, 0xE0, 0xF0,
  0xFC, 0x3F, 0xFF, 0x07, 0xFD, 0xE0, 0xFC, 0x3C, 0x7B, 0xBD, 0xEF, 0x7B,
  0x9C, 0xE0, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xF8, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xC1, 0xFC, 0x0F, 0x80, 0x78, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x1B, 0xE6, 0x3D, 0xFB,
  0x7F, 0x7F, 0xFE, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xEF, 0x01,
  0xE3, 0x81, 0xE1, 0xE0, 0xE0, 0xF0, 0x30, 0x20, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x8F, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0,
  0xF0, 0x70, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0x7B, 0xEF, 0xBE, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0x1F, 0x3C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07,
  0x78, 0x0F, 0x71, 0x8F, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0xF0, 0x0E,
  0xF0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78,
  0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8,
  0x0F, 0xB8, 0x1E, 0x78, 0x1C, 0x78, 0x10, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFB,
  0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x40, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8F,
  0x07, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1C,
  0xF0, 0x1C, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3B, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x1E, 0x78, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xFC,
  0x1F, 0xFE, 0x3F, 0x3F, 0x3C, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x70, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCE, 0x01, 0xE7, 0x00,
  0xE3, 0x80, 0xF2, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xF0,
  0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1E, 0x0F, 0x07, 0x8F,
  0x03, 0xEF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7B, 0xE0, 0xF0, 0x78, 0x70,
  0x1C, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x83, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3E, 0x3E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x7F, 0xFC, 0x7F, 0xB8, 0x1F, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF8, 0xF8, 0xF8, 0xF0,
  0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7C, 0x00, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x18, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x18, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x38, 0x0C, 0xE3, 0x83, 0xEE, 0x38, 0x7F, 0xE3, 0x8E, 0x1E, 0x38,
  0xE1, 0xE7, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x1C, 0x1C, 0x71, 0xC1, 0xC7,
  0x1C, 0x1C, 0x71, 0xC3, 0xC7, 0x1E, 0x38, 0xE1, 0xFD, 0x8E, 0x0F, 0xB8,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0xCE,
  0x03, 0x8E, 0x03, 0x8E, 0x07, 0x8E, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x0F,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07,
  0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1C,
  0x1C, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x3E, 0x0E,
  0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x01,
  0xE1, 0xC0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBF, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xC1, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70,
  0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3,
  0x80, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3C, 0x07,
  0x1C, 0x07, 0x8E, 0x0F, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x87, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBF,
  0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x71, 0xFE, 0x71, 0xFE, 0x71, 0xFE, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xC0, 0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x78,
  0x0E, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x1C, 0x07,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0E, 0x03, 0xC3,
  0x80, 0xE1, 0xE0, 0x38, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x01, 0xE1, 0xC0,
  0x78, 0x70, 0x1C, 0x1C, 0x07, 0x0F, 0x01, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x01,
  0xE1, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x01,
  0xE1, 0xC0, 0x78, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C,
  0x07, 0x07, 0x80, 0xE1, 0xE0, 0x1C, 0x78, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0x87, 0x00, 0x70, 0xF0, 0x0E, 0x1E, 0x03, 0xC1, 0xC0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0F, 0x07, 0x01, 0xE0,
  0xE0, 0x3C, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03,
  0xC7, 0xC1, 0xF1, 0xB0, 0x7C, 0x6C, 0x3F, 0x1B, 0x0D, 0xCE, 0xC7, 0x63,
  0xB9, 0xB8, 0xEE, 0xEE, 0x39, 0xBB, 0x8E, 0x6C, 0xE3, 0x9F, 0x38, 0xE7,
  0x9E, 0x79, 0xE7, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F,
  0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x01, 0xE0, 0x0F, 0x01, 0xC3, 0xE0, 0xF1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F,
  0x83, 0x87, 0x60, 0xE1, 0xDC, 0x38, 0x77, 0x1E, 0x3D, 0xC7, 0x8F, 0x71,
  0xC3, 0x9C, 0x70, 0xE3, 0x9C, 0x38, 0xE7, 0x0E, 0x39, 0xC3, 0x8E, 0xF1,
  0xE3, 0xB8, 0x70, 0x6E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70,
  0x7E, 0x3C, 0x0F, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xBF, 0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x78,
  0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFC, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBF, 0x1C, 0x0F, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x07, 0x8F, 0x03, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x0E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x1C, 0x1C, 0x07, 0x8F,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x7E, 0x0E,
  0x07, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x78,
  0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x07, 0x8E,
  0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01,
  0xE3, 0x80, 0xF1, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38,
  0xF0, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0,
  0x71, 0xC0, 0x71, 0xC0, 0x73, 0xC0, 0x7B, 0x80, 0x7B, 0x80, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x70, 0xF0, 0xEE, 0x1C,
  0x39, 0xC7, 0x87, 0x38, 0xF0, 0xE7, 0x1E, 0x1C, 0xE3, 0xC7, 0x1C, 0xD8,
  0xE3, 0x1B, 0x1C, 0x63, 0x63, 0x1C, 0x6C, 0xE3, 0x99, 0x9C, 0x73, 0x33,
  0x8E, 0x66, 0x61, 0xD8, 0xDC, 0x3B, 0x1B, 0x87, 0x63, 0x70, 0xEC, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0,
  0x3C, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x78,
  0x38, 0x03, 0x87, 0x80, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x1D, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xB8, 0x00, 0x7B, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xE0,
  0x1E, 0x1E, 0x03, 0xC0, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0xDC, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x38, 0x1E,
  0x0F, 0x0F, 0x03, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0xF0, 0x07, 0xB8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x00,
  0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0xF0, 0x1C, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01,
  0xDC, 0x0E, 0x70, 0x39, 0xC1, 0xC3, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xE7,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0xF0, 0xE0,
  0xF0, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3E, 0x3E, 0x38, 0x1E, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF, 0xFC, 0x7F, 0xB8, 0x3F,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE3, 0xE0, 0x77, 0xF8, 0x3B, 0xFE, 0x1F, 0x1F, 0x1F, 0x07, 0x8F, 0x01,
  0xC7, 0x80, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x78,
  0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0xFF, 0xC3, 0xBF, 0xC3,
  0xCF, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x3E, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x3E, 0x78, 0x3F, 0xBC, 0x3F, 0xFE, 0x3E, 0x3E, 0x1C, 0x0F, 0x1E,
  0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x38,
  0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0xC3, 0xFD,
  0xC0, 0xFC, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80,
  0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1E, 0x07, 0xBC, 0x0E, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x87, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xCF, 0x0F,
  0xEF, 0x1F, 0xFF, 0x3E, 0x3E, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF8,
  0x7C, 0x7F, 0xFC, 0x3F, 0xBC, 0x1E, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x7C, 0x1D, 0xFE, 0x1D,
  0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x38,
  0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0x00, 0x38, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7E, 0x07, 0xFE, 0x03, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xF1, 0xC0, 0x78, 0x70, 0x3C, 0x1C, 0x0F, 0x07,
  0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC0, 0xF0,
  0x70, 0x3C, 0x1C, 0x07, 0x8F, 0x01, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80,
  0x1C, 0xE3, 0x87, 0x7B, 0xF1, 0xFF, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xCF,
  0x18, 0x73, 0x86, 0x1C, 0xE1, 0x8F, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x39, 0xE3, 0x8E, 0x70, 0xC3, 0x9C, 0x30, 0xE7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x3C, 0x71, 0xC0, 0x1C, 0x7C, 0x1D, 0xFE, 0x1D, 0xFF, 0x1F,
  0x1F, 0x3E, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1,
  0xF3, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x0F, 0x70, 0x1F, 0xE0, 0x3F,
  0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBC, 0x1E, 0x3F, 0xFC, 0x7F,
  0xF0, 0x3F, 0x80, 0x0E, 0x3E, 0x03, 0xBF, 0xC0, 0xEF, 0xF8, 0x3E, 0x3E,
  0x1F, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x87,
  0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC1,
  0xE0, 0xFF, 0xF8, 0x3B, 0xFC, 0x1E, 0x7E, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xCF, 0x0F,
  0xEF, 0x1F, 0xFF, 0x3E, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xFF, 0xFC, 0x7F, 0xB8, 0x3F, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x1C, 0xF8, 0x3D,
  0xFE, 0x3F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1C, 0x07, 0x3C, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70,
  0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0,
  0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x78, 0x70, 0x38,
  0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0xE1, 0xC1, 0xF8, 0x70, 0x6E, 0x1C, 0x3B,
  0x8D, 0x0E, 0xE3, 0x43, 0x38, 0xF1, 0xCE, 0x2C, 0x73, 0x9B, 0x18, 0xE6,
  0xCE, 0x39, 0xB3, 0x8E, 0xCC, 0xC3, 0xB3, 0x70, 0xEC, 0xDC, 0x3E, 0x37,
  0x0F, 0x8D, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x00, 0x1E, 0x01,
  0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x07, 0x3C,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0x73, 0xC0, 0x1E, 0x78, 0x07, 0x87, 0x81, 0xE0, 0xF0,
  0x78, 0x0F, 0x1F, 0x01, 0xE0, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70,
  0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F,
  0xB8, 0x0E, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x30, 0x07, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0x7F,
  0x87, 0xF3, 0xC7, 0xE1, 0xFE, 0xE1, 0xFE, 0xE0, 0xFC,
};

const GFXglyph JetBrainsMono_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 11, 9, 19, 6, -23 },
  { 37, 19, 23, 19, 1, -23 },
  { 92, 18, 32, 19, 1, -28 },
  { 164, 22, 24, 19, -1, -24 },
  { 230, 18, 24, 19, 1, -24 },
  { 284, 5, 9, 19, 9, -23 },
  { 290, 13, 31, 19, 5, -27 },
  { 341, 13, 31, 19, 2, -27 },
  { 392, 17, 17, 19, 2, -20 },
  { 429, 16, 15, 19, 2, -18 },
  { 459, 9, 10, 19, 3, -5 },
  { 471, 11, 3, 19, 4, -12 },
  { 476, 6, 5, 19, 6, -5 },
  { 480, 20, 31, 19, 0, -27 },
  { 558, 16, 24, 19, 2, -24 },
  { 606, 16, 23, 19, 1, -23 },
  { 652, 17, 24, 19, 1, -24 },
  { 703, 17, 23, 19, 1, -23 },
  { 752, 16, 23, 19, 2, -23 },
  { 798, 16, 23, 19, 2, -23 },
  { 844, 16, 23, 19, 1, -23 },
  { 890, 17, 23, 19, 3, -23 },
  { 939, 17, 24, 19, 1, -24 },
  { 990, 16, 24, 19, 3, -24 },
  { 1038, 8, 18, 19, 6, -18 },
  { 1056, 11, 23, 19, 3, -18 },
  { 1088, 15, 17, 19, 3, -19 },
  { 1120, 16, 11, 19, 2, -16 },
  { 1142, 16, 17, 19, 1, -19 },
  { 1176, 14, 23, 19, 4, -23 },
  { 1217, 20, 30, 19, 0, -24 },
  { 1292, 16, 23, 19, 0, -23 },
  { 1338, 18, 23, 19, 1, -23 },
  { 1390, 16, 24, 19, 2, -24 },
  { 1438, 17, 23, 19, 1, -23 },
  { 1487, 17, 23, 19, 2, -23 },
  { 1536, 18, 23, 19, 1, -23 },
  { 1588, 16, 24, 19, 2, -24 },
  { 1636, 18, 23, 19, 1, -23 },
  { 1688, 16, 23, 19, 2, -23 },
  { 1734, 18, 23, 19, 0, -23 },
  { 1786, 19, 23, 19, 1, -23 },
  { 1841, 14, 23, 19, 2, -23 },
  { 1882, 18, 23, 19, 1, -23 },
  { 1934, 18, 23, 19, 1, -23 },
  { 1986, 16, 24, 19, 2, -24 },
  { 2034, 18, 23, 19, 1, -23 },
  { 2086, 16, 30, 19, 2, -24 },
  { 2146, 18, 23, 19, 1, -23 },
  { 2198, 18, 24, 19, 1, -24 },
  { 2252, 17, 23, 19, 3, -23 },
  { 2301, 17, 23, 19, 2, -23 },
  { 2350, 16, 23, 19, 4, -23 },
  { 2396, 19, 23, 19, 2, -23 },
  { 2451, 20, 23, 19, 0, -23 },
  { 2509, 18, 23, 19, 3, -23 },
  { 2561, 18, 23, 19, 1, -23 },
  { 2613, 13, 31, 19, 4, -27 },
  { 2664, 10, 31, 19, 5, -27 },
  { 2703, 13, 31, 19, 3, -27 },
  { 2754, 14, 12, 19, 3, -23 },
  { 2775, 16, 3, 19, 0, 1 },
  { 2781, 7, 4, 19, 8, -25 },
  { 2785, 16, 18, 19, 2, -18 },
  { 2821, 17, 23, 19, 1, -23 },
  { 2870, 16, 18, 19, 2, -18 },
  { 2906, 17, 23, 19, 2, -23 },
  { 2955, 15, 18, 19, 2, -18 },
  { 2989, 22, 29, 19, -2, -23 },
  { 3069, 16, 24, 19, 2, -18 },
  { 3117, 16, 23, 19, 1, -23 },
  { 3163, 16, 25, 19, 1, -25 },
  { 3213, 17, 31, 19, 0, -25 },
  { 3279, 18, 23, 19, 1, -23 },
  { 3331, 14, 23, 19, 3, -23 },
  { 3372, 18, 18, 19, 0, -18 },
  { 3413, 16, 18, 19, 1, -18 },
  { 3449, 15, 18, 19, 2, -18 },
  { 3483, 18, 24, 19, 0, -18 },
  { 3537, 16, 24, 19, 2, -18 },
  { 3585, 16, 18, 19, 2, -18 },
  { 3621, 16, 18, 19, 1, -18 },
  { 3657, 16, 22, 19, 2, -22 },
  { 3701, 16, 18, 19, 2, -18 },
  { 3737, 16, 18, 19, 3, -18 },
  { 3773, 18, 18, 19, 2, -18 },
  { 3814, 19, 18, 19, 0, -18 },
  { 3857, 16, 24, 19, 2, -18 },
  { 3905, 17, 18, 19, 1, -18 },
  { 3944, 16, 31, 19, 3, -27 },
  { 4006, 8, 31, 19, 6, -27 },
  { 4037, 16, 31, 19, 1, -27 },
  { 4099, 16, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_MEDIUMITALIC32PT7B_H_
