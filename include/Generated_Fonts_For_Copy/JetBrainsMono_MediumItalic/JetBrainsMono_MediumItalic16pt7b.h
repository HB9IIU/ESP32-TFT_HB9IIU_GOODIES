#ifndef _JETBRAINSMONO_MEDIUMITALIC16PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x64, 0x00, 0xEC, 0xCF, 0x2D, 0xB6, 0x98, 0x0C,
  0xC2, 0x20, 0x98, 0xFF, 0x7F, 0xC4, 0xC3, 0x20, 0x8A, 0xFF, 0x19, 0x04,
  0x41, 0x30, 0x04, 0x04, 0x1E, 0x3F, 0x6B, 0x68, 0x68, 0x78, 0x1E, 0x16,
  0x12, 0xD6, 0xDE, 0x7C, 0x10, 0x20, 0x1C, 0x33, 0x66, 0x26, 0xC2, 0x48,
  0x3D, 0x01, 0xA0, 0x04, 0x00, 0xFC, 0x1A, 0x41, 0x24, 0x26, 0xCC, 0x38,
  0x0E, 0x0F, 0x8C, 0x46, 0x03, 0x01, 0xC1, 0xA6, 0x9A, 0x47, 0x63, 0x3B,
  0xCF, 0x60, 0x6D, 0x2C, 0x02, 0x0C, 0x70, 0xC3, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x03, 0x06, 0x0E, 0x0E, 0x0C, 0x20, 0xC1, 0x83, 0x0C, 0x10, 0x43,
  0x0C, 0x30, 0xC6, 0x18, 0xCE, 0x20, 0x08, 0x08, 0x89, 0xEF, 0x7E, 0x38,
  0x6C, 0xC6, 0x44, 0x08, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x39,
  0x98, 0xCC, 0x00, 0xFF, 0xE0, 0x5F, 0x00, 0x00, 0xC0, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x00, 0x1E, 0x3F, 0x63, 0x43, 0x43, 0x5B, 0xDB, 0xC2, 0xC2, 0xC6,
  0xCE, 0x78, 0x0C, 0x79, 0xB2, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x33, 0xFF,
  0xF0, 0x1E, 0x3F, 0x63, 0x43, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE,
  0xFE, 0x3F, 0x7F, 0x06, 0x0C, 0x18, 0x1E, 0x06, 0x02, 0x06, 0xC6, 0xCC,
  0x78, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x62, 0x62, 0xC6, 0xFE, 0xFE, 0x06,
  0x04, 0x3F, 0x3F, 0x60, 0x60, 0x6C, 0x7E, 0x62, 0x02, 0x06, 0xC6, 0xCE,
  0x78, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x7E, 0xE6, 0xC3, 0xC2, 0xC6, 0xCE,
  0x78, 0xFF, 0xFF, 0xC6, 0x86, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60,
  0xC0, 0x1E, 0x3F, 0x63, 0x63, 0x62, 0x3C, 0x3C, 0x46, 0xC2, 0xC6, 0xCE,
  0x7C, 0x1E, 0x3F, 0x63, 0x41, 0xC3, 0x63, 0x7E, 0x16, 0x0C, 0x18, 0x30,
  0x60, 0x77, 0x20, 0x00, 0x0E, 0xC0, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x8C,
  0x31, 0x86, 0x30, 0x01, 0x03, 0x0E, 0x78, 0xE0, 0xE0, 0x38, 0x0E, 0x02,
  0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x40, 0x60, 0x38, 0x0E, 0x03, 0x0E, 0x38,
  0xE0, 0x80, 0x78, 0xF8, 0x18, 0x30, 0x43, 0x9E, 0x30, 0x60, 0x03, 0x87,
  0x00, 0x0F, 0x06, 0x63, 0x0D, 0x83, 0x66, 0xD3, 0x64, 0x89, 0x22, 0xC9,
  0xB2, 0x6C, 0xFB, 0x00, 0xC0, 0x1E, 0x03, 0x80, 0x06, 0x0E, 0x0E, 0x1A,
  0x1A, 0x13, 0x33, 0x33, 0x7F, 0x63, 0x43, 0xC3, 0x7C, 0x7F, 0x63, 0x63,
  0x63, 0x7E, 0x7E, 0xC2, 0xC2, 0xC6, 0xCE, 0xFC, 0x1E, 0x3F, 0x63, 0x63,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC6, 0xEE, 0x7C, 0x7C, 0x7F, 0x63, 0x63,
  0x63, 0x43, 0xC3, 0xC2, 0xC2, 0xC6, 0xFC, 0xF8, 0x3F, 0xBF, 0x98, 0x0C,
  0x06, 0x03, 0xF1, 0xF8, 0x80, 0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF,
  0x98, 0x0C, 0x06, 0x03, 0xF1, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00,
  0x1E, 0x3F, 0x63, 0x63, 0x40, 0x40, 0xCF, 0xC2, 0xC2, 0xC6, 0xEE, 0x7C,
  0x61, 0x63, 0x63, 0x63, 0x63, 0x7F, 0x7E, 0xC2, 0xC6, 0xC6, 0xC6, 0x86,
  0x3F, 0x7F, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0xFE, 0xFC,
  0x07, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x61, 0x99,
  0x8F, 0x80, 0x61, 0xB1, 0x98, 0xCC, 0xC6, 0xC3, 0xE1, 0xF1, 0x98, 0xCC,
  0x63, 0x31, 0x90, 0xC0, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41,
  0x83, 0xFF, 0xF0, 0x31, 0xCC, 0x73, 0x98, 0xAA, 0x2A, 0x9B, 0x66, 0xD9,
  0x86, 0x61, 0x10, 0x44, 0x33, 0x0C, 0x71, 0x71, 0x71, 0x53, 0x53, 0x5B,
  0xDA, 0xCA, 0xCA, 0xCA, 0x8E, 0x8E, 0x1E, 0x3F, 0x63, 0x63, 0x43, 0x43,
  0xC2, 0xC2, 0xC6, 0xC6, 0xEC, 0x78, 0x7E, 0x3F, 0x98, 0xCC, 0x36, 0x12,
  0x19, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x1E, 0x3F, 0x63, 0x63,
  0x43, 0x43, 0xC3, 0xC2, 0xC2, 0xC6, 0xEE, 0x78, 0x18, 0x0C, 0x0C, 0x7C,
  0x7F, 0x63, 0x61, 0x63, 0x47, 0x7E, 0xCC, 0xCC, 0xCC, 0xC6, 0x86, 0x1E,
  0x3F, 0x63, 0x60, 0x60, 0x78, 0x1E, 0x06, 0x02, 0xC6, 0xCE, 0x7C, 0xFF,
  0xFF, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x61,
  0x61, 0x63, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0xC6, 0xC6, 0xEC, 0x78, 0xC3,
  0xC3, 0xC6, 0xC6, 0xC4, 0xCC, 0xCC, 0x58, 0x58, 0x50, 0x70, 0x60, 0xCC,
  0xE6, 0x73, 0x7A, 0xBD, 0x56, 0xAB, 0xAD, 0xD4, 0xAA, 0x55, 0x33, 0x99,
  0x80, 0x30, 0xCC, 0x61, 0x90, 0x6C, 0x1E, 0x03, 0x00, 0xC0, 0x78, 0x36,
  0x0C, 0x86, 0x33, 0x0C, 0x83, 0xC3, 0xC6, 0x4C, 0x6C, 0x78, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x3F, 0x7F, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0xC0, 0xFE, 0xFE, 0x3E, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x82, 0x0C, 0x1F, 0x3C, 0x00, 0xC1, 0x86, 0x18, 0x20, 0x83, 0x0C,
  0x30, 0x41, 0x86, 0x18, 0x20, 0xC0, 0x1E, 0x4C, 0x10, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC1, 0x8F, 0x3E, 0x00, 0x0C, 0x1C, 0x14, 0x36,
  0x22, 0x62, 0xC3, 0xFF, 0xFF, 0xCD, 0x80, 0x3B, 0x7F, 0x63, 0xC2, 0xC2,
  0xC6, 0xC6, 0xCE, 0x76, 0x60, 0x60, 0x60, 0x6E, 0x7E, 0x63, 0x42, 0xC2,
  0xC6, 0xC6, 0xEE, 0xBC, 0x1E, 0x7E, 0x63, 0xC0, 0xC0, 0xC0, 0xC6, 0xEE,
  0x7C, 0x01, 0x01, 0x03, 0x3B, 0x7F, 0x63, 0xC2, 0xC2, 0xC6, 0xC6, 0xCE,
  0x76, 0x1C, 0x76, 0x43, 0xC2, 0xFE, 0xC0, 0xC0, 0xC6, 0x7C, 0x01, 0xE0,
  0x7C, 0x18, 0x03, 0x03, 0xFC, 0x7F, 0x81, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x81, 0xF0, 0x3C, 0x00, 0x3B, 0x7F, 0x63, 0xC2, 0xC2,
  0xC6, 0xC6, 0x7E, 0x06, 0x04, 0x7C, 0xF8, 0x60, 0x60, 0x60, 0x7E, 0x7E,
  0x63, 0x42, 0xC2, 0xC6, 0xC6, 0xC6, 0x86, 0x04, 0x18, 0x30, 0x07, 0xCF,
  0x02, 0x0C, 0x18, 0x30, 0x67, 0xFF, 0xE0, 0x01, 0x01, 0xC0, 0xC0, 0x03,
  0xF1, 0xF8, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x63, 0xF1,
  0xE0, 0x20, 0x30, 0x18, 0x0C, 0x76, 0x62, 0x31, 0x31, 0xF0, 0xCC, 0x66,
  0x31, 0x18, 0xC0, 0x79, 0xF0, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60,
  0xF8, 0xF0, 0x3F, 0xB6, 0xDB, 0x6D, 0xB6, 0x9A, 0x4D, 0x25, 0x92, 0xDB,
  0x00, 0x7E, 0x7E, 0x63, 0x42, 0xC2, 0xC6, 0xC6, 0xC6, 0x86, 0x3C, 0x7E,
  0x43, 0xC3, 0xC2, 0xC6, 0xC6, 0xEC, 0x78, 0x37, 0x1F, 0x8C, 0x64, 0x26,
  0x13, 0x19, 0x8C, 0xEE, 0x5E, 0x20, 0x30, 0x18, 0x00, 0x3B, 0x7F, 0x43,
  0xC2, 0xC2, 0xC6, 0xC6, 0xCE, 0x76, 0x04, 0x04, 0x0C, 0x6E, 0x7F, 0x63,
  0x63, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x7F, 0x40, 0x60, 0x7C, 0x06,
  0x06, 0xC6, 0x7C, 0x18, 0x18, 0xFF, 0xFF, 0x10, 0x30, 0x30, 0x30, 0x30,
  0x3E, 0x3E, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0xC6, 0xC6, 0xEC, 0x78, 0xC1,
  0x43, 0x62, 0x66, 0x64, 0x6C, 0x28, 0x38, 0x30, 0xC9, 0xEC, 0xB6, 0x5B,
  0x6A, 0xA5, 0x52, 0xA9, 0x9C, 0xCC, 0x00, 0x31, 0x99, 0x86, 0x83, 0xC0,
  0xC0, 0xE0, 0xD8, 0xC4, 0xC3, 0x00, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0xC6,
  0xC6, 0x7E, 0x06, 0x04, 0x7C, 0xF8, 0x7F, 0x7F, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xFE, 0xFE, 0x07, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xE1, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xF0, 0x30, 0x33, 0x32, 0x26, 0x66,
  0x66, 0x4C, 0xCC, 0xC0, 0x1C, 0x16, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x3E,
  0x1E, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x83, 0x83, 0x80, 0x73, 0xDB, 0x8E,
};

const GFXglyph JetBrainsMono_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 16, 10, 1, -14 },
  { 42, 12, 12, 10, -1, -12 },
  { 60, 9, 12, 10, 0, -12 },
  { 74, 3, 5, 10, 4, -12 },
  { 76, 7, 16, 10, 2, -14 },
  { 90, 6, 16, 10, 1, -14 },
  { 102, 8, 9, 10, 1, -10 },
  { 111, 8, 8, 10, 1, -9 },
  { 119, 5, 5, 10, 1, -2 },
  { 123, 6, 2, 10, 2, -6 },
  { 125, 3, 3, 10, 3, -3 },
  { 127, 10, 15, 10, 0, -13 },
  { 146, 8, 12, 10, 1, -12 },
  { 158, 7, 12, 10, 1, -12 },
  { 169, 8, 12, 10, 1, -12 },
  { 181, 8, 12, 10, 1, -12 },
  { 193, 8, 12, 10, 1, -12 },
  { 205, 8, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 1, -12 },
  { 229, 8, 12, 10, 2, -12 },
  { 241, 8, 12, 10, 1, -12 },
  { 253, 8, 12, 10, 1, -12 },
  { 265, 4, 9, 10, 3, -9 },
  { 270, 6, 12, 10, 1, -9 },
  { 279, 8, 9, 10, 1, -10 },
  { 288, 8, 5, 10, 1, -8 },
  { 293, 8, 9, 10, 1, -10 },
  { 302, 7, 12, 10, 2, -12 },
  { 313, 10, 15, 10, 0, -12 },
  { 332, 8, 12, 10, 0, -12 },
  { 344, 8, 12, 10, 1, -12 },
  { 356, 8, 12, 10, 1, -12 },
  { 368, 8, 12, 10, 1, -12 },
  { 380, 9, 12, 10, 1, -12 },
  { 394, 9, 12, 10, 1, -12 },
  { 408, 8, 12, 10, 1, -12 },
  { 420, 8, 12, 10, 1, -12 },
  { 432, 8, 12, 10, 1, -12 },
  { 444, 9, 12, 10, 0, -12 },
  { 458, 9, 12, 10, 1, -12 },
  { 472, 7, 12, 10, 1, -12 },
  { 483, 10, 12, 10, 0, -12 },
  { 498, 8, 12, 10, 1, -12 },
  { 510, 8, 12, 10, 1, -12 },
  { 522, 9, 12, 10, 1, -12 },
  { 536, 8, 15, 10, 1, -12 },
  { 551, 8, 12, 10, 1, -12 },
  { 563, 8, 12, 10, 1, -12 },
  { 575, 8, 12, 10, 2, -12 },
  { 587, 8, 12, 10, 1, -12 },
  { 599, 8, 12, 10, 2, -12 },
  { 611, 9, 12, 10, 1, -12 },
  { 625, 10, 12, 10, 0, -12 },
  { 640, 8, 12, 10, 2, -12 },
  { 652, 8, 12, 10, 1, -12 },
  { 664, 7, 15, 10, 2, -13 },
  { 678, 6, 15, 10, 2, -13 },
  { 690, 7, 15, 10, 1, -13 },
  { 704, 8, 7, 10, 1, -12 },
  { 711, 8, 2, 10, 0, 0 },
  { 713, 3, 3, 10, 4, -13 },
  { 715, 8, 9, 10, 1, -9 },
  { 724, 8, 12, 10, 1, -12 },
  { 736, 8, 9, 10, 1, -9 },
  { 745, 8, 12, 10, 1, -12 },
  { 757, 8, 9, 10, 1, -9 },
  { 766, 11, 15, 10, -1, -12 },
  { 787, 8, 12, 10, 1, -9 },
  { 799, 8, 12, 10, 1, -12 },
  { 811, 7, 13, 10, 1, -13 },
  { 823, 9, 16, 10, 0, -13 },
  { 841, 9, 12, 10, 1, -12 },
  { 855, 7, 12, 10, 1, -12 },
  { 866, 9, 9, 10, 0, -9 },
  { 877, 8, 9, 10, 1, -9 },
  { 886, 8, 9, 10, 1, -9 },
  { 895, 9, 12, 10, 0, -9 },
  { 909, 8, 12, 10, 1, -9 },
  { 921, 8, 9, 10, 1, -9 },
  { 930, 8, 9, 10, 1, -9 },
  { 939, 8, 11, 10, 1, -11 },
  { 950, 8, 9, 10, 1, -9 },
  { 959, 8, 9, 10, 1, -9 },
  { 968, 9, 9, 10, 1, -9 },
  { 979, 9, 9, 10, 0, -9 },
  { 990, 8, 12, 10, 1, -9 },
  { 1002, 8, 9, 10, 1, -9 },
  { 1011, 9, 15, 10, 1, -13 },
  { 1028, 4, 15, 10, 3, -13 },
  { 1036, 9, 15, 10, 0, -13 },
  { 1053, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_MEDIUMITALIC16PT7B_H_
