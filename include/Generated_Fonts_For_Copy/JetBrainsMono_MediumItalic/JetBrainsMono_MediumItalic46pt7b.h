#ifndef _JETBRAINSMONO_MEDIUMITALIC46PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x1F, 0xBF, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x78, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC2,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0xE7, 0xE0, 0xFC, 0x71, 0xF0, 0x7C, 0x38,
  0xF8, 0x3E, 0x38, 0x7C, 0x1F, 0x1C, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xC7,
  0x00, 0x03, 0xF3, 0x80, 0x01, 0xFD, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x06, 0x7F, 0x00, 0x07, 0x1F, 0x80, 0x03, 0x87, 0xC0,
  0x01, 0xC3, 0xE0, 0x00, 0xE1, 0xF1, 0xF0, 0x70, 0xF8, 0xF8, 0x38, 0x7C,
  0x7E, 0x38, 0x7C, 0x3F, 0x1C, 0x7E, 0x0F, 0xEE, 0x7E, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xC0,
  0x07, 0x80, 0x7F, 0xE0, 0x07, 0x80, 0x7F, 0xF8, 0x07, 0x80, 0x3C, 0x3C,
  0x07, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x0F, 0x07,
  0x83, 0xC0, 0x07, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE3, 0xC0, 0x03, 0xC0,
  0xE3, 0xC0, 0x01, 0xF0, 0xF3, 0xC0, 0x00, 0x7F, 0xF3, 0xC0, 0x00, 0x3F,
  0xF9, 0xE0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE3, 0xF8, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0xF3, 0xFF, 0x80,
  0x00, 0xF3, 0xE3, 0xC0, 0x00, 0xF1, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x70,
  0x00, 0xF0, 0xF0, 0x38, 0x00, 0x78, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x03, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x01,
  0xF3, 0xF7, 0xE0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x1E, 0x1F, 0x07,
  0xCF, 0x87, 0xC0, 0xFF, 0xC1, 0xF0, 0x3F, 0xE0, 0x7C, 0x07, 0xF8, 0x1E,
  0x01, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0,
  0x3F, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xF9, 0xF0, 0x3F, 0xFC,
  0x7C, 0x07, 0xFC, 0x0F, 0x80, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0xBF, 0x7C,
  0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x78, 0x04, 0x78, 0x3C, 0x1E, 0x7F,
  0x1C, 0x3F, 0x3F, 0xCE, 0x7F, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xE7, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x70, 0x07, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0C, 0x1F, 0x9F,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x70, 0xF8,
  0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3F, 0x1F, 0x0F, 0x8F, 0x8F,
  0x87, 0x83, 0x87, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xF8, 0x3F, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xDF, 0x00, 0xFE, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x07,
  0xC0, 0x30, 0x1F, 0x00, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFD,
  0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0x3F,
  0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF3,
  0xF8, 0x03, 0xCF, 0xFC, 0x0F, 0xBF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x83,
  0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F,
  0x81, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0xF0, 0x03, 0xF7, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0x87, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x03, 0xE7,
  0xC0, 0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x8F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3F,
  0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xE0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x7C, 0x07, 0xE1, 0xF8,
  0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFE, 0x3F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7E, 0x03,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0x00, 0xFE, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F,
  0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E, 0x01, 0xFD, 0xE1, 0xE0,
  0x7F, 0xDE, 0x1E, 0x07, 0xFF, 0xE1, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x03,
  0xE3, 0xE1, 0xF0, 0x3E, 0x3C, 0x1E, 0x03, 0xC3, 0xC1, 0xE0, 0x3C, 0x3C,
  0x1E, 0x03, 0xC3, 0xC1, 0xE0, 0x3C, 0x3C, 0x1E, 0x03, 0xC7, 0xC3, 0xE0,
  0x7C, 0x7C, 0x3C, 0x07, 0xC7, 0x83, 0xC0, 0x78, 0x78, 0x3E, 0x07, 0x87,
  0x83, 0xE0, 0xF8, 0x78, 0x3F, 0xFF, 0x8F, 0x81, 0xFF, 0x78, 0xF8, 0x0F,
  0xE7, 0x8F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7C, 0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFB, 0xFE,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFB, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x1F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C,
  0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC,
  0x03, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03,
  0xE0, 0x0F, 0xC0, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xDC, 0x0E, 0xE0, 0x7F, 0x83, 0xDC, 0x0F, 0xF0, 0x7B, 0x83, 0xDE,
  0x0F, 0x78, 0x7B, 0xC1, 0xEF, 0x1E, 0xF0, 0x3D, 0xE3, 0xDE, 0x07, 0x9C,
  0x73, 0xC1, 0xF3, 0x9E, 0x78, 0x3E, 0x73, 0x9F, 0x07, 0x8E, 0xF3, 0xE0,
  0xF1, 0xFC, 0x78, 0x1E, 0x3F, 0x8F, 0x03, 0xC7, 0xE1, 0xE0, 0xF8, 0x7C,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0x83, 0xF0, 0x07, 0xC1, 0xFC,
  0x03, 0xE0, 0xFE, 0x01, 0xF0, 0xFF, 0x00, 0xF8, 0x7F, 0x80, 0x78, 0x3F,
  0xC0, 0x3C, 0x1E, 0xF0, 0x3E, 0x0F, 0x78, 0x1F, 0x07, 0xBC, 0x0F, 0x87,
  0xDE, 0x07, 0xC3, 0xEF, 0x03, 0xC1, 0xF7, 0xC1, 0xE0, 0xF9, 0xE1, 0xF0,
  0x78, 0xF0, 0xF8, 0x3C, 0x78, 0x7C, 0x3E, 0x3C, 0x3E, 0x1F, 0x1F, 0x1E,
  0x0F, 0x87, 0x8F, 0x07, 0xC3, 0xC7, 0x83, 0xC1, 0xE7, 0xC1, 0xE0, 0xF3,
  0xE0, 0xF0, 0x7D, 0xF0, 0xF8, 0x1E, 0xF8, 0x7C, 0x0F, 0x78, 0x3E, 0x07,
  0xBC, 0x1F, 0x03, 0xDE, 0x0F, 0x01, 0xFF, 0x07, 0x80, 0x7F, 0x87, 0xC0,
  0x3F, 0xC3, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF8, 0x07, 0xF0, 0x78,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xE0, 0x0F,
  0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x8F, 0xE0,
  0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xE0, 0x1F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x8F, 0xF0, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x0F, 0x81, 0xEF, 0x81, 0xE0, 0x7D,
  0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xB0, 0x3C, 0xF0, 0x7E,
  0x0F, 0x9E, 0x0F, 0xC1, 0xE3, 0xC1, 0xF8, 0x3C, 0x78, 0x37, 0x07, 0x8F,
  0x0E, 0xE1, 0xF1, 0xE1, 0xDC, 0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x8E, 0x70,
  0xF0, 0xF1, 0xCE, 0x3C, 0x1E, 0x39, 0xC7, 0x83, 0xC7, 0x38, 0xF0, 0xF9,
  0xC7, 0x1E, 0x1F, 0x38, 0xE7, 0x83, 0xC7, 0x1C, 0xF0, 0x79, 0xC3, 0x9E,
  0x0F, 0x38, 0x77, 0xC1, 0xE7, 0x0E, 0xF0, 0x3C, 0xE1, 0x9E, 0x07, 0xB8,
  0x33, 0xC0, 0xF7, 0x06, 0xF0, 0x1E, 0xE1, 0xDE, 0x03, 0xF8, 0x3B, 0xC0,
  0x7F, 0x07, 0x78, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xC3,
  0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x1E, 0x0F,
  0x00, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0x1F, 0x03, 0xFF, 0x9E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F,
  0x06, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x1F, 0xF9, 0xF0, 0x0F,
  0xF1, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xC0, 0x1F, 0x3F, 0xE0, 0x3C, 0xFF, 0xE0, 0xFB, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x0F, 0xE0, 0xFE, 0x3E, 0xFF, 0xF8, 0x7D, 0xFF, 0xE0, 0xF9, 0xFF,
  0x81, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x2F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0xFF, 0x8F, 0x80,
  0xFF, 0xE7, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xF0,
  0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF8,
  0x37, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xE0, 0x1F, 0xF9, 0xF0, 0x07,
  0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xC3, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x03,
  0xE3, 0xF0, 0x1F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xFC, 0x7C, 0x1F, 0xFC, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8,
  0x03, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x7F, 0x87, 0xFF, 0xDF, 0x0F, 0xFF,
  0xBC, 0x0F, 0xFE, 0xF8, 0x0F, 0xF1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xC0, 0x1F, 0x3F, 0xE0, 0x3E, 0xFF, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00,
  0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F,
  0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1C, 0x1E, 0x07, 0xBF, 0x1F, 0x87, 0xFF, 0xDF, 0xE3, 0xDF, 0xFF, 0xF1,
  0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x78, 0x3C, 0x3E, 0x3C, 0x1E, 0x1F,
  0x3E, 0x0E, 0x0F, 0x9F, 0x0F, 0x07, 0xCF, 0x87, 0x83, 0xC7, 0x83, 0xC1,
  0xE3, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF9, 0xF0, 0x70, 0x7C, 0xF8, 0x38,
  0x3E, 0x7C, 0x3C, 0x1E, 0x3E, 0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x07,
  0x87, 0xC7, 0x83, 0xC3, 0xE7, 0xC1, 0xC1, 0xF3, 0xE1, 0xE0, 0xF1, 0xF0,
  0xF0, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0x3F, 0xE0, 0x3C, 0xFF, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF8, 0x3F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xF3, 0xFE, 0x00, 0xF3, 0xFF, 0x80, 0xFB, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF6, 0x0F, 0xE0, 0xFB, 0xFF, 0xE0,
  0x7D, 0xFF, 0xE0, 0x3E, 0x7F, 0xE0, 0x1F, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x1F, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7F, 0x06, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x1F,
  0xF9, 0xF0, 0x0F, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x3F, 0xE0, 0x7D,
  0xFF, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0xBF, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0x1F, 0xE3, 0xF0,
  0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1E,
  0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0,
  0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x83,
  0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0, 0xF7, 0x83, 0xF0, 0xF3, 0xC3, 0xB8,
  0x79, 0xE1, 0xDC, 0x3C, 0xF0, 0xEE, 0x1E, 0x78, 0xE7, 0x1E, 0x3C, 0x73,
  0x8F, 0x1E, 0x39, 0xC7, 0x8F, 0x18, 0xE7, 0x87, 0x9C, 0x73, 0xC3, 0xCE,
  0x39, 0xE1, 0xE6, 0x1D, 0xE0, 0xF7, 0x0E, 0xF0, 0x7B, 0x87, 0x78, 0x3D,
  0xC3, 0xB8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x07, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0xC3, 0xFF, 0xEF, 0x87, 0xFF, 0xFE, 0x07,
  0xFE, 0x7C, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0x1F, 0xF8, 0x0F, 0x3F, 0xFC,
  0x1F, 0x3F, 0xFC, 0x1F, 0x7C, 0x7E, 0x1F, 0x78, 0x3F, 0x3E, 0x78, 0x1F,
  0xFE, 0x78, 0x1F, 0xFC, 0x78, 0x0F, 0xF8, 0x80, 0x03, 0xC0,
};

const GFXglyph JetBrainsMono_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 34, 28, 8, -34 },
  { 52, 17, 14, 28, 8, -34 },
  { 82, 27, 34, 28, 1, -34 },
  { 197, 25, 46, 28, 2, -40 },
  { 341, 33, 34, 28, -2, -34 },
  { 482, 26, 34, 28, 1, -34 },
  { 593, 7, 14, 28, 13, -34 },
  { 606, 19, 45, 28, 7, -39 },
  { 713, 20, 45, 28, 2, -39 },
  { 826, 25, 24, 28, 2, -28 },
  { 901, 22, 22, 28, 3, -26 },
  { 962, 13, 14, 28, 4, -7 },
  { 985, 16, 4, 28, 6, -17 },
  { 993, 9, 8, 28, 8, -8 },
  { 1002, 28, 43, 28, 0, -38 },
  { 1153, 25, 34, 28, 2, -34 },
  { 1260, 22, 34, 28, 2, -34 },
  { 1354, 24, 34, 28, 2, -34 },
  { 1456, 24, 34, 28, 2, -34 },
  { 1558, 23, 34, 28, 2, -34 },
  { 1656, 23, 34, 28, 3, -34 },
  { 1754, 23, 34, 28, 2, -34 },
  { 1852, 23, 34, 28, 5, -34 },
  { 1950, 24, 34, 28, 2, -34 },
  { 2052, 23, 34, 28, 4, -34 },
  { 2150, 12, 26, 28, 8, -26 },
  { 2189, 16, 33, 28, 4, -26 },
  { 2255, 22, 25, 28, 4, -28 },
  { 2324, 22, 16, 28, 3, -23 },
  { 2368, 23, 25, 28, 2, -28 },
  { 2440, 19, 34, 28, 6, -34 },
  { 2521, 28, 42, 28, 0, -34 },
  { 2668, 24, 34, 28, 0, -34 },
  { 2770, 25, 34, 28, 2, -34 },
  { 2877, 24, 34, 28, 3, -34 },
  { 2979, 24, 34, 28, 2, -34 },
  { 3081, 25, 34, 28, 2, -34 },
  { 3188, 26, 34, 28, 2, -34 },
  { 3299, 24, 34, 28, 3, -34 },
  { 3401, 25, 34, 28, 2, -34 },
  { 3508, 24, 34, 28, 2, -34 },
  { 3610, 26, 34, 28, 0, -34 },
  { 3721, 27, 34, 28, 2, -34 },
  { 3836, 20, 34, 28, 3, -34 },
  { 3921, 27, 34, 28, 1, -34 },
  { 4036, 25, 34, 28, 2, -34 },
  { 4143, 23, 34, 28, 3, -34 },
  { 4241, 26, 34, 28, 2, -34 },
  { 4352, 25, 42, 28, 2, -34 },
  { 4484, 25, 34, 28, 2, -34 },
  { 4591, 25, 34, 28, 2, -34 },
  { 4698, 24, 34, 28, 5, -34 },
  { 4800, 25, 34, 28, 2, -34 },
  { 4907, 24, 34, 28, 5, -34 },
  { 5009, 27, 34, 28, 3, -34 },
  { 5124, 29, 34, 28, 0, -34 },
  { 5248, 25, 34, 28, 5, -34 },
  { 5355, 25, 34, 28, 2, -34 },
  { 5462, 19, 43, 28, 6, -38 },
  { 5565, 15, 43, 28, 7, -38 },
  { 5646, 19, 43, 28, 4, -38 },
  { 5749, 21, 18, 28, 4, -34 },
  { 5797, 23, 4, 28, 0, 1 },
  { 5809, 9, 6, 28, 12, -36 },
  { 5816, 24, 26, 28, 2, -26 },
  { 5894, 23, 34, 28, 2, -34 },
  { 5992, 22, 26, 28, 3, -26 },
  { 6064, 25, 34, 28, 2, -34 },
  { 6171, 22, 26, 28, 3, -26 },
  { 6243, 31, 42, 28, -2, -34 },
  { 6406, 23, 34, 28, 3, -26 },
  { 6504, 23, 34, 28, 2, -34 },
  { 6602, 22, 36, 28, 2, -36 },
  { 6701, 25, 44, 28, 0, -36 },
  { 6839, 25, 34, 28, 2, -34 },
  { 6946, 20, 34, 28, 4, -34 },
  { 7031, 25, 26, 28, 1, -26 },
  { 7113, 23, 26, 28, 2, -26 },
  { 7188, 22, 26, 28, 3, -26 },
  { 7260, 25, 34, 28, 0, -26 },
  { 7367, 24, 34, 28, 2, -26 },
  { 7469, 23, 26, 28, 3, -26 },
  { 7544, 23, 26, 28, 2, -26 },
  { 7619, 22, 32, 28, 4, -32 },
  { 7707, 23, 25, 28, 3, -25 },
  { 7779, 23, 25, 28, 4, -25 },
  { 7851, 25, 25, 28, 3, -25 },
  { 7930, 27, 25, 28, 0, -25 },
  { 8015, 23, 33, 28, 3, -25 },
  { 8110, 23, 25, 28, 2, -25 },
  { 8182, 24, 43, 28, 4, -38 },
  { 8311, 11, 43, 28, 9, -38 },
  { 8371, 24, 43, 28, 1, -38 },
  { 8500, 24, 10, 28, 2, -21 },
};

const GFXfont JetBrainsMono_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_MEDIUMITALIC46PT7B_H_
