#ifndef _JETBRAINSMONO_MEDIUMITALIC43PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0xF8, 0x7D,
  0xE0, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x78, 0x3E, 0xF0,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3C, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x3C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x39, 0xF0, 0x7C, 0x61, 0xF0, 0xF0, 0xC3, 0xC3,
  0xE3, 0x87, 0x87, 0xC7, 0x00, 0x0F, 0x8E, 0x00, 0x1F, 0x9C, 0x00, 0x3F,
  0x38, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x33, 0xF0, 0x00, 0x63,
  0xE0, 0x01, 0xC3, 0xE0, 0x03, 0x87, 0xC0, 0x07, 0x0F, 0x1F, 0x0E, 0x1E,
  0x3E, 0x18, 0x7C, 0x7C, 0x30, 0xF8, 0xFC, 0xE7, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x01, 0xFE, 0x00, 0x78, 0x07, 0xFC,
  0x01, 0xE0, 0x1F, 0xFC, 0x03, 0x80, 0x78, 0x78, 0x0E, 0x00, 0xE0, 0x70,
  0x3C, 0x01, 0xC1, 0xE0, 0xF0, 0x03, 0x83, 0xC3, 0xC0, 0x0F, 0x07, 0x8F,
  0x00, 0x1E, 0x0F, 0x3C, 0x00, 0x3C, 0x1C, 0x70, 0x00, 0x7C, 0xF9, 0xC0,
  0x00, 0x7F, 0xE7, 0x80, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0xFC, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x03, 0xCF, 0xFC, 0x00,
  0x0F, 0x3C, 0x3C, 0x00, 0x3C, 0x70, 0x78, 0x00, 0x71, 0xE0, 0xF0, 0x01,
  0xC3, 0xC1, 0xE0, 0x07, 0x87, 0x83, 0x80, 0x1E, 0x0E, 0x07, 0x00, 0x78,
  0x1C, 0x1E, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x7F, 0xF0, 0x0E, 0x00,
  0x7F, 0xC0, 0x78, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xC0, 0x78,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0x3E, 0x7C, 0x1E,
  0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0xF8, 0x78, 0x1F, 0xF0,
  0x78, 0x1F, 0xF0, 0x78, 0x0F, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0,
  0x3F, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0xBE,
  0xFB, 0xCF, 0x3C, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0x07, 0x3F,
  0x1C, 0x3F, 0x7F, 0x19, 0xFF, 0xFF, 0xB7, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xE7,
  0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x3E,
  0x01, 0xC0, 0x38, 0x01, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1E, 0x1F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC2, 0x0F,
  0x8F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF8, 0xF1,
  0xF0, 0xE3, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xF0,
  0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xF8,
  0x18, 0x0F, 0x01, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F,
  0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7C, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3C, 0x3F, 0x00, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x70, 0x07, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7B, 0xFF,
  0xC1, 0xFC, 0x7F, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xFC, 0x0F, 0xBF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFE, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x7C,
  0x00, 0xFB, 0xE0, 0x0F, 0x9E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x1F, 0x9F, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF8, 0x7E,
  0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x01,
  0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC,
  0x7F, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x1F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xF0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78,
  0x07, 0xCF, 0x1E, 0x07, 0xFB, 0xC7, 0x83, 0xFE, 0xE1, 0xE1, 0xF0, 0xF8,
  0xF0, 0x78, 0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0xC3, 0xC0,
  0x78, 0xF0, 0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x1E, 0x0F, 0x03, 0xC7, 0x83,
  0xC0, 0xF1, 0xE0, 0xF0, 0x3C, 0x78, 0x7C, 0x1F, 0x1E, 0x1F, 0x07, 0x87,
  0x83, 0xE7, 0xE3, 0xC0, 0xFF, 0xB8, 0xF0, 0x1F, 0xDE, 0x3C, 0x01, 0x80,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0xFB, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1E, 0x0F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C,
  0x07, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF0,
  0x0F, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x3F,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x78, 0x03, 0xE0, 0xF0, 0x07, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0,
  0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0,
  0x3F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xF8, 0x0F, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x1E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x03,
  0xE0, 0xF0, 0x0F, 0xC3, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x1F, 0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0xFF, 0xE1, 0xE1, 0xFF, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x78, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7C, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x01,
  0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0x70, 0x77, 0x03, 0xB8, 0x3B, 0xC3, 0xBC, 0x1D,
  0xE1, 0xDE, 0x0E, 0x71, 0xEF, 0x0F, 0x38, 0xE7, 0x87, 0x9C, 0xF7, 0x83,
  0xCE, 0x73, 0xC1, 0xE7, 0x79, 0xE0, 0xF3, 0xF8, 0xF0, 0x78, 0xFC, 0xF8,
  0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0x0F, 0xE0, 0x1E, 0x1F, 0xC0, 0x3C, 0x3F, 0x80, 0x78, 0x7F,
  0x01, 0xF0, 0xFE, 0x03, 0xE1, 0xFE, 0x07, 0x87, 0xBC, 0x0F, 0x0F, 0x78,
  0x1E, 0x1E, 0xF0, 0x3C, 0x3D, 0xE0, 0x78, 0x79, 0xE1, 0xF0, 0xF3, 0xC3,
  0xE1, 0xE7, 0x87, 0x87, 0xCF, 0x0F, 0x0F, 0x9E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x3C, 0xF8, 0x78, 0x79, 0xF0, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x87,
  0xC1, 0xCF, 0x0F, 0x03, 0xDE, 0x1E, 0x07, 0xBC, 0x3C, 0x0F, 0x78, 0x78,
  0x1E, 0xE1, 0xF0, 0x1F, 0xC3, 0xE0, 0x3F, 0x87, 0x80, 0x7F, 0x0F, 0x00,
  0xFE, 0x1E, 0x01, 0xFC, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0,
  0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01,
  0xF0, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x07, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x3F, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1F,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00,
  0x3E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x03, 0xCF,
  0x07, 0xC1, 0xF3, 0xC1, 0xF0, 0x78, 0xF0, 0x7C, 0x1E, 0x3C, 0x3F, 0x07,
  0x8F, 0x0F, 0xC3, 0xC3, 0xC3, 0xF0, 0xF0, 0xF0, 0xDC, 0x3C, 0x38, 0x77,
  0x0F, 0x1E, 0x1D, 0xC7, 0x87, 0x87, 0x71, 0xE1, 0xE3, 0x9C, 0x78, 0x78,
  0xE7, 0x1E, 0x1E, 0x39, 0xCF, 0x07, 0x8C, 0x73, 0xC1, 0xE7, 0x18, 0xF0,
  0x79, 0xC6, 0x38, 0x1E, 0x71, 0x9E, 0x07, 0x98, 0x67, 0x81, 0xEE, 0x19,
  0xE0, 0x7B, 0x86, 0x70, 0x1E, 0xC1, 0xBC, 0x07, 0xF0, 0xEF, 0x01, 0xDC,
  0x3B, 0xC0, 0x77, 0x0E, 0xE0, 0x1D, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xBE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xF7, 0x00, 0x1E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x38, 0x0F,
  0x87, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8,
  0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xFC,
  0x00, 0xFC, 0x7C, 0x0F, 0xFD, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xEF,
  0x83, 0xFF, 0xBE, 0x07, 0xF8, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC7, 0xF0, 0x1F, 0x3F, 0xE0, 0x7D, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xF0, 0x7E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0xE0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xEF, 0xFC, 0x0F, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7C, 0x03,
  0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E,
  0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7E,
  0x3E, 0x03, 0xFF, 0x7C, 0x0F, 0xFE, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xBE, 0x07, 0xFF, 0x7C, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x1F, 0x8F, 0x80, 0x7C,
  0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xF8,
  0x3F, 0xF7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF3, 0xF8, 0x7F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0xFE, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0x0C, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE3, 0xF8, 0x1F, 0x3F, 0xE0, 0xFB, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x83, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0x78,
  0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0xE0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1E, 0x78, 0x7C, 0x1E, 0xFC, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0x3F, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E,
  0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x3E, 0x3C,
  0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x3C, 0x78, 0x38, 0x3C, 0x78,
  0x38, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0x78, 0x78, 0xF8, 0x78, 0x78, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x78, 0xF0,
  0x70, 0xF8, 0xF0, 0xF0, 0xF0, 0x1F, 0x1F, 0xC0, 0xF9, 0xFF, 0x07, 0xDF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x8F, 0x80, 0x7C,
  0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00,
  0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xC7, 0xF0, 0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x3F, 0x81, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3E, 0xFF, 0xC0, 0x3C, 0x7F, 0x80, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xDF, 0x1F, 0xC3,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x81, 0x78, 0x7F, 0xFF, 0xE0, 0xFF, 0xEF, 0x83,
  0xFF, 0xBE, 0x07, 0xF8, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0,
  0x7B, 0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x79, 0xF8, 0x07, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x00,
  0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x3C,
  0x0F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xEF, 0x0F, 0xC3,
  0xDE, 0x1F, 0x87, 0xBC, 0x37, 0x0F, 0x78, 0xEE, 0x3C, 0xF1, 0xDC, 0x79,
  0xE3, 0x38, 0xF3, 0xCE, 0x71, 0xC7, 0x9C, 0xE7, 0x8F, 0x39, 0xCF, 0x1E,
  0x63, 0x9C, 0x3D, 0xC7, 0x78, 0x7B, 0x8E, 0xF0, 0xF6, 0x1D, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0x60, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0xFE, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0x7C, 0x0F, 0xE3, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xC0, 0xF3, 0xFF, 0x03, 0xCF, 0xFE, 0x0F, 0x7C, 0x7C,
  0x3D, 0xE1, 0xF9, 0xF7, 0x83, 0xFF, 0x9E, 0x07, 0xFC, 0xF8, 0x0F, 0xE0,
  0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 15, 13, 26, 8, -31 },
  { 69, 25, 31, 26, 1, -31 },
  { 166, 23, 43, 26, 2, -37 },
  { 290, 31, 32, 26, -2, -32 },
  { 414, 24, 32, 26, 1, -32 },
  { 510, 6, 13, 26, 12, -31 },
  { 520, 19, 41, 26, 6, -36 },
  { 618, 18, 41, 26, 2, -36 },
  { 711, 23, 22, 26, 2, -26 },
  { 775, 21, 20, 26, 3, -24 },
  { 828, 12, 14, 26, 4, -7 },
  { 849, 15, 4, 26, 6, -16 },
  { 857, 9, 7, 26, 7, -7 },
  { 865, 27, 41, 26, 0, -36 },
  { 1004, 23, 32, 26, 2, -32 },
  { 1096, 20, 31, 26, 2, -31 },
  { 1174, 23, 32, 26, 2, -32 },
  { 1266, 22, 31, 26, 2, -31 },
  { 1352, 22, 31, 26, 2, -31 },
  { 1438, 22, 31, 26, 2, -31 },
  { 1524, 21, 31, 26, 2, -31 },
  { 1606, 21, 31, 26, 5, -31 },
  { 1688, 22, 32, 26, 2, -32 },
  { 1776, 21, 32, 26, 4, -32 },
  { 1860, 11, 24, 26, 7, -24 },
  { 1893, 14, 31, 26, 4, -24 },
  { 1948, 22, 23, 26, 3, -26 },
  { 2012, 21, 15, 26, 3, -22 },
  { 2052, 21, 23, 26, 2, -26 },
  { 2113, 18, 31, 26, 6, -31 },
  { 2183, 26, 40, 26, 0, -32 },
  { 2313, 22, 31, 26, 0, -31 },
  { 2399, 23, 31, 26, 2, -31 },
  { 2489, 23, 32, 26, 2, -32 },
  { 2581, 23, 31, 26, 2, -31 },
  { 2671, 24, 31, 26, 2, -31 },
  { 2764, 24, 31, 26, 2, -31 },
  { 2857, 23, 32, 26, 2, -32 },
  { 2949, 23, 31, 26, 2, -31 },
  { 3039, 23, 31, 26, 2, -31 },
  { 3129, 25, 31, 26, 0, -31 },
  { 3226, 25, 31, 26, 2, -31 },
  { 3323, 19, 31, 26, 3, -31 },
  { 3397, 25, 31, 26, 1, -31 },
  { 3494, 23, 31, 26, 2, -31 },
  { 3584, 23, 32, 26, 2, -32 },
  { 3676, 24, 31, 26, 2, -31 },
  { 3769, 23, 40, 26, 2, -32 },
  { 3884, 23, 31, 26, 2, -31 },
  { 3974, 23, 32, 26, 2, -32 },
  { 4066, 22, 31, 26, 5, -31 },
  { 4152, 23, 31, 26, 2, -31 },
  { 4242, 22, 31, 26, 5, -31 },
  { 4328, 26, 31, 26, 2, -31 },
  { 4429, 27, 31, 26, 0, -31 },
  { 4534, 24, 31, 26, 4, -31 },
  { 4627, 23, 31, 26, 2, -31 },
  { 4717, 17, 41, 26, 6, -36 },
  { 4805, 13, 41, 26, 7, -36 },
  { 4872, 17, 41, 26, 4, -36 },
  { 4960, 19, 16, 26, 4, -31 },
  { 4998, 21, 4, 26, 0, 1 },
  { 5009, 9, 6, 26, 11, -34 },
  { 5016, 22, 24, 26, 2, -24 },
  { 5082, 22, 31, 26, 2, -31 },
  { 5168, 22, 24, 26, 2, -24 },
  { 5234, 23, 31, 26, 2, -31 },
  { 5324, 21, 24, 26, 2, -24 },
  { 5387, 29, 39, 26, -2, -31 },
  { 5529, 21, 32, 26, 3, -24 },
  { 5613, 21, 31, 26, 2, -31 },
  { 5695, 22, 34, 26, 1, -34 },
  { 5789, 23, 42, 26, 0, -34 },
  { 5910, 24, 31, 26, 2, -31 },
  { 6003, 19, 31, 26, 4, -31 },
  { 6077, 24, 24, 26, 1, -24 },
  { 6149, 21, 24, 26, 2, -24 },
  { 6212, 21, 24, 26, 2, -24 },
  { 6275, 24, 32, 26, 0, -24 },
  { 6371, 22, 32, 26, 2, -24 },
  { 6459, 23, 24, 26, 2, -24 },
  { 6528, 21, 24, 26, 2, -24 },
  { 6591, 21, 30, 26, 3, -30 },
  { 6670, 22, 24, 26, 2, -24 },
  { 6736, 22, 24, 26, 4, -24 },
  { 6802, 23, 24, 26, 3, -24 },
  { 6871, 25, 24, 26, 0, -24 },
  { 6946, 21, 32, 26, 3, -24 },
  { 7030, 22, 24, 26, 2, -24 },
  { 7096, 22, 41, 26, 4, -36 },
  { 7209, 11, 41, 26, 8, -36 },
  { 7266, 22, 41, 26, 1, -36 },
  { 7379, 22, 10, 26, 2, -20 },
};

const GFXfont JetBrainsMono_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_MEDIUMITALIC43PT7B_H_
