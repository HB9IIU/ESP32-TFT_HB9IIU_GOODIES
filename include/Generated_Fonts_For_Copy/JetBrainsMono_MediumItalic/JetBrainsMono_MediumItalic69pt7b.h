#ifndef _JETBRAINSMONO_MEDIUMITALIC69PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F,
  0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x8F, 0x3F, 0xF0, 0x0F, 0xF8, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xC3, 0xFC,
  0x07, 0xF8, 0x3C, 0x0F, 0xE0, 0x3F, 0xC1, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0x03, 0xF8, 0x1F, 0xE0, 0x78, 0x1F, 0xC0, 0xFF, 0x07, 0xC0, 0x00, 0x07,
  0xF8, 0x3E, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0x00,
  0x00, 0x0F, 0xF8, 0x78, 0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x00, 0x01, 0xFF,
  0xDE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x7F,
  0xF0, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x00,
  0x7C, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x1E, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0xFE, 0x1F, 0xE0, 0x3C,
  0x0F, 0xF0, 0xFF, 0x03, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0x03, 0xF8, 0x3F,
  0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0x83, 0xFC, 0x07, 0xFC, 0x3C, 0x3F,
  0xE0, 0x3F, 0xF9, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x9F, 0xE0,
  0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0x7F,
  0x9F, 0xC0, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x40, 0x03, 0xF0, 0x00, 0x87, 0x80, 0x1F, 0x80, 0x3C, 0x3F, 0x80,
  0xF8, 0x0F, 0xE3, 0xFF, 0x07, 0xC1, 0xFF, 0x9F, 0xFC, 0x3C, 0x3F, 0xFD,
  0xFF, 0xF1, 0xE3, 0xFF, 0xFF, 0xFF, 0xEE, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x01, 0x00, 0x7F, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x0E, 0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F,
  0x83, 0xFC, 0x3F, 0x87, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0xC3, 0xF8, 0x3F,
  0x87, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x87, 0xF8, 0x1F, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x3E, 0x01,
  0xFE, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x7F, 0x00, 0x08, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC7, 0xFF, 0xC0, 0x07,
  0xFB, 0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF9,
  0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFB, 0xFC, 0x00, 0x3F, 0xF9, 0xFE, 0x00,
  0x00, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xF1,
  0xF8, 0x1F, 0x80, 0x1F, 0xFE, 0x7E, 0x0F, 0xE0, 0x0F, 0xFF, 0xDF, 0x83,
  0xF8, 0x07, 0xFF, 0xF7, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xF8, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x81, 0xF8,
  0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x81,
  0xFF, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0xF3, 0xE0,
  0x7E, 0x00, 0x7F, 0xFD, 0xF8, 0x1F, 0x80, 0x1F, 0xFE, 0x7E, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x83,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0x7E,
  0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xF7,
  0xC0, 0x7E, 0xFC, 0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xE7, 0xC0, 0x7C,
  0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x07, 0xE3, 0xE0, 0xF9, 0xF8, 0x07,
  0xE3, 0xE1, 0xF9, 0xF8, 0x07, 0xE3, 0xE1, 0xF1, 0xF8, 0x07, 0xE3, 0xE3,
  0xF1, 0xF8, 0x07, 0xE3, 0xE3, 0xE3, 0xF8, 0x0F, 0xE3, 0xE7, 0xE3, 0xF8,
  0x0F, 0xE3, 0xF7, 0xC3, 0xF8, 0x0F, 0xE1, 0xF7, 0xC3, 0xF0, 0x0F, 0xE1,
  0xFF, 0x87, 0xF0, 0x0F, 0xC1, 0xFF, 0x87, 0xF0, 0x0F, 0xC1, 0xFF, 0x87,
  0xF0, 0x1F, 0xC1, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0x07, 0xF0, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x00,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x3F,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0xC0, 0x3F, 0x7E, 0x00, 0x7F, 0x00, 0xFD,
  0xF8, 0x01, 0xFC, 0x07, 0xF7, 0xE0, 0x07, 0xF0, 0x1F, 0xDF, 0xC0, 0x1F,
  0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xC0, 0x3F, 0x87,
  0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x3F, 0x80,
  0x7F, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x1F,
  0x8F, 0xE0, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0xFC, 0x03,
  0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x80, 0x3F,
  0x7F, 0x00, 0xFC, 0x00, 0xFD, 0xFC, 0x07, 0xF0, 0x03, 0xF7, 0xF0, 0x1F,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0xFE,
  0x00, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x17, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xDE, 0x01, 0xF8, 0x7E,
  0x01, 0xEF, 0x01, 0xFC, 0x3F, 0x00, 0xF7, 0x80, 0xFE, 0x1F, 0x80, 0xFB,
  0xC0, 0x7E, 0x0F, 0xC0, 0x79, 0xE0, 0x3F, 0x07, 0xE0, 0x3D, 0xF0, 0x3F,
  0x83, 0xF0, 0x1E, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0x9F, 0x07, 0xF0, 0x3F, 0x07, 0xCF,
  0x03, 0xF0, 0x1F, 0x83, 0xE7, 0x81, 0xF8, 0x1F, 0xC1, 0xE3, 0xC0, 0xFC,
  0x0F, 0xE0, 0xF1, 0xE0, 0xFE, 0x07, 0xF0, 0xF8, 0xF0, 0x7E, 0x03, 0xF0,
  0x78, 0x78, 0x3F, 0x01, 0xF8, 0x3C, 0x3C, 0x1F, 0x80, 0xFC, 0x1E, 0x1E,
  0x1F, 0x80, 0x7E, 0x1F, 0x0F, 0x0F, 0xC0, 0x3F, 0x0F, 0x07, 0x87, 0xE0,
  0x1F, 0x87, 0x83, 0xC3, 0xF0, 0x0F, 0xC7, 0xC1, 0xE3, 0xF0, 0x07, 0xE3,
  0xE0, 0xF1, 0xF8, 0x03, 0xF1, 0xE0, 0x78, 0xFC, 0x01, 0xF8, 0xF0, 0x3C,
  0x7E, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0x7E, 0x78, 0x1F, 0x3F, 0x00,
  0x3F, 0x3C, 0x0F, 0x9F, 0x80, 0x1F, 0xBE, 0x07, 0xCF, 0x80, 0x0F, 0xDF,
  0x03, 0xEF, 0xC0, 0x07, 0xEF, 0x01, 0xE7, 0xE0, 0x07, 0xE7, 0x80, 0xF3,
  0xF0, 0x03, 0xF7, 0xC0, 0x7B, 0xF0, 0x01, 0xFB, 0xC0, 0x3D, 0xF8, 0x00,
  0xFD, 0xE0, 0x1E, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x7E, 0x00, 0x3F, 0xF8,
  0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x00,
  0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xBF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFC, 0x01,
  0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xC1, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x83,
  0xFF, 0x80, 0x07, 0xF1, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x3F,
  0xDF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0xFF,
  0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xFE, 0x00, 0xFE,
  0x1F, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0xC0, 0x01,
  0xFF, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0xFE, 0x7F,
  0x00, 0x3F, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFD, 0xFC, 0x00,
  0xFF, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0x0F, 0xFF, 0xC7,
  0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xFF,
  0xCF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x7F, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x7F,
  0x00, 0x1F, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x03, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x83, 0xFF,
  0x80, 0x07, 0xF1, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xDF,
  0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x07, 0xE3, 0xF8, 0x1F, 0xE0, 0x0F, 0xCF,
  0xF8, 0x7F, 0xE0, 0x1F, 0xBF, 0xF9, 0xFF, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF,
  0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0x80,
  0xFE, 0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0x80, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xF0,
  0x03, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF,
  0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0x8F, 0xFF,
  0xC0, 0x03, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xFF, 0xFC, 0x00, 0xFE,
  0xFF, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF7, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xF0, 0x03, 0xFC, 0xFF,
  0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xCF,
  0xE0, 0x1F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xFE, 0x3F,
  0x80, 0x1F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xC1, 0xFE, 0x00, 0x03, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x07, 0xFF, 0x00,
  0x0F, 0xE3, 0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF,
  0xF8, 0x0F, 0xEF, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xA0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0xC0, 0x3F, 0x7E, 0x01, 0xFE, 0x01, 0xFB, 0xF0, 0x1E, 0xF0, 0x1F, 0x9F,
  0x80, 0xF7, 0x80, 0xFC, 0xFC, 0x07, 0xBC, 0x07, 0xE7, 0xE0, 0x7D, 0xE0,
  0x7E, 0x3F, 0x03, 0xCF, 0x03, 0xF1, 0xF8, 0x1E, 0x78, 0x1F, 0x8F, 0xC1,
  0xF3, 0xC0, 0xF8, 0x7E, 0x0F, 0x1E, 0x0F, 0xC3, 0xF0, 0x78, 0xF0, 0x7E,
  0x1F, 0x83, 0xC7, 0x83, 0xF0, 0xFC, 0x3C, 0x3C, 0x3F, 0x07, 0xE1, 0xE1,
  0xE1, 0xF8, 0x3F, 0x0F, 0x0F, 0x0F, 0xC1, 0xF8, 0xF0, 0x78, 0xFC, 0x0F,
  0xC7, 0x83, 0xC7, 0xE0, 0x7E, 0x3C, 0x1E, 0x3F, 0x03, 0xF3, 0xE0, 0xF1,
  0xF0, 0x1F, 0x9E, 0x07, 0x9F, 0x80, 0xFC, 0xF0, 0x3C, 0xFC, 0x07, 0xEF,
  0x81, 0xE7, 0xC0, 0x3F, 0x78, 0x0F, 0x7E, 0x01, 0xF3, 0xC0, 0x7B, 0xF0,
  0x0F, 0xBE, 0x03, 0xDF, 0x00, 0x7D, 0xE0, 0x1F, 0xF8, 0x03, 0xEF, 0x00,
  0xFF, 0xC0, 0x1F, 0x78, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x03, 0xDF, 0xC0, 0x7F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xF3, 0xF8, 0x00, 0xFF, 0xF8,
  0x7F, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x17, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xFE,
  0x00, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xDF, 0xE3, 0xFE, 0x03, 0xF3, 0xF8,
  0x3F, 0xC0, 0xFE, 0x7E, 0x03, 0xFC, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0xF3,
  0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF,
  0xE1, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 17, 50, 41, 13, -50 },
  { 108, 25, 20, 41, 12, -50 },
  { 171, 41, 50, 41, 1, -50 },
  { 428, 37, 70, 41, 3, -60 },
  { 752, 49, 51, 41, -3, -51 },
  { 1065, 39, 52, 41, 1, -51 },
  { 1319, 10, 20, 41, 19, -50 },
  { 1344, 30, 67, 41, 10, -58 },
  { 1596, 28, 67, 41, 4, -58 },
  { 1831, 37, 36, 41, 3, -42 },
  { 1998, 34, 33, 41, 4, -39 },
  { 2139, 19, 21, 41, 6, -10 },
  { 2189, 24, 7, 41, 9, -26 },
  { 2210, 13, 13, 41, 12, -12 },
  { 2232, 43, 65, 41, 0, -57 },
  { 2582, 36, 52, 41, 4, -51 },
  { 2816, 33, 50, 41, 3, -50 },
  { 3023, 36, 51, 41, 3, -51 },
  { 3253, 36, 51, 41, 3, -50 },
  { 3483, 34, 50, 41, 4, -50 },
  { 3696, 35, 51, 41, 4, -50 },
  { 3920, 34, 51, 41, 3, -50 },
  { 4137, 34, 50, 41, 8, -50 },
  { 4350, 36, 52, 41, 3, -51 },
  { 4584, 34, 51, 41, 6, -51 },
  { 4801, 17, 40, 41, 12, -39 },
  { 4886, 23, 50, 41, 6, -39 },
  { 5030, 33, 37, 41, 6, -41 },
  { 5183, 34, 24, 41, 4, -35 },
  { 5285, 34, 37, 41, 3, -41 },
  { 5443, 29, 50, 41, 9, -50 },
  { 5625, 42, 63, 41, 0, -51 },
  { 5956, 35, 50, 41, 0, -50 },
  { 6175, 37, 50, 41, 3, -50 },
  { 6407, 36, 52, 41, 4, -51 },
  { 6641, 36, 50, 41, 3, -50 },
  { 6866, 38, 50, 41, 3, -50 },
  { 7104, 38, 50, 41, 3, -50 },
  { 7342, 36, 52, 41, 4, -51 },
  { 7576, 38, 50, 41, 3, -50 },
  { 7814, 36, 50, 41, 4, -50 },
  { 8039, 39, 51, 41, 1, -50 },
  { 8288, 40, 50, 41, 3, -50 },
  { 8538, 31, 50, 41, 4, -50 },
  { 8732, 40, 50, 41, 2, -50 },
  { 8982, 38, 50, 41, 3, -50 },
  { 9220, 35, 52, 41, 4, -51 },
  { 9448, 39, 50, 41, 3, -50 },
  { 9692, 36, 63, 41, 4, -51 },
  { 9976, 38, 50, 41, 3, -50 },
  { 10214, 37, 52, 41, 3, -51 },
  { 10455, 36, 50, 41, 7, -50 },
  { 10680, 37, 51, 41, 4, -50 },
  { 10916, 35, 50, 41, 8, -50 },
  { 11135, 41, 50, 41, 4, -50 },
  { 11392, 44, 50, 41, -1, -50 },
  { 11667, 37, 50, 41, 7, -50 },
  { 11899, 37, 50, 41, 3, -50 },
  { 12131, 29, 65, 41, 9, -57 },
  { 12367, 22, 65, 41, 11, -57 },
  { 12546, 28, 65, 41, 6, -57 },
  { 12774, 31, 27, 41, 6, -50 },
  { 12879, 34, 6, 41, 0, 2 },
  { 12905, 13, 10, 41, 18, -54 },
  { 12922, 35, 40, 41, 4, -39 },
  { 13097, 35, 51, 41, 3, -50 },
  { 13321, 34, 40, 41, 4, -39 },
  { 13491, 37, 51, 41, 4, -50 },
  { 13727, 33, 40, 41, 4, -39 },
  { 13892, 48, 62, 41, -4, -50 },
  { 14264, 35, 51, 41, 4, -39 },
  { 14488, 35, 50, 41, 3, -50 },
  { 14707, 34, 54, 41, 2, -54 },
  { 14937, 36, 66, 41, 1, -54 },
  { 15234, 38, 50, 41, 3, -50 },
  { 15472, 30, 50, 41, 6, -50 },
  { 15660, 39, 39, 41, 1, -39 },
  { 15851, 35, 39, 41, 3, -39 },
  { 16022, 33, 40, 41, 4, -39 },
  { 16187, 37, 51, 41, 1, -39 },
  { 16423, 35, 51, 41, 4, -39 },
  { 16647, 35, 39, 41, 4, -39 },
  { 16818, 35, 40, 41, 3, -39 },
  { 16993, 34, 48, 41, 5, -48 },
  { 17197, 35, 39, 41, 4, -38 },
  { 17368, 35, 38, 41, 6, -38 },
  { 17535, 37, 38, 41, 5, -38 },
  { 17711, 40, 38, 41, 0, -38 },
  { 17901, 35, 50, 41, 4, -38 },
  { 18120, 35, 38, 41, 3, -38 },
  { 18287, 36, 65, 41, 6, -57 },
  { 18580, 17, 65, 41, 13, -57 },
  { 18719, 36, 65, 41, 1, -57 },
  { 19012, 35, 15, 41, 4, -32 },
};

const GFXfont JetBrainsMono_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_MEDIUMITALIC69PT7B_H_
