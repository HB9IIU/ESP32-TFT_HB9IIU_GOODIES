#ifndef _JETBRAINSMONO_MEDIUMITALIC62PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFB, 0xDF, 0xF8, 0x07, 0xF8, 0xF1, 0xFE, 0x01, 0xFC,
  0x3C, 0x3F, 0x80, 0xFE, 0x0F, 0x0F, 0xE0, 0x3F, 0x83, 0xC1, 0xF8, 0x0F,
  0xE0, 0xE0, 0x7E, 0x03, 0xF0, 0x78, 0x20, 0x01, 0xFC, 0x1E, 0x00, 0x00,
  0x7F, 0x07, 0x80, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x03, 0xF8, 0x78, 0x00,
  0x00, 0xFF, 0x1C, 0x00, 0x00, 0x3F, 0xEF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xBF, 0xF0, 0x00,
  0x01, 0xE3, 0xFC, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x00, 0x1C, 0x1F, 0xE0,
  0x00, 0x0F, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x3F,
  0x07, 0xF0, 0x3C, 0x0F, 0xC1, 0xFC, 0x0F, 0x07, 0xF0, 0x7F, 0x03, 0x81,
  0xFC, 0x1F, 0xC1, 0xE0, 0xFE, 0x07, 0xF8, 0x78, 0x7F, 0x81, 0xFF, 0x1E,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x7E,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0x0F,
  0x8F, 0xC0, 0x00, 0x3F, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xC0, 0x00,
  0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xC7, 0xFF, 0xF0, 0x00,
  0x01, 0xF1, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3E,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0x1F,
  0xF7, 0xF0, 0x0F, 0xC3, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xC7, 0xF0, 0x7E, 0x03, 0xF9,
  0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xFB, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x10, 0x01, 0xF0, 0x01, 0x0E, 0x00, 0xF8, 0x03, 0x8F, 0xC0, 0x7C, 0x0F,
  0xC7, 0xF8, 0x3C, 0x1F, 0xF7, 0xFF, 0x1E, 0x3F, 0xFF, 0xFF, 0xCE, 0x7F,
  0xFF, 0xFF, 0xF7, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x1F, 0xC3, 0xFC, 0x7F, 0xE7,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0xC7, 0xF8, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x38, 0x0F, 0xC1, 0xF8,
  0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFE, 0xFE, 0x00, 0x7F, 0xC7, 0xE0, 0x07, 0xFC, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0x70, 0x07,
  0xF0, 0x02, 0x00, 0x3F, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE3, 0xFF, 0x80, 0x0F, 0xE7, 0xFF,
  0xE0, 0x0F, 0xEF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x0F, 0xEF, 0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x7F, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x07, 0x87, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xF8, 0x3F, 0x00,
  0x7F, 0xF3, 0xE0, 0xFC, 0x03, 0xFF, 0xCF, 0x83, 0xF0, 0x1F, 0xFF, 0xBE,
  0x0F, 0x80, 0x7F, 0x0F, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0,
  0xFF, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0x00, 0xFF, 0xFB, 0xE0, 0x7C,
  0x01, 0xFF, 0xCF, 0x83, 0xF0, 0x03, 0xFE, 0x3E, 0x0F, 0xC0, 0x01, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x07,
  0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFF, 0x81, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0xFC,
  0x3F, 0x03, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xF8,
  0x7F, 0x03, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xF3, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x17, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x1E, 0xF0, 0x03, 0xFF, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F,
  0x7C, 0x07, 0xDF, 0x00, 0xF9, 0xE0, 0x7C, 0xF8, 0x07, 0xCF, 0x03, 0xEF,
  0xC0, 0x3E, 0x7C, 0x3E, 0x7E, 0x03, 0xF3, 0xE1, 0xF3, 0xE0, 0x1F, 0x9F,
  0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x07, 0xE7, 0xCF, 0x8F, 0xC0,
  0x3F, 0x1E, 0x7C, 0x7E, 0x01, 0xF0, 0xF3, 0xC3, 0xF0, 0x1F, 0x87, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0xF1, 0xF8, 0x07, 0xE1, 0xFF, 0x0F, 0xC0, 0x3F,
  0x0F, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0x00,
  0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0x01, 0xF3,
  0xE0, 0x0F, 0xC0, 0x7E, 0x7C, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x01,
  0xF9, 0xF8, 0x0F, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x00, 0xFC, 0x7C, 0x07, 0xE0, 0x3F, 0x8F, 0xC1, 0xFC, 0x07, 0xF1, 0xF8,
  0x3F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0xFC, 0x03, 0xF0,
  0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0xFE, 0x03,
  0xF8, 0x3F, 0x1F, 0xC0, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xC0, 0x7C, 0x7E,
  0x01, 0xF8, 0x0F, 0x8F, 0xC0, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xE0, 0x3F,
  0x3F, 0x01, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xE0,
  0x0F, 0xBF, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFC,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x07,
  0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0xF8, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x1F,
  0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x80, 0x7E, 0x3E, 0x01, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0xE0, 0x3F, 0x1F,
  0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0xC0,
  0x7C, 0x3F, 0x03, 0xDE, 0x07, 0xE1, 0xF8, 0x1E, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF7, 0x81, 0xF0, 0x7E, 0x07, 0xBC, 0x0F, 0x83, 0xF0, 0x79, 0xE0, 0xFC,
  0x1F, 0x83, 0xCF, 0x07, 0xE0, 0xFC, 0x1E, 0x78, 0x3E, 0x07, 0xE0, 0xE3,
  0xC3, 0xF0, 0x3F, 0x0F, 0x1E, 0x1F, 0x81, 0xF0, 0x78, 0xE0, 0xFC, 0x0F,
  0x83, 0xC7, 0x07, 0xC0, 0x7C, 0x3C, 0x38, 0x7E, 0x03, 0xE1, 0xE3, 0xC3,
  0xF0, 0x1F, 0x0F, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0xF0, 0xF8, 0x07, 0xC7,
  0x87, 0x8F, 0xC0, 0x7E, 0x3C, 0x3C, 0x7E, 0x03, 0xF1, 0xE1, 0xE3, 0xE0,
  0x1F, 0x9E, 0x0F, 0x1F, 0x00, 0xFC, 0xF0, 0x79, 0xF8, 0x07, 0xE7, 0x83,
  0xCF, 0xC0, 0x3F, 0x3C, 0x1E, 0x7C, 0x01, 0xFB, 0xC0, 0xF3, 0xE0, 0x0F,
  0xDE, 0x07, 0xBF, 0x00, 0x7C, 0xF0, 0x3D, 0xF8, 0x03, 0xEF, 0x01, 0xEF,
  0x80, 0x1F, 0x78, 0x0F, 0x7C, 0x00, 0xFB, 0xC0, 0x7F, 0xE0, 0x07, 0xDE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xEF, 0x80,
  0x0F, 0xF8, 0x07, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x00, 0x7F, 0xFC, 0x7E,
  0x00, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xF1, 0xF7, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xFF, 0xE0,
  0x03, 0xF1, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xC0,
  0x7F, 0x7F, 0xFF, 0x80, 0x7E, 0x3F, 0xFE, 0x00, 0xFE, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x07,
  0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xC7,
  0xE0, 0x07, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xE3, 0xEF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF7, 0xF0,
  0x07, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x7F, 0xE0, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xE1, 0xFC, 0x03, 0xFF,
  0xE3, 0xF0, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xFF, 0x7E, 0x03, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xF9, 0xF8, 0x07, 0xFF,
  0xE7, 0xF0, 0x07, 0xFF, 0x8F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xFF,
  0xE0, 0x03, 0xF1, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0xFC, 0xFE, 0x0F, 0xE0, 0x1F, 0xBF, 0xE3, 0xFE,
  0x03, 0xFF, 0xFC, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0x07,
  0xE0, 0x7C, 0x07, 0xE1, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x3F,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0,
  0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x81,
  0xF0, 0x1F, 0x87, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x1F,
  0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x1F,
  0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xF0, 0x07, 0xF3, 0xFF,
  0xF8, 0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x07, 0x80,
  0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x7E, 0x3F, 0xFE, 0x00, 0x7F, 0x3F, 0xFF,
  0x80, 0x3F, 0xBF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0,
  0x1F, 0x8F, 0xFF, 0x80, 0x0F, 0xC3, 0xFF, 0x80, 0x0F, 0xE0, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x7F, 0x00, 0x7F, 0xFC, 0x7E, 0x01, 0xFF, 0xFE, 0x7E, 0x03, 0xFF,
  0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8,
  0x07, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xE0, 0x7F, 0xF1, 0xF7, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x8F, 0xC0, 0x07, 0xFE,
  0x0F, 0xC0, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xC3, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xC0, 0x3F, 0x3F,
  0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFB, 0xF0, 0x1F, 0xC0, 0x3E, 0xFC, 0x07, 0xF0, 0x1F, 0xBF, 0x01, 0xFC,
  0x07, 0xCF, 0xC0, 0xFF, 0x01, 0xF3, 0xF0, 0x3F, 0xC0, 0xFC, 0xFC, 0x0E,
  0xF0, 0x3E, 0x3F, 0x07, 0xBC, 0x0F, 0x8F, 0xC1, 0xEF, 0x07, 0xE3, 0xF0,
  0x73, 0xC1, 0xF0, 0xFC, 0x3C, 0xF0, 0x7C, 0x3F, 0x0F, 0x3C, 0x1F, 0x0F,
  0xC3, 0xCF, 0x0F, 0xC3, 0xF1, 0xE3, 0xC3, 0xE0, 0xFC, 0x78, 0xF0, 0xF8,
  0x3F, 0x1E, 0x3C, 0x7E, 0x0F, 0xCF, 0x0F, 0x1F, 0x03, 0xF3, 0xC3, 0xC7,
  0xC0, 0xFC, 0xF0, 0xF3, 0xF0, 0x3F, 0x78, 0x3C, 0xF8, 0x0F, 0x9E, 0x0F,
  0x3E, 0x03, 0xE7, 0x83, 0xDF, 0x80, 0xF9, 0xC0, 0xF7, 0xC0, 0x3E, 0xF0,
  0x3D, 0xF0, 0x0F, 0xBC, 0x0F, 0x7C, 0x03, 0xEE, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xC0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0x7E, 0x03, 0xFF,
  0xFD, 0xFC, 0x03, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x30,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0x0F, 0xFF, 0x80, 0x3F, 0x1F, 0xFF, 0xC0,
  0x3F, 0x1F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xE0, 0x3F, 0x3F, 0x0F, 0xE0,
  0x7E, 0x7E, 0x07, 0xF0, 0x7E, 0x7E, 0x03, 0xFD, 0xFE, 0x7E, 0x03, 0xFF,
  0xFC, 0x7E, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 45, 37, 11, -45 },
  { 91, 22, 18, 37, 11, -45 },
  { 141, 37, 45, 37, 1, -45 },
  { 350, 34, 63, 37, 2, -54 },
  { 618, 43, 46, 37, -2, -46 },
  { 866, 35, 47, 37, 1, -46 },
  { 1072, 9, 18, 37, 17, -45 },
  { 1093, 27, 60, 37, 9, -52 },
  { 1296, 26, 60, 37, 3, -52 },
  { 1491, 33, 32, 37, 3, -38 },
  { 1623, 30, 29, 37, 4, -35 },
  { 1732, 18, 19, 37, 5, -9 },
  { 1775, 22, 7, 37, 8, -24 },
  { 1795, 12, 11, 37, 11, -10 },
  { 1812, 38, 58, 37, 0, -51 },
  { 2088, 33, 47, 37, 3, -46 },
  { 2282, 29, 45, 37, 3, -45 },
  { 2446, 32, 46, 37, 3, -46 },
  { 2630, 32, 46, 37, 3, -45 },
  { 2814, 31, 45, 37, 3, -45 },
  { 2989, 32, 46, 37, 3, -45 },
  { 3173, 31, 46, 37, 3, -45 },
  { 3352, 31, 45, 37, 7, -45 },
  { 3527, 32, 47, 37, 3, -46 },
  { 3715, 31, 46, 37, 5, -46 },
  { 3894, 15, 36, 37, 11, -35 },
  { 3962, 20, 45, 37, 6, -35 },
  { 4075, 30, 33, 37, 5, -37 },
  { 4199, 30, 21, 37, 4, -31 },
  { 4278, 30, 33, 37, 3, -37 },
  { 4402, 26, 45, 37, 8, -45 },
  { 4549, 38, 57, 37, 0, -46 },
  { 4820, 32, 45, 37, 0, -45 },
  { 5000, 33, 45, 37, 3, -45 },
  { 5186, 32, 47, 37, 4, -46 },
  { 5374, 33, 45, 37, 2, -45 },
  { 5560, 34, 45, 37, 3, -45 },
  { 5752, 34, 45, 37, 3, -45 },
  { 5944, 32, 47, 37, 4, -46 },
  { 6132, 33, 45, 37, 3, -45 },
  { 6318, 33, 45, 37, 3, -45 },
  { 6504, 35, 46, 37, 1, -45 },
  { 6706, 37, 45, 37, 2, -45 },
  { 6915, 28, 45, 37, 4, -45 },
  { 7073, 37, 45, 37, 1, -45 },
  { 7282, 35, 45, 37, 2, -45 },
  { 7479, 31, 47, 37, 4, -46 },
  { 7662, 35, 45, 37, 2, -45 },
  { 7859, 33, 57, 37, 3, -46 },
  { 8095, 35, 45, 37, 2, -45 },
  { 8292, 34, 47, 37, 2, -46 },
  { 8492, 32, 45, 37, 7, -45 },
  { 8672, 34, 46, 37, 3, -45 },
  { 8868, 32, 45, 37, 7, -45 },
  { 9048, 37, 45, 37, 3, -45 },
  { 9257, 40, 45, 37, -1, -45 },
  { 9482, 34, 45, 37, 6, -45 },
  { 9674, 34, 45, 37, 2, -45 },
  { 9866, 26, 58, 37, 8, -51 },
  { 10055, 19, 58, 37, 10, -51 },
  { 10193, 26, 58, 37, 5, -51 },
  { 10382, 28, 24, 37, 5, -45 },
  { 10466, 31, 5, 37, 0, 2 },
  { 10486, 12, 9, 37, 16, -49 },
  { 10500, 32, 36, 37, 3, -35 },
  { 10644, 32, 46, 37, 2, -45 },
  { 10828, 30, 36, 37, 4, -35 },
  { 10963, 33, 46, 37, 3, -45 },
  { 11153, 30, 36, 37, 4, -35 },
  { 11288, 42, 56, 37, -3, -45 },
  { 11582, 31, 46, 37, 4, -35 },
  { 11761, 32, 45, 37, 2, -45 },
  { 11941, 31, 48, 37, 2, -48 },
  { 12127, 32, 59, 37, 1, -48 },
  { 12363, 34, 45, 37, 3, -45 },
  { 12555, 27, 45, 37, 6, -45 },
  { 12707, 35, 35, 37, 1, -35 },
  { 12861, 32, 35, 37, 2, -35 },
  { 13001, 30, 36, 37, 4, -35 },
  { 13136, 33, 46, 37, 1, -35 },
  { 13326, 32, 46, 37, 3, -35 },
  { 13510, 31, 35, 37, 4, -35 },
  { 13646, 31, 36, 37, 3, -35 },
  { 13786, 30, 43, 37, 5, -43 },
  { 13948, 32, 35, 37, 3, -34 },
  { 14088, 31, 34, 37, 6, -34 },
  { 14220, 34, 34, 37, 4, -34 },
  { 14365, 36, 34, 37, 0, -34 },
  { 14518, 31, 45, 37, 4, -34 },
  { 14693, 32, 34, 37, 2, -34 },
  { 14829, 33, 58, 37, 5, -51 },
  { 15069, 16, 58, 37, 11, -51 },
  { 15185, 32, 58, 37, 1, -51 },
  { 15417, 32, 14, 37, 3, -29 },
};

const GFXfont JetBrainsMono_MediumItalic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_MEDIUMITALIC62PT7B_H_
