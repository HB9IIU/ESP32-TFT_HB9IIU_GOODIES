#ifndef _JETBRAINSMONO_MEDIUMITALIC38PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3F, 0x1F, 0x00, 0x78, 0x7B, 0xC3,
  0xDE, 0x1F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7,
  0x07, 0xB8, 0x39, 0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x38, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x78,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3C, 0xE7,
  0x83, 0xC7, 0x3E, 0x1E, 0x31, 0xF0, 0xF1, 0x80, 0x07, 0x8C, 0x00, 0x3C,
  0x60, 0x01, 0xF7, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xCF, 0x80, 0x0E,
  0x7C, 0x00, 0x61, 0xE0, 0x03, 0x0F, 0x1E, 0x18, 0x78, 0xF1, 0xC7, 0x87,
  0xCE, 0x7C, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xF0, 0x01, 0xC1, 0xFE, 0x00, 0xE0, 0x7F, 0xC0, 0x70,
  0x38, 0x70, 0x3C, 0x0E, 0x1C, 0x1E, 0x07, 0x87, 0x07, 0x01, 0xC1, 0xC3,
  0x80, 0x70, 0x71, 0xC0, 0x1C, 0x1C, 0xE0, 0x07, 0x8E, 0x70, 0x01, 0xFF,
  0xBC, 0x00, 0x3F, 0xCE, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x7B, 0xF8, 0x00, 0x3D, 0xFF,
  0x00, 0x0E, 0x71, 0xE0, 0x07, 0x38, 0x38, 0x03, 0x8E, 0x0E, 0x01, 0xC3,
  0x87, 0x80, 0xE0, 0xE1, 0xC0, 0x78, 0x78, 0x70, 0x3C, 0x1E, 0x1C, 0x0E,
  0x03, 0xFE, 0x07, 0x00, 0xFF, 0x83, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x78, 0x3E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x81,
  0xEF, 0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xC3, 0xCF, 0x1E, 0x1F, 0xF0, 0xF0,
  0x7F, 0x0F, 0x01, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x07, 0xE0,
  0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xFC, 0xF0, 0x7F, 0x87, 0xC0, 0x7B,
  0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0x39, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x06,
  0x07, 0x03, 0x7C, 0x71, 0xFF, 0xE6, 0x7F, 0xFF, 0x6F, 0xF3, 0xFF, 0xF8,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xB8, 0x00, 0x73, 0xC0, 0x0F, 0x3C,
  0x01, 0xE1, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x18, 0x0C, 0x01, 0x00,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFB, 0xFF, 0xEF, 0xDF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F, 0x01,
  0xE1, 0xE0, 0x1F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0xF1, 0xE7, 0x8F, 0x1E, 0x79,
  0xF1, 0xC7, 0x8F, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF0,
  0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDE, 0x07, 0xC7, 0x81,
  0xE3, 0xE0, 0x60, 0xF0, 0x10, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xFC,
  0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF3, 0xE0, 0x3E, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x7E, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xF0, 0xFC, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x80, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBF, 0x01, 0xEF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xC3, 0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0x7C,
  0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0xBC,
  0x01, 0xE7, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFE, 0xFE, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1F, 0x07, 0xC0, 0xF8, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFB, 0xF0, 0x3E, 0x0F, 0x83, 0xC0,
  0x78, 0x78, 0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x80, 0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xE3,
  0xE0, 0x3E, 0x78, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x1F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xDF, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0xCF,
  0xE7, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x7C, 0x7F, 0x3F, 0x1F, 0x8F, 0x80, 0x01, 0xE0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x10,
  0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x78, 0x03, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x06, 0x3C,
  0x70, 0x3F, 0x79, 0xE0, 0xFF, 0xE3, 0xC3, 0xC3, 0xC7, 0x87, 0x07, 0x8E,
  0x1E, 0x0F, 0x1C, 0x3C, 0x1E, 0x38, 0x78, 0x3C, 0xF0, 0xE0, 0x79, 0xE1,
  0xC0, 0xE3, 0xC3, 0x81, 0xC7, 0x0F, 0x07, 0x8E, 0x1E, 0x0F, 0x1C, 0x3C,
  0x3E, 0x78, 0x3F, 0xFC, 0xF0, 0x7F, 0x71, 0xE0, 0x7C, 0xE3, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3B,
  0x80, 0x07, 0xB8, 0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x1C, 0x07, 0x81, 0xC0, 0xF0, 0x1C, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1E, 0x03, 0xE1, 0xE0,
  0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x03, 0xC3, 0xC0, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xC1, 0xF8, 0x78, 0x07, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x81, 0xE1, 0xF0, 0x1F, 0x1E,
  0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07,
  0xCF, 0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x7E, 0x3F, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x3F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x81,
  0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x7F, 0xE7, 0x87, 0xFC, 0x78, 0x7F, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF8,
  0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xF0,
  0x7F, 0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1E, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80,
  0xF8, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x77, 0x0F, 0xC1, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x3B, 0x87,
  0x70, 0xEE, 0x1C, 0xC7, 0x78, 0x73, 0x9D, 0xE1, 0xCE, 0xE7, 0x0F, 0x3B,
  0x9C, 0x3C, 0xFC, 0xF0, 0xF3, 0xF3, 0xC3, 0xCF, 0x8F, 0x0F, 0x1E, 0x3C,
  0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x38,
  0x3E, 0x03, 0xC3, 0xF0, 0x1E, 0x1F, 0xC0, 0xF0, 0xFE, 0x07, 0x87, 0x70,
  0x3C, 0x3B, 0x81, 0xC1, 0xDC, 0x1E, 0x1E, 0xF0, 0xF0, 0xF7, 0x87, 0x87,
  0x9C, 0x3C, 0x3C, 0xE1, 0xE1, 0xE7, 0x0F, 0x0F, 0x3C, 0x70, 0x71, 0xE7,
  0x87, 0x87, 0x3C, 0x3C, 0x39, 0xE1, 0xE1, 0xCF, 0x0F, 0x0E, 0x78, 0x78,
  0x7B, 0x83, 0x83, 0xDC, 0x3C, 0x0E, 0xE1, 0xE0, 0x7F, 0x0F, 0x03, 0xF8,
  0x78, 0x1F, 0xC3, 0xC0, 0xFC, 0x1C, 0x03, 0xE1, 0xE0, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x87, 0x80, 0xF0, 0x7E,
  0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x1F, 0x0F, 0x00,
  0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1,
  0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80,
  0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF0, 0x7E,
  0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1E, 0x03, 0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x07, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x1E,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x78, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x78, 0x0F, 0x07, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x0F, 0x0F, 0x80, 0xF8, 0x7F, 0x1F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x87, 0x80,
  0xF0, 0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x01, 0xDC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x38, 0x3C, 0x1E,
  0xF0, 0x78, 0x39, 0xE0, 0xF0, 0x73, 0xC3, 0xE1, 0xE7, 0x86, 0xC3, 0xCF,
  0x0D, 0x87, 0x1E, 0x3F, 0x0E, 0x3C, 0x7E, 0x3C, 0x78, 0xDC, 0x78, 0xF1,
  0xB8, 0xE1, 0xC7, 0x71, 0xC3, 0x8C, 0xE7, 0x87, 0x19, 0xCE, 0x0E, 0x33,
  0x1C, 0x1C, 0xE6, 0x38, 0x39, 0x8C, 0xF0, 0x73, 0x19, 0xC0, 0xEE, 0x33,
  0x81, 0xDC, 0x6F, 0x03, 0xB0, 0xDE, 0x0F, 0x61, 0xB8, 0x1F, 0xC3, 0x70,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x3E,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0xF0,
  0x01, 0xE1, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF, 0x00,
  0x03, 0xEF, 0x00, 0x03, 0xCF, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x87, 0x80,
  0x1F, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0,
  0x78, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x78,
  0x01, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x3C, 0x0F, 0x83,
  0xC0, 0xF0, 0x3E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80,
  0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x1E,
  0xF0, 0x1E, 0x78, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x87, 0x81, 0xC7,
  0x80, 0xE3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xF0, 0xF1, 0xE1, 0xE1, 0xE0, 0x03,
  0xF9, 0xE0, 0xFF, 0xBC, 0x3F, 0xF7, 0x8F, 0xC6, 0xF3, 0xE0, 0x7E, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x8F, 0x87, 0xF1, 0xFF, 0xFC, 0x1F, 0xF7, 0x81, 0xFC,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF3, 0xF8, 0x1E, 0xFF, 0x87, 0xBF,
  0xF8, 0xFE, 0x3F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xFE, 0x3F,
  0x1F, 0xFF, 0xC3, 0xDF, 0xF0, 0x79, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xE7, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0xCF, 0x00,
  0xFB, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x0F,
  0x8F, 0xC7, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x3F, 0x9E, 0x07, 0xFD, 0xE0, 0xFF, 0xDE, 0x1F,
  0x8D, 0xE3, 0xE0, 0x7E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x3F,
  0x87, 0xFF, 0xF0, 0x3F, 0xEF, 0x01, 0xFC, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x0F,
  0x8F, 0x83, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF9, 0xE0, 0xFF, 0xBC, 0x3F, 0xF7, 0x8F,
  0xC7, 0xF3, 0xE0, 0x7E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x03, 0xE3, 0xE0, 0xFC, 0x7F, 0xF7, 0x87, 0xFF, 0xF0, 0x7F,
  0xBC, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF3, 0xF8, 0x1E, 0xFF, 0x87, 0xFF, 0xF8, 0xFE,
  0x3F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F,
  0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x03, 0xC1,
  0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xE1, 0xE0, 0x0F, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x1C, 0xF1, 0xE0, 0xEF, 0xDF, 0x8F, 0xFF,
  0xFC, 0x78, 0x70, 0xF3, 0xC3, 0x87, 0x9E, 0x1C, 0x38, 0xF1, 0xE3, 0xC7,
  0x0E, 0x1E, 0x38, 0x70, 0xF3, 0xC3, 0x87, 0x9E, 0x1C, 0x3C, 0xF0, 0xE1,
  0xC7, 0x87, 0x0E, 0x38, 0x70, 0xF1, 0xC3, 0x87, 0x9E, 0x1C, 0x3C, 0xF0,
  0xE1, 0xE7, 0x87, 0x0E, 0x3C, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x3C,
  0x00, 0x1E, 0x7F, 0x03, 0xDF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC7, 0xE3, 0xE0,
  0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xC7,
  0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F,
  0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0xC7, 0xE1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x9F, 0xC0, 0x3D, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xC7, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03,
  0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xC1, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0x7B, 0xFE, 0x03, 0xCF, 0xE0,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xE0, 0xFF, 0xBC,
  0x3F, 0xF7, 0x8F, 0xC6, 0xF3, 0xE0, 0x7E, 0x78, 0x07, 0x8F, 0x00, 0xF3,
  0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F,
  0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7, 0x81, 0xFC, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1E, 0x3F, 0x81, 0xEF, 0xFC, 0x1E, 0xFF, 0xE1, 0xFC, 0x7E,
  0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0x83, 0xE3, 0xE0, 0x3E, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0xF0, 0x07, 0x9F,
  0x03, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0xC7, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE1,
  0xF0, 0xFE, 0x1F, 0x0E, 0xE1, 0xF0, 0xEE, 0x1F, 0x1E, 0xE3, 0xF1, 0xCE,
  0x37, 0x1C, 0xE3, 0x73, 0xCE, 0x77, 0x38, 0xE6, 0x73, 0x8E, 0x67, 0x38,
  0xEE, 0x77, 0x0E, 0xC7, 0x70, 0xEC, 0x77, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E,
  0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xE3,
  0xE0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1F,
  0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xE0, 0xFC, 0x7F,
  0xF7, 0x87, 0xFD, 0xE0, 0x7F, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0x00, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xE7, 0xFE, 0x0E, 0x78, 0xF1, 0xEF,
  0x0F, 0xFE, 0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0x00, 0x0E, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 13, 12, 23, 7, -28 },
  { 53, 22, 28, 23, 1, -28 },
  { 130, 21, 38, 23, 1, -33 },
  { 230, 26, 28, 23, -1, -28 },
  { 321, 21, 28, 23, 1, -28 },
  { 395, 5, 12, 23, 11, -28 },
  { 403, 16, 37, 23, 6, -32 },
  { 477, 16, 37, 23, 2, -32 },
  { 551, 20, 20, 23, 2, -23 },
  { 601, 19, 18, 23, 2, -22 },
  { 644, 11, 12, 23, 3, -6 },
  { 661, 13, 3, 23, 5, -14 },
  { 666, 7, 6, 23, 7, -6 },
  { 672, 24, 36, 23, 0, -32 },
  { 780, 20, 28, 23, 2, -28 },
  { 850, 18, 28, 23, 2, -28 },
  { 913, 20, 28, 23, 2, -28 },
  { 983, 20, 28, 23, 2, -28 },
  { 1053, 19, 28, 23, 2, -28 },
  { 1120, 20, 28, 23, 2, -28 },
  { 1190, 19, 28, 23, 2, -28 },
  { 1257, 19, 28, 23, 4, -28 },
  { 1324, 20, 28, 23, 2, -28 },
  { 1394, 19, 28, 23, 3, -28 },
  { 1461, 9, 21, 23, 7, -21 },
  { 1485, 12, 27, 23, 4, -21 },
  { 1526, 19, 21, 23, 3, -23 },
  { 1576, 19, 13, 23, 2, -19 },
  { 1607, 18, 21, 23, 2, -23 },
  { 1655, 16, 28, 23, 5, -28 },
  { 1711, 23, 35, 23, 0, -28 },
  { 1812, 20, 28, 23, 0, -28 },
  { 1882, 20, 28, 23, 2, -28 },
  { 1952, 20, 28, 23, 2, -28 },
  { 2022, 21, 28, 23, 1, -28 },
  { 2096, 21, 28, 23, 2, -28 },
  { 2170, 21, 28, 23, 2, -28 },
  { 2244, 20, 28, 23, 2, -28 },
  { 2314, 20, 28, 23, 2, -28 },
  { 2384, 20, 28, 23, 2, -28 },
  { 2454, 22, 28, 23, 0, -28 },
  { 2531, 22, 28, 23, 2, -28 },
  { 2608, 17, 28, 23, 2, -28 },
  { 2668, 22, 28, 23, 1, -28 },
  { 2745, 21, 28, 23, 1, -28 },
  { 2819, 20, 28, 23, 2, -28 },
  { 2889, 21, 28, 23, 2, -28 },
  { 2963, 20, 35, 23, 2, -28 },
  { 3051, 20, 28, 23, 2, -28 },
  { 3121, 21, 28, 23, 1, -28 },
  { 3195, 20, 28, 23, 4, -28 },
  { 3265, 20, 28, 23, 2, -28 },
  { 3335, 20, 28, 23, 4, -28 },
  { 3405, 23, 28, 23, 2, -28 },
  { 3486, 24, 28, 23, 0, -28 },
  { 3570, 20, 28, 23, 4, -28 },
  { 3640, 21, 28, 23, 1, -28 },
  { 3714, 16, 36, 23, 5, -32 },
  { 3786, 12, 36, 23, 6, -32 },
  { 3840, 16, 36, 23, 3, -32 },
  { 3912, 17, 15, 23, 3, -28 },
  { 3944, 19, 4, 23, 0, 1 },
  { 3954, 7, 5, 23, 10, -30 },
  { 3959, 19, 21, 23, 2, -21 },
  { 4009, 19, 28, 23, 2, -28 },
  { 4076, 19, 21, 23, 2, -21 },
  { 4126, 20, 28, 23, 2, -28 },
  { 4196, 19, 21, 23, 2, -21 },
  { 4246, 26, 35, 23, -2, -28 },
  { 4360, 19, 28, 23, 2, -21 },
  { 4427, 19, 28, 23, 2, -28 },
  { 4494, 19, 30, 23, 1, -30 },
  { 4566, 20, 37, 23, 0, -30 },
  { 4659, 21, 28, 23, 2, -28 },
  { 4733, 17, 28, 23, 3, -28 },
  { 4793, 21, 21, 23, 1, -21 },
  { 4849, 19, 21, 23, 2, -21 },
  { 4899, 19, 21, 23, 2, -21 },
  { 4949, 21, 28, 23, 0, -21 },
  { 5023, 19, 28, 23, 2, -21 },
  { 5090, 20, 21, 23, 2, -21 },
  { 5143, 19, 21, 23, 2, -21 },
  { 5193, 19, 27, 23, 3, -27 },
  { 5258, 19, 21, 23, 2, -21 },
  { 5308, 19, 21, 23, 4, -21 },
  { 5358, 20, 21, 23, 3, -21 },
  { 5411, 22, 21, 23, 0, -21 },
  { 5469, 19, 28, 23, 2, -21 },
  { 5536, 19, 21, 23, 2, -21 },
  { 5586, 20, 36, 23, 3, -32 },
  { 5676, 10, 36, 23, 7, -32 },
  { 5721, 19, 36, 23, 1, -32 },
  { 5807, 20, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_MEDIUMITALIC38PT7B_H_
