#ifndef _JETBRAINSMONO_MEDIUMITALIC39PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0,
  0x7C, 0x7D, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xE1, 0xEF, 0x0F,
  0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x03,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x83, 0xC0, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0xCF, 0x87, 0xC6, 0x3C, 0x3C, 0x71,
  0xE1, 0xE3, 0x8F, 0x0F, 0x1C, 0x00, 0x78, 0xC0, 0x03, 0xE6, 0x00, 0x1F,
  0xB0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xBF, 0x00, 0x0C, 0xF8, 0x00, 0xE3, 0xC0, 0x07,
  0x1E, 0x3C, 0x30, 0xF1, 0xE1, 0x87, 0x8F, 0x0C, 0x7C, 0x7C, 0x67, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x10, 0x1F, 0xC0, 0x0E, 0x03, 0xFE, 0x01, 0xC0, 0x78,
  0xF0, 0x3C, 0x07, 0x0F, 0x07, 0x80, 0x70, 0xF0, 0xF0, 0x0F, 0x0F, 0x0E,
  0x00, 0xE0, 0xE1, 0xC0, 0x0E, 0x0E, 0x38, 0x00, 0xE0, 0xE7, 0x00, 0x0F,
  0xBC, 0xF0, 0x00, 0x7F, 0xDE, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x7C, 0x00,
  0x03, 0xDF, 0xE0, 0x00, 0x7B, 0xFF, 0x00, 0x07, 0x38, 0x70, 0x00, 0xE7,
  0x87, 0x00, 0x1C, 0x70, 0x70, 0x03, 0x87, 0x07, 0x00, 0x70, 0x70, 0x70,
  0x0F, 0x07, 0x07, 0x01, 0xE0, 0x70, 0xF0, 0x1C, 0x07, 0xFE, 0x03, 0x80,
  0x3F, 0xC0, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xBC, 0x1F, 0x7C, 0xF8, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0xDE, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC3, 0xC0, 0x7E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0,
  0xF8, 0x3F, 0x83, 0xF1, 0xFF, 0x07, 0xFF, 0xBC, 0x1F, 0xFC, 0xF8, 0x3F,
  0xC1, 0xF0, 0x7D, 0xE7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF3, 0xCE, 0x00, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xE0, 0x00, 0x60, 0x02, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x20, 0x3C, 0x09, 0xE1,
  0xC1, 0xCF, 0xCE, 0x3E, 0xFF, 0x77, 0xFB, 0xFF, 0xFF, 0x87, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE3,
  0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0x30, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x7C, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0x10, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x71,
  0xE3, 0xCF, 0x1E, 0x78, 0xF9, 0xE7, 0x8F, 0x9E, 0x78, 0xF1, 0xE7, 0x80,
  0x1E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xE3, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0x9E, 0x07, 0xC7, 0x81, 0xC1, 0xE0, 0x60, 0xF8, 0x20,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0xF0,
  0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF8, 0xFE, 0x3F, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x3E, 0x3E, 0x07, 0x8F, 0x80, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE3, 0xC0, 0x1E, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0,
  0x7C, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F,
  0x80, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x20, 0x0F, 0xBF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x81, 0xF3,
  0xE0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0x7E, 0x3F, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x07,
  0xCF, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1F, 0x03, 0xE0, 0xF8, 0x7C, 0x0F,
  0xDF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0x9F, 0x83,
  0xE0, 0x78, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7,
  0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xE7, 0xC0, 0x7C, 0x7E, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x07, 0xE1, 0xF8, 0xFE,
  0x1F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x1F, 0x00, 0x00,
  0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x3F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7E, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0E, 0x1C, 0x07, 0xCE, 0x1C, 0x0F, 0xEE, 0x3C, 0x1F, 0xEE, 0x3C, 0x3C,
  0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x38, 0x1C, 0x38, 0x78, 0x1C, 0x38, 0x78,
  0x1C, 0x78, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x70, 0x3C, 0x78, 0x70,
  0x3C, 0x70, 0x70, 0x78, 0x70, 0x78, 0x78, 0xF0, 0x7F, 0xB8, 0xF0, 0x3F,
  0xB8, 0xF0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x7B,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE1, 0xC0, 0x1E,
  0x1C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3E, 0x07, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0x80, 0xF8, 0x7C,
  0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x01, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x7C, 0x0F,
  0x83, 0xF9, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF0, 0xFE, 0x1E, 0x01,
  0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x01, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xFF, 0x87, 0x8F, 0xFC, 0x7C,
  0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x7C, 0x0F, 0x83, 0xF9,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x0F, 0x80, 0x78, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80,
  0x3C, 0x1F, 0x01, 0xF0, 0x7F, 0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x87,
  0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0x81,
  0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x0F, 0x00, 0x7C,
  0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x1F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1D, 0xC3, 0xF8,
  0x3F, 0x87, 0xB8, 0xEF, 0x0F, 0x71, 0xDC, 0x1C, 0xE7, 0x38, 0x39, 0xCE,
  0xF0, 0x73, 0xB9, 0xE1, 0xE7, 0x73, 0xC3, 0xCE, 0xC7, 0x87, 0x8F, 0x8E,
  0x0F, 0x1F, 0x3C, 0x1E, 0x3C, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x1F, 0x80, 0xF0, 0xFE,
  0x03, 0xC3, 0xF8, 0x0E, 0x0F, 0xE0, 0x78, 0x3F, 0x81, 0xE0, 0xFF, 0x07,
  0x83, 0xBC, 0x1E, 0x0E, 0x70, 0x78, 0x79, 0xC1, 0xC1, 0xE7, 0x0F, 0x07,
  0x9E, 0x3C, 0x1E, 0x78, 0xF0, 0x79, 0xE3, 0xC1, 0xE3, 0x8F, 0x0F, 0x0E,
  0x3C, 0x3C, 0x3D, 0xE0, 0xF0, 0xF7, 0x83, 0xC3, 0xDE, 0x0F, 0x07, 0x78,
  0x3C, 0x1D, 0xE1, 0xE0, 0x77, 0x87, 0x81, 0xFC, 0x1E, 0x07, 0xF0, 0x78,
  0x0F, 0xC1, 0xE0, 0x3F, 0x07, 0x80, 0xFC, 0x3C, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xF1, 0xF0,
  0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F,
  0x87, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xC0, 0xFE, 0x1E, 0x00,
  0xF8, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x07, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xE3, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3E, 0x07, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF1, 0xF0, 0x07,
  0x8F, 0x80, 0x7C, 0x78, 0x07, 0xC3, 0xC1, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xFE, 0x7F, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0,
  0x7E, 0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF8,
  0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x38, 0x3E, 0x1E, 0x70, 0x78, 0x3D, 0xE0, 0xF0, 0x7B, 0xC3, 0xE0,
  0xE7, 0x87, 0xC3, 0xCF, 0x0D, 0x87, 0x9E, 0x1B, 0x0F, 0x3C, 0x76, 0x1C,
  0x78, 0xEC, 0x78, 0xF1, 0x98, 0xF1, 0xE7, 0x31, 0xC3, 0xCE, 0x63, 0x87,
  0x19, 0xCF, 0x0E, 0x33, 0x9E, 0x1C, 0xE7, 0x38, 0x39, 0xCE, 0x70, 0x73,
  0x1D, 0xE0, 0xEE, 0x3B, 0xC1, 0xDC, 0x77, 0x03, 0xB0, 0xEE, 0x07, 0x61,
  0xFC, 0x0F, 0xC3, 0x70, 0x3F, 0x86, 0xE0, 0x7E, 0x0D, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7C, 0x01, 0xE0,
  0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF3,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xC7, 0x80, 0x07, 0xC7,
  0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x00,
  0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0xC0, 0x3C, 0x1E,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0,
  0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x04, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xCE, 0x00, 0xF3,
  0x80, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x07, 0x07, 0x81, 0xC1, 0xE0, 0x78,
  0xF0, 0x1E, 0x3C, 0x03, 0x9E, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x1F, 0x00, 0xF0, 0x00, 0x7F, 0xDF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0x07, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x7E, 0x3F,
  0x87, 0xFF, 0x78, 0x3F, 0xE7, 0x81, 0xFC, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0xF3, 0xFC, 0x1E, 0xFF, 0xC7, 0xFF, 0xF8, 0xF4, 0x1F, 0x9F, 0x01,
  0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x7C, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F,
  0xBE, 0x01, 0xE7, 0xE0, 0x7C, 0xFE, 0x3F, 0x1E, 0xFF, 0xE3, 0xDF, 0xF8,
  0x79, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x81, 0xF1, 0xFC, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x03, 0xC3, 0xC0, 0xFF, 0xBE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xC1,
  0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x8F,
  0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x7E,
  0x3F, 0x83, 0xFF, 0xBC, 0x0F, 0xF9, 0xE0, 0x3F, 0x9E, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x3E, 0x7C, 0x07,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xDF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x07, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03,
  0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x7C, 0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F,
  0xF7, 0x81, 0xFE, 0x78, 0x07, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x87, 0x80, 0xF3, 0xFC, 0x1E, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07,
  0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xC0, 0x00, 0x02,
  0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x02, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x1F, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03,
  0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x3C,
  0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x7C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x70, 0xE0, 0xEF, 0xDF, 0x87,
  0x7E, 0xFE, 0x7C, 0xFC, 0xF3, 0xC3, 0xC7, 0x9E, 0x1C, 0x3C, 0xF0, 0xE1,
  0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x79, 0xC3, 0xC3, 0x9E, 0x1C, 0x3C, 0xF0,
  0xE1, 0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x79, 0xE1, 0xC3, 0xCE, 0x1E, 0x1C,
  0xF0, 0xE1, 0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x79, 0xE1, 0xC3, 0xCF, 0x0E,
  0x1E, 0x70, 0xF0, 0xE0, 0x00, 0x1E, 0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x1F,
  0xFF, 0xE3, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C,
  0x03, 0xE7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x01, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0xFF, 0x01, 0xEF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF8,
  0x1F, 0x0F, 0xE3, 0xF0, 0x7B, 0xFF, 0x83, 0xDF, 0xF8, 0x1E, 0x7F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xDF,
  0x0F, 0xFD, 0xE1, 0xFF, 0xFE, 0x1F, 0x07, 0xE3, 0xE0, 0x3E, 0x3C, 0x03,
  0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8,
  0x07, 0x87, 0x80, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0x78, 0x3F, 0xEF, 0x81,
  0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xF7,
  0xFC, 0x1E, 0xFF, 0xE1, 0xEF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x1E,
  0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0xF0, 0x07, 0xDF, 0x00, 0xF3, 0xF0, 0x7E,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xE3, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0,
  0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x03, 0xB8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xE0, 0xF0, 0x7F, 0x07,
  0x83, 0xB8, 0x3C, 0x1D, 0xC3, 0xE1, 0xEE, 0x1B, 0x0E, 0x70, 0xD8, 0x73,
  0x8E, 0xC7, 0x9C, 0x66, 0x38, 0xE3, 0x31, 0xC7, 0x39, 0x8E, 0x39, 0x8C,
  0xF1, 0xCC, 0x67, 0x0E, 0xE3, 0x38, 0x77, 0x1B, 0xC3, 0xB0, 0xDC, 0x1F,
  0x86, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x3E, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0,
  0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xE1, 0xF8, 0x7F, 0xF7, 0x83,
  0xFF, 0x78, 0x1F, 0xC7, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF1, 0xFE, 0x0F,
  0x3F, 0xE0, 0xF7, 0xDF, 0x0F, 0x70, 0xF8, 0xFF, 0x07, 0xFE, 0xF0, 0x7F,
  0xCF, 0x03, 0xF8, 0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 14, 11, 23, 7, -28 },
  { 56, 23, 28, 23, 1, -28 },
  { 137, 21, 39, 23, 2, -34 },
  { 240, 28, 29, 23, -2, -29 },
  { 342, 22, 29, 23, 1, -29 },
  { 422, 6, 11, 23, 11, -28 },
  { 431, 16, 38, 23, 6, -33 },
  { 507, 16, 38, 23, 2, -33 },
  { 583, 21, 20, 23, 2, -24 },
  { 636, 20, 18, 23, 2, -22 },
  { 681, 11, 12, 23, 3, -6 },
  { 698, 14, 4, 23, 5, -15 },
  { 705, 7, 7, 23, 7, -7 },
  { 712, 24, 36, 23, 0, -32 },
  { 820, 20, 29, 23, 2, -29 },
  { 893, 18, 28, 23, 2, -28 },
  { 956, 20, 29, 23, 2, -29 },
  { 1029, 20, 28, 23, 2, -28 },
  { 1099, 19, 28, 23, 2, -28 },
  { 1166, 20, 28, 23, 2, -28 },
  { 1236, 19, 28, 23, 2, -28 },
  { 1303, 20, 28, 23, 4, -28 },
  { 1373, 20, 29, 23, 2, -29 },
  { 1446, 20, 29, 23, 3, -29 },
  { 1519, 10, 22, 23, 7, -22 },
  { 1547, 13, 28, 23, 4, -22 },
  { 1593, 19, 21, 23, 3, -23 },
  { 1643, 19, 14, 23, 3, -20 },
  { 1677, 19, 21, 23, 2, -23 },
  { 1727, 16, 28, 23, 5, -28 },
  { 1783, 24, 36, 23, 0, -29 },
  { 1891, 20, 28, 23, 0, -28 },
  { 1961, 21, 28, 23, 2, -28 },
  { 2035, 21, 29, 23, 2, -29 },
  { 2112, 20, 28, 23, 2, -28 },
  { 2182, 21, 28, 23, 2, -28 },
  { 2256, 21, 29, 23, 2, -29 },
  { 2333, 21, 29, 23, 2, -29 },
  { 2410, 21, 28, 23, 2, -28 },
  { 2484, 20, 28, 23, 2, -28 },
  { 2554, 22, 28, 23, 0, -28 },
  { 2631, 22, 28, 23, 2, -28 },
  { 2708, 17, 28, 23, 3, -28 },
  { 2768, 23, 28, 23, 1, -28 },
  { 2849, 22, 28, 23, 1, -28 },
  { 2926, 20, 29, 23, 2, -29 },
  { 2999, 22, 28, 23, 2, -28 },
  { 3076, 20, 36, 23, 2, -29 },
  { 3166, 21, 28, 23, 2, -28 },
  { 3240, 22, 29, 23, 1, -29 },
  { 3320, 20, 29, 23, 4, -29 },
  { 3393, 21, 28, 23, 2, -28 },
  { 3467, 21, 28, 23, 4, -28 },
  { 3541, 23, 28, 23, 2, -28 },
  { 3622, 24, 28, 23, 0, -28 },
  { 3706, 21, 28, 23, 4, -28 },
  { 3780, 22, 28, 23, 1, -28 },
  { 3857, 16, 36, 23, 5, -32 },
  { 3929, 12, 36, 23, 6, -32 },
  { 3983, 16, 36, 23, 3, -32 },
  { 4055, 18, 15, 23, 3, -28 },
  { 4089, 19, 4, 23, 0, 1 },
  { 4099, 8, 6, 23, 10, -31 },
  { 4105, 20, 22, 23, 2, -22 },
  { 4160, 19, 28, 23, 2, -28 },
  { 4227, 19, 22, 23, 2, -22 },
  { 4280, 21, 28, 23, 2, -28 },
  { 4354, 19, 22, 23, 2, -22 },
  { 4407, 27, 35, 23, -2, -28 },
  { 4526, 20, 29, 23, 2, -22 },
  { 4599, 19, 28, 23, 2, -28 },
  { 4666, 19, 31, 23, 1, -31 },
  { 4740, 21, 38, 23, 0, -31 },
  { 4840, 21, 28, 23, 2, -28 },
  { 4914, 17, 28, 23, 4, -28 },
  { 4974, 21, 22, 23, 1, -22 },
  { 5032, 19, 22, 23, 2, -22 },
  { 5085, 19, 22, 23, 2, -22 },
  { 5138, 21, 29, 23, 0, -22 },
  { 5215, 20, 29, 23, 2, -22 },
  { 5288, 20, 22, 23, 2, -22 },
  { 5343, 19, 22, 23, 2, -22 },
  { 5396, 19, 27, 23, 3, -27 },
  { 5461, 20, 21, 23, 2, -21 },
  { 5514, 19, 21, 23, 4, -21 },
  { 5564, 21, 21, 23, 3, -21 },
  { 5620, 23, 21, 23, 0, -21 },
  { 5681, 20, 28, 23, 2, -21 },
  { 5751, 19, 21, 23, 2, -21 },
  { 5801, 21, 36, 23, 3, -32 },
  { 5896, 10, 36, 23, 7, -32 },
  { 5941, 20, 36, 23, 1, -32 },
  { 6031, 20, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_MEDIUMITALIC39PT7B_H_
