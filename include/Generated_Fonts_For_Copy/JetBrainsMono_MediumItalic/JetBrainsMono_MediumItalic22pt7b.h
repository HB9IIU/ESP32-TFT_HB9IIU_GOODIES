#ifndef _JETBRAINSMONO_MEDIUMITALIC22PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC2, 0x00, 0x01, 0x8F,
  0x38, 0x67, 0xE6, 0xE6, 0xC6, 0xC6, 0xC6, 0xCC, 0x03, 0x18, 0x10, 0xC1,
  0x8C, 0x0C, 0x63, 0xFF, 0x9F, 0xFC, 0x31, 0x81, 0x08, 0x18, 0xC0, 0xC6,
  0x1F, 0xFD, 0xFF, 0xE3, 0x18, 0x10, 0x81, 0x8C, 0x0C, 0x60, 0x01, 0x00,
  0x10, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0xB6, 0x32, 0x73, 0x20, 0x32, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x05, 0xC0, 0x4E, 0x24, 0xEC, 0x4C, 0xED, 0xC7,
  0xF8, 0x3F, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0x07, 0x1B, 0x8C, 0x31,
  0x88, 0x31, 0x98, 0x31, 0x30, 0x33, 0x60, 0x1E, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x78, 0x06, 0xDC, 0x0D, 0x8C, 0x19, 0x88, 0x31, 0x88, 0x61,
  0xF8, 0xC0, 0xF0, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x30, 0xC1, 0x80, 0x0E,
  0x00, 0x30, 0x07, 0xC0, 0x36, 0x3B, 0x3B, 0x98, 0xF8, 0xC3, 0x86, 0x1C,
  0x31, 0xE1, 0xFF, 0x87, 0xCE, 0x6F, 0xFF, 0xB0, 0x00, 0x40, 0x60, 0x78,
  0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xF8, 0x1C, 0x01, 0x00,
  0x10, 0x0E, 0x07, 0x80, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x1F, 0x0E, 0x04,
  0x00, 0x03, 0x00, 0x70, 0x06, 0x07, 0x67, 0xFD, 0xF1, 0xF8, 0x0E, 0x01,
  0xB0, 0x33, 0x87, 0x18, 0x21, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x07,
  0xFF, 0xFF, 0xC3, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x3C, 0xE3, 0x1C, 0x63,
  0x8C, 0x00, 0xFF, 0xFE, 0x6F, 0xFE, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x07, 0x70,
  0x67, 0x06, 0x60, 0x66, 0xE6, 0x66, 0x66, 0x0E, 0x60, 0xCE, 0x0C, 0xE0,
  0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x07, 0x83, 0xE3, 0xF8, 0xCE, 0x23, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x8F, 0xFF,
  0xFF, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x06, 0x70, 0x60, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xFF, 0xCF,
  0xFC, 0x1F, 0xE7, 0xFC, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0xE0, 0x7E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x6E, 0x0D, 0xC3, 0x9F, 0xE1, 0xF0, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC7, 0x70, 0xCC,
  0x1B, 0x83, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x60, 0x0C, 0x1F, 0xF3, 0xFE,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x30, 0x3F, 0xC7, 0x9C, 0x70, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0xE0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0F, 0xE3, 0xFE, 0x70, 0xEC, 0x1F, 0x83,
  0xE0, 0x7E, 0x0D, 0xC3, 0x9F, 0xE1, 0xF8, 0x7F, 0xEF, 0xFD, 0x83, 0xB0,
  0x68, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x0F, 0xC3, 0xFC, 0xE1, 0x98, 0x33, 0x06,
  0x61, 0xCF, 0x70, 0x78, 0x1F, 0x8E, 0x39, 0x83, 0x70, 0x6E, 0x0D, 0xC3,
  0x9F, 0xE1, 0xF8, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF8,
  0x37, 0x0E, 0x7F, 0x87, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xC0, 0x0E, 0x3C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0x00,
  0x60, 0x38, 0x1E, 0x1F, 0x0F, 0x81, 0xC0, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0E, 0x00, 0x40, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xBF, 0xF0, 0x20, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x78,
  0x3C, 0x3E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x7E, 0x3F, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x7C, 0x3C, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x03, 0xC1,
  0xC0, 0x07, 0xF0, 0x7B, 0xC6, 0x06, 0x60, 0x33, 0x01, 0x98, 0xED, 0x8F,
  0xEC, 0x63, 0x66, 0x1B, 0x31, 0xD9, 0x8C, 0xCC, 0x6C, 0x63, 0x63, 0xFB,
  0x0E, 0xD8, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0x60, 0x6C, 0x1D, 0x83, 0x30, 0xE6, 0x18, 0xE3, 0x1C,
  0xFF, 0x9F, 0xF7, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0x3F, 0xC3, 0xFE, 0x30,
  0xE3, 0x06, 0x30, 0x63, 0x06, 0x71, 0xC7, 0xF0, 0x7F, 0xC6, 0x0E, 0x60,
  0xE6, 0x0E, 0xE0, 0xCE, 0x1C, 0xFF, 0x8F, 0xF0, 0x0F, 0xC1, 0xFE, 0x38,
  0x63, 0x07, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x3F, 0x83, 0xFE, 0x30,
  0xE3, 0x06, 0x30, 0x63, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0x60,
  0xC6, 0x0C, 0xE1, 0xCE, 0x38, 0xFF, 0x8F, 0xE0, 0x1F, 0xF3, 0xFF, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0xFC, 0x7F, 0xC6, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0xFE, 0x7F, 0xC6, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x0F, 0xC1, 0xFE, 0x38,
  0x63, 0x07, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x67, 0xE6, 0x7E, 0x60,
  0xC6, 0x0C, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x38, 0x73, 0x87, 0x30,
  0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0xE7, 0xFE, 0x7F, 0xE6, 0x0C, 0x60,
  0xC6, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCC, 0x18, 0x1F, 0xF3, 0xFE, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0xFF, 0x8F, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0xC1, 0xC6, 0x0E, 0x30, 0xE1, 0xFE, 0x07, 0xE0, 0x38, 0x39,
  0xC3, 0x8C, 0x18, 0x61, 0xC3, 0x1C, 0x18, 0xC1, 0xCE, 0x0F, 0xE0, 0x7F,
  0x03, 0x18, 0x18, 0xE0, 0xC7, 0x0E, 0x18, 0x70, 0xE3, 0x07, 0x18, 0x18,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x07, 0xFF, 0xFF, 0x1C, 0x38, 0xE1, 0xC5,
  0x1E, 0x68, 0xB3, 0x6D, 0x9B, 0x78, 0xDE, 0xC6, 0xF6, 0x33, 0x31, 0x81,
  0x9C, 0x1C, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0x38, 0x33,
  0xC3, 0x3C, 0x73, 0xC6, 0x3C, 0x67, 0xC6, 0x76, 0x66, 0x66, 0x66, 0xE6,
  0x6C, 0x66, 0xC6, 0x3C, 0xE3, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0x0F, 0xC1,
  0xFE, 0x38, 0x63, 0x06, 0x30, 0x67, 0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6,
  0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x3F, 0xC3,
  0xFE, 0x30, 0x73, 0x03, 0x30, 0x33, 0x07, 0x70, 0x77, 0xFE, 0x7F, 0xC7,
  0xF0, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC1,
  0xFE, 0x38, 0x63, 0x07, 0x70, 0x67, 0x06, 0x70, 0x66, 0x06, 0x60, 0xE6,
  0x0E, 0x60, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x3F, 0xC3, 0xFE, 0x30, 0x73, 0x07, 0x30, 0x73,
  0x07, 0x70, 0xE7, 0xFC, 0x7F, 0x86, 0x30, 0x63, 0x06, 0x38, 0xE1, 0x8E,
  0x18, 0xC1, 0xCC, 0x1C, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x07, 0x30, 0x03,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xE2, 0x0E, 0xC0, 0xCE,
  0x1C, 0x7F, 0x83, 0xF0, 0x7F, 0xFF, 0xFE, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x33, 0x07, 0x30, 0x73, 0x06, 0x30, 0x67,
  0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE0, 0xC6,
  0x1C, 0x7F, 0x83, 0xF0, 0xC0, 0xF8, 0x1B, 0x07, 0x60, 0xCC, 0x19, 0x87,
  0x30, 0xC7, 0x38, 0xE6, 0x1C, 0xC1, 0xB0, 0x36, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0x80, 0x63, 0x1B, 0x18, 0xD9, 0xC6, 0xCA, 0x66, 0x53, 0x32, 0x99,
  0xB4, 0xCD, 0x2C, 0x69, 0x62, 0xCB, 0x16, 0xD1, 0xA7, 0x8D, 0x3C, 0x79,
  0xE3, 0x8E, 0x1C, 0x70, 0x18, 0x1C, 0x70, 0xE0, 0xC7, 0x03, 0x18, 0x0E,
  0xE0, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x07,
  0x70, 0x38, 0xC0, 0xC3, 0x87, 0x0E, 0x38, 0x18, 0xE0, 0x76, 0x06, 0x60,
  0xE7, 0x1C, 0x31, 0x83, 0x38, 0x3B, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3F, 0xF3, 0xFE, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0x8F, 0xC6, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x3F, 0x1F, 0x80, 0xE0, 0xC1, 0x83, 0x87, 0x06,
  0x0C, 0x18, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x18,
  0x30, 0x1F, 0x8F, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x3F, 0x1F, 0x80,
  0x06, 0x03, 0xC0, 0xF0, 0x6C, 0x31, 0x8C, 0x66, 0x1B, 0x87, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFC, 0xE6, 0x70, 0x1F, 0x67, 0xFC, 0xC3, 0xB8, 0x76, 0x0E,
  0xC1, 0x98, 0x33, 0x06, 0xE1, 0xDC, 0x39, 0xFF, 0x1E, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x7C, 0x7F, 0x9C, 0x3B, 0x87, 0x60, 0xEC, 0x1D,
  0x83, 0x30, 0x6E, 0x0D, 0xC3, 0xB7, 0xE6, 0xF8, 0x1F, 0xC7, 0xF8, 0xC3,
  0xB8, 0x36, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0xCC, 0x39, 0xFE, 0x1F,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x1F, 0x63, 0xFE, 0x30, 0xE7,
  0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xCE, 0x1C, 0x7F, 0xC3,
  0xD8, 0x0F, 0x87, 0xF8, 0xC3, 0xB8, 0x76, 0x0E, 0xFF, 0xDF, 0xF3, 0x00,
  0xE0, 0x0C, 0x39, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x67, 0xFC, 0xC3,
  0xB8, 0x76, 0x0E, 0xC1, 0x98, 0x33, 0x06, 0x61, 0xCF, 0xF8, 0xF7, 0x00,
  0xC0, 0x18, 0x07, 0x1F, 0xC3, 0xF0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x7C, 0x7F, 0xDC, 0x3B, 0x87, 0x60, 0xEC, 0x19, 0x83, 0x30, 0x6E, 0x0D,
  0xC3, 0xB0, 0x76, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x8F, 0xFE, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x07, 0x0F, 0xE0, 0xFC, 0x00,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x73, 0x0E, 0x71, 0xC7, 0x38,
  0x73, 0x07, 0xF0, 0x7F, 0x06, 0x30, 0x63, 0x8E, 0x38, 0xE1, 0xCC, 0x1C,
  0xFC, 0x3F, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0E, 0x03, 0xFC, 0x7E, 0x37, 0x71, 0xDD, 0x8C,
  0xCC, 0x66, 0x63, 0x33, 0x31, 0x99, 0x88, 0xCC, 0xC6, 0x66, 0x63, 0x33,
  0x19, 0x99, 0xCC, 0xC0, 0x37, 0xC7, 0xFD, 0xC3, 0xB8, 0x76, 0x0E, 0xC1,
  0x98, 0x33, 0x06, 0xE0, 0xDC, 0x3B, 0x07, 0x60, 0xE0, 0x1F, 0x87, 0xF8,
  0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0xD8, 0x33, 0x06, 0xE0, 0xCC, 0x39, 0xFE,
  0x1F, 0x80, 0x1B, 0xE1, 0xFE, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x30,
  0x63, 0x06, 0x70, 0x67, 0x0E, 0x6F, 0xC6, 0xF8, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0x1F, 0x67, 0xEC, 0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0x98, 0x37,
  0x06, 0xE1, 0xDC, 0x39, 0xFF, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x37, 0xC3, 0xFE, 0x38, 0x63, 0x06, 0x70, 0x67, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x1F, 0xC7, 0xFC, 0xC3, 0xB8, 0x07,
  0x00, 0x7F, 0x03, 0xF0, 0x06, 0x00, 0xDC, 0x3B, 0xFE, 0x3F, 0x80, 0x0C,
  0x03, 0x01, 0xC3, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0F, 0xE1, 0xF0, 0x30, 0x66, 0x0D, 0xC1, 0xB8, 0x76,
  0x0E, 0xC1, 0x98, 0x33, 0x06, 0xE1, 0xCC, 0x31, 0xFE, 0x1F, 0x80, 0xE0,
  0xFC, 0x1B, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x18, 0xC3, 0xB0, 0x76, 0x07,
  0x80, 0xF0, 0x1C, 0x00, 0xCE, 0x78, 0xE6, 0x8E, 0x69, 0xE4, 0x96, 0xC9,
  0x6C, 0xB6, 0x8A, 0x78, 0xA7, 0x8E, 0x70, 0xE7, 0x0C, 0x70, 0x38, 0x38,
  0xE3, 0x83, 0x38, 0x1F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x1D,
  0x81, 0xCE, 0x1C, 0x31, 0xC1, 0xC0, 0x30, 0x6E, 0x0D, 0xC3, 0xB8, 0x76,
  0x0E, 0xC1, 0x98, 0x33, 0x06, 0x61, 0xCF, 0xF8, 0xF7, 0x00, 0xC0, 0x18,
  0x07, 0x1F, 0xC3, 0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xE0, 0x7C,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x1F, 0x83, 0xF0,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x7C, 0x07,
  0x80, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x1C, 0x71, 0xC6,
  0x18, 0x61, 0x8E, 0x38, 0x0F, 0x01, 0xF0, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x3F, 0x03, 0xF0, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7C, 0x0F, 0x80, 0x3C, 0x77,
  0xE6, 0xE6, 0x6C, 0x7C, 0x01, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 16, 13, 4, -16 },
  { 13, 8, 7, 13, 4, -16 },
  { 20, 13, 16, 13, 0, -16 },
  { 46, 12, 22, 13, 1, -19 },
  { 79, 16, 16, 13, -1, -16 },
  { 111, 13, 16, 13, 0, -16 },
  { 137, 3, 7, 13, 6, -16 },
  { 140, 10, 22, 13, 3, -19 },
  { 168, 9, 22, 13, 1, -19 },
  { 193, 12, 11, 13, 1, -13 },
  { 210, 11, 10, 13, 1, -12 },
  { 224, 6, 7, 13, 2, -3 },
  { 230, 8, 2, 13, 3, -8 },
  { 232, 4, 4, 13, 4, -4 },
  { 234, 14, 20, 13, 0, -18 },
  { 269, 12, 16, 13, 1, -16 },
  { 293, 10, 16, 13, 1, -16 },
  { 313, 12, 16, 13, 1, -16 },
  { 337, 11, 16, 13, 1, -16 },
  { 359, 11, 16, 13, 1, -16 },
  { 381, 12, 16, 13, 1, -16 },
  { 405, 11, 16, 13, 1, -16 },
  { 427, 11, 16, 13, 2, -16 },
  { 449, 11, 16, 13, 1, -16 },
  { 471, 11, 16, 13, 2, -16 },
  { 493, 5, 12, 13, 4, -12 },
  { 501, 7, 16, 13, 2, -12 },
  { 515, 11, 12, 13, 2, -13 },
  { 532, 11, 7, 13, 1, -11 },
  { 542, 11, 12, 13, 1, -13 },
  { 559, 9, 16, 13, 3, -16 },
  { 577, 13, 20, 13, 0, -16 },
  { 610, 11, 16, 13, 0, -16 },
  { 632, 12, 16, 13, 1, -16 },
  { 656, 12, 16, 13, 1, -16 },
  { 680, 12, 16, 13, 1, -16 },
  { 704, 12, 16, 13, 1, -16 },
  { 728, 12, 16, 13, 1, -16 },
  { 752, 12, 16, 13, 1, -16 },
  { 776, 12, 16, 13, 1, -16 },
  { 800, 12, 16, 13, 1, -16 },
  { 824, 13, 16, 13, 0, -16 },
  { 850, 13, 16, 13, 1, -16 },
  { 876, 10, 16, 13, 1, -16 },
  { 896, 13, 16, 13, 0, -16 },
  { 922, 12, 16, 13, 1, -16 },
  { 946, 12, 16, 13, 1, -16 },
  { 970, 12, 16, 13, 1, -16 },
  { 994, 12, 20, 13, 1, -16 },
  { 1024, 12, 16, 13, 1, -16 },
  { 1048, 12, 16, 13, 1, -16 },
  { 1072, 12, 16, 13, 2, -16 },
  { 1096, 12, 16, 13, 1, -16 },
  { 1120, 11, 16, 13, 3, -16 },
  { 1142, 13, 16, 13, 1, -16 },
  { 1168, 14, 16, 13, 0, -16 },
  { 1196, 12, 16, 13, 2, -16 },
  { 1220, 12, 16, 13, 1, -16 },
  { 1244, 9, 20, 13, 3, -18 },
  { 1267, 7, 20, 13, 3, -18 },
  { 1285, 9, 20, 13, 2, -18 },
  { 1308, 10, 9, 13, 2, -16 },
  { 1320, 11, 2, 13, 0, 1 },
  { 1323, 4, 3, 13, 6, -17 },
  { 1325, 11, 12, 13, 1, -12 },
  { 1342, 11, 16, 13, 1, -16 },
  { 1364, 11, 12, 13, 1, -12 },
  { 1381, 12, 16, 13, 1, -16 },
  { 1405, 11, 12, 13, 1, -12 },
  { 1422, 15, 20, 13, -1, -16 },
  { 1460, 11, 16, 13, 1, -12 },
  { 1482, 11, 16, 13, 1, -16 },
  { 1504, 11, 17, 13, 1, -17 },
  { 1528, 12, 21, 13, 0, -17 },
  { 1560, 12, 16, 13, 1, -16 },
  { 1584, 10, 16, 13, 2, -16 },
  { 1604, 13, 12, 13, 0, -12 },
  { 1624, 11, 12, 13, 1, -12 },
  { 1641, 11, 12, 13, 1, -12 },
  { 1658, 12, 16, 13, 0, -12 },
  { 1682, 11, 16, 13, 1, -12 },
  { 1704, 12, 12, 13, 1, -12 },
  { 1722, 11, 12, 13, 1, -12 },
  { 1739, 10, 15, 13, 2, -15 },
  { 1758, 11, 12, 13, 1, -12 },
  { 1775, 11, 12, 13, 2, -12 },
  { 1792, 12, 12, 13, 2, -12 },
  { 1810, 13, 12, 13, 0, -12 },
  { 1830, 11, 16, 13, 1, -12 },
  { 1852, 11, 12, 13, 1, -12 },
  { 1869, 11, 20, 13, 2, -18 },
  { 1897, 6, 20, 13, 4, -18 },
  { 1912, 12, 20, 13, 0, -18 },
  { 1942, 12, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_MEDIUMITALIC22PT7B_H_
