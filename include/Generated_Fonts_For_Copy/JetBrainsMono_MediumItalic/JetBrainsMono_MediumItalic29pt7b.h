#ifndef _JETBRAINSMONO_MEDIUMITALIC29PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x38, 0x38, 0x00, 0x00, 0x30, 0x78, 0xF8, 0x70, 0x71, 0xDC,
  0x77, 0x1D, 0xC7, 0xF1, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0x80, 0x00, 0xE1,
  0x80, 0x30, 0xE0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x87, 0x07, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x38,
  0x60, 0x0C, 0x18, 0x1F, 0xFF, 0x87, 0xFF, 0xE2, 0x60, 0xC0, 0x18, 0x70,
  0x0E, 0x18, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x5E,
  0x1C, 0xCE, 0x1C, 0xCF, 0x1C, 0xC0, 0x3C, 0xC0, 0x1C, 0xC0, 0x1F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xBC, 0x01, 0x9C, 0x01, 0x1C,
  0xF3, 0x1C, 0xF3, 0x1C, 0xF3, 0x38, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x70, 0xFE,
  0x0E, 0x1C, 0x60, 0xC1, 0x86, 0x18, 0x18, 0x63, 0x01, 0x8E, 0x70, 0x18,
  0xEE, 0x01, 0xFD, 0xC0, 0x1F, 0xB8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x20, 0x01, 0xDF, 0x80, 0x3B, 0xF8, 0x07, 0x31, 0xC0, 0x67, 0x1C,
  0x0C, 0x71, 0x81, 0x86, 0x18, 0x30, 0x73, 0x87, 0x07, 0xF0, 0xE0, 0x3E,
  0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x0E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0x73,
  0x8E, 0xF3, 0xDC, 0xE1, 0xDC, 0xE1, 0xF8, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0,
  0xF0, 0xF3, 0xF8, 0xFF, 0xB8, 0x7F, 0x1C, 0x77, 0x7F, 0xFE, 0xEE, 0xE0,
  0x00, 0x08, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x21, 0xC2, 0x79, 0x8F,
  0xFD, 0xBF, 0x3F, 0xFC, 0x01, 0x80, 0x03, 0xC0, 0x0E, 0xE0, 0x1E, 0xF0,
  0x3C, 0x70, 0x78, 0x78, 0x30, 0x30, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1F, 0x3E, 0x3C, 0x38, 0x78, 0x70, 0xF0,
  0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x39, 0xEF, 0xBE, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xF8, 0x78, 0xF1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x71, 0x1C, 0xEF, 0x39, 0xDE, 0x77, 0x1D, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0xEF, 0x83, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0x9C, 0x1C, 0xF0,
  0x43, 0x82, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x1C, 0x0E,
  0x3C, 0x0E, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x78, 0x0E, 0xF0, 0x38, 0xE0, 0xF1, 0xF7, 0xC3, 0xFF, 0x01,
  0xFC, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xE7, 0x83, 0x9C, 0x0E, 0xE0,
  0x3B, 0x81, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0xF8, 0x77, 0xF1, 0xFF, 0xE7, 0x87, 0x9C, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xE0, 0x73, 0x81, 0xCF, 0xFE,
  0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0xF9,
  0xF3, 0xC0, 0xE7, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0x78, 0x0E, 0xF0, 0x1C,
  0xE0, 0x71, 0xF7, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF3, 0x80, 0xEF, 0x03, 0x9C, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xFC, 0x3C, 0x78, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x0E, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xC3, 0xC3,
  0x8F, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xF7, 0xE1,
  0xFF, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xF8, 0xF1, 0xC0, 0xF7,
  0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x79, 0xFF,
  0xE1, 0xFF, 0xC1, 0xF7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x7C, 0xF9, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E, 0x7C, 0x07, 0x87,
  0xC3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21,
  0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x30,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x04, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x10, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x06,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x7F, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE3, 0xFC, 0x3F, 0x83, 0xE0, 0x38, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x02, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x73,
  0x80, 0x18, 0xE1, 0xF6, 0x30, 0xFD, 0x8C, 0x38, 0xE7, 0x1C, 0x39, 0xC7,
  0x0E, 0x71, 0xC3, 0x1C, 0x60, 0xC7, 0x18, 0x71, 0x8E, 0x1C, 0x63, 0x87,
  0x38, 0x7F, 0xCE, 0x1F, 0x73, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x73, 0x00, 0xE6, 0x01, 0xCE,
  0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0x38, 0x1C, 0xF0, 0x1D, 0xC0, 0x3B, 0x80, 0x7E, 0x00,
  0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x3C, 0x3F, 0xF0, 0x3F, 0xF8, 0x38,
  0x7C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x78,
  0xF1, 0xE0, 0xE3, 0x81, 0xEF, 0x03, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x1C, 0xE0, 0x79, 0xE0, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0xF1, 0xE0,
  0xE3, 0x81, 0xEF, 0x03, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC7, 0xF3, 0x9F, 0xEF, 0x3F, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0,
  0x79, 0xC0, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x1E, 0x07, 0x1C,
  0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x1C, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0,
  0x38, 0xE0, 0x38, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF0, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x03, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1F, 0xFE, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x03, 0xC3, 0x83,
  0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0xF1, 0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x81, 0xC1, 0xC0,
  0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x1E, 0x07, 0x8E, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC7, 0xC3, 0x63, 0xE3, 0xF1, 0xF9,
  0xB8, 0xEC, 0xDC, 0x66, 0xCC, 0x33, 0x6E, 0x39, 0xF7, 0x1C, 0xF3, 0x8E,
  0x79, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x1F,
  0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1B, 0x0E, 0x1B, 0x0E, 0x3B, 0x8E, 0x3B,
  0x8E, 0x3B, 0x8E, 0x39, 0x8E, 0x39, 0x8C, 0x31, 0xDC, 0x71, 0xDC, 0x71,
  0xDC, 0x70, 0xDC, 0x70, 0xDC, 0x70, 0xFC, 0x70, 0xF8, 0xE0, 0xF8, 0xE0,
  0x78, 0xE0, 0x78, 0x07, 0xF0, 0x1F, 0xF0, 0x79, 0xF1, 0xE0, 0xE3, 0x81,
  0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xF3,
  0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC1,
  0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFF, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x0E, 0x38, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0x80, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xCF, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF7, 0x81, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0xFF,
  0x83, 0xFF, 0x03, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07,
  0x1C, 0x07, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x7C, 0x3F, 0xF8,
  0x3F, 0xF0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x78, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0xFE,
  0x0F, 0x1E, 0x1C, 0x0E, 0x1C, 0x0F, 0x1C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x38, 0x7F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0,
  0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3C,
  0xE0, 0x71, 0xC1, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0xF0, 0x0F,
  0xE0, 0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x8E, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x61, 0xC3, 0xB0, 0xE1, 0x98, 0x71, 0xCC, 0x78, 0xEE, 0x3C,
  0x77, 0x1E, 0x33, 0x9B, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x72, 0x66, 0x3B,
  0x37, 0x1D, 0x9B, 0x8E, 0xCD, 0x87, 0xC6, 0xC3, 0x63, 0xE1, 0xB1, 0xF0,
  0xD8, 0xF0, 0x78, 0x58, 0x3C, 0x3C, 0x1E, 0x1E, 0x0E, 0x0E, 0x00, 0x1E,
  0x03, 0xC3, 0x81, 0xE0, 0xF0, 0x70, 0x1C, 0x3C, 0x07, 0x1E, 0x00, 0xE7,
  0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x38, 0xE0, 0x1C,
  0x38, 0x0F, 0x0F, 0x07, 0x81, 0xC1, 0xC0, 0x78, 0xF0, 0x0E, 0x00, 0xE0,
  0x0F, 0xF0, 0x1E, 0x70, 0x1C, 0x70, 0x38, 0x78, 0x78, 0x38, 0x70, 0x38,
  0xE0, 0x38, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xFF,
  0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x36,
  0x01, 0xD8, 0x0E, 0x70, 0x39, 0xC1, 0xC3, 0x07, 0x0C, 0x38, 0x39, 0xC0,
  0xEF, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xC3, 0x87, 0x0F, 0x9C,
  0x7F, 0x73, 0xEF, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0xBC, 0x0E,
  0xE0, 0x3B, 0x80, 0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0xEF, 0xC7, 0xF7,
  0x1F, 0x9C, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xBF, 0x0F, 0xFF, 0x1D, 0xFE, 0x3C, 0x1C, 0x70, 0x3C, 0xE0, 0x71, 0xC0,
  0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xF0, 0x71,
  0xFF, 0xE7, 0xFF, 0x8E, 0x7C, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x9E,
  0x0F, 0x70, 0x1D, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x1E, 0xE0, 0x73, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC1, 0xF3, 0x87, 0xF7, 0x1F,
  0x7E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xC1, 0xE3, 0xEF, 0xC3, 0xFB, 0x87,
  0xE7, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC7, 0x9E, 0x0E, 0x70, 0x3D, 0xC0,
  0xE7, 0x03, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x73, 0xC7, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xDC, 0x7F, 0x73,
  0xEF, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B,
  0x80, 0xEE, 0x07, 0xBC, 0x3C, 0xFF, 0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x3E, 0x1F, 0xF0, 0xFF, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xBF, 0x0F, 0xFF, 0x1D, 0xBE,
  0x3C, 0x1C, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03,
  0x80, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x0F, 0x1C, 0x1E, 0x3C, 0x1C, 0x38, 0x3C, 0x38, 0x78, 0x38, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xF0,
  0x70, 0x70, 0x70, 0x78, 0xF0, 0x38, 0xE0, 0x3C, 0xFF, 0x0F, 0xF0, 0xFF,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x3F,
  0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0xCF, 0x0D, 0xFF, 0x87, 0x39, 0xC7, 0x1C,
  0x63, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x1C, 0x71, 0x8E, 0x31, 0xC7, 0x38,
  0xE3, 0x1C, 0x63, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0xCE, 0x39,
  0xC7, 0x18, 0x1D, 0xF8, 0x7F, 0xF8, 0xED, 0xF1, 0xE0, 0xE3, 0x81, 0xE7,
  0x03, 0x8E, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0x0F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x9E, 0x0E, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0xFF, 0x87, 0xFE, 0x0F, 0xE0,
  0x0E, 0xFC, 0x1F, 0xFE, 0x1D, 0xFE, 0x1E, 0x0E, 0x1C, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C,
  0x3C, 0x1C, 0x3F, 0xFC, 0x7F, 0xF8, 0x73, 0xF0, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xFF, 0xDE,
  0x0F, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xEE,
  0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0xEF, 0xC7, 0xF7, 0x1F, 0x9C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x39, 0xF0, 0x77, 0xF0, 0xFD,
  0xF1, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x78, 0xF1, 0xE0, 0xF3, 0x80, 0x07, 0x00,
  0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xEF,
  0x03, 0x8F, 0x8F, 0x1F, 0xFC, 0x1F, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xEE,
  0x07, 0xB8, 0x1C, 0xF0, 0xF3, 0xEF, 0x87, 0xFC, 0x0F, 0xE0, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xF0, 0x71, 0xC3, 0xC7, 0x0E, 0x1C, 0x78,
  0x71, 0xC1, 0xC7, 0x07, 0x38, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0xE3, 0x87, 0xE3, 0x86, 0xE3, 0x86, 0xE6, 0x8E, 0xE6, 0x8C,
  0xE6, 0x8C, 0xE5, 0x9C, 0xED, 0x98, 0xCD, 0x98, 0xC9, 0xB8, 0xD9, 0xB8,
  0xD9, 0xB0, 0xD1, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E, 0x07,
  0x87, 0x07, 0x83, 0xC7, 0x80, 0xE3, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x01, 0xCE, 0x01,
  0xE3, 0x81, 0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0x38, 0x1D, 0xE0, 0x77,
  0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B,
  0x81, 0xEE, 0x07, 0xBC, 0x3C, 0xFF, 0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x3E, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0x3F,
  0xFE, 0x7F, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x0F, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x0F, 0x80,
  0xFF, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xC0, 0x00,
  0x3E, 0x0E, 0xFE, 0x3B, 0x9E, 0x77, 0x1F, 0xEE, 0x3F, 0x98, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 21, 17, 5, -21 },
  { 22, 10, 9, 17, 5, -21 },
  { 34, 18, 21, 17, 0, -21 },
  { 82, 16, 29, 17, 1, -25 },
  { 140, 20, 21, 17, -1, -21 },
  { 193, 16, 21, 17, 1, -21 },
  { 235, 4, 9, 17, 8, -21 },
  { 240, 13, 29, 17, 4, -25 },
  { 288, 13, 29, 17, 1, -25 },
  { 336, 16, 15, 17, 1, -18 },
  { 366, 14, 13, 17, 2, -16 },
  { 389, 8, 9, 17, 3, -4 },
  { 398, 10, 3, 17, 4, -11 },
  { 402, 6, 5, 17, 5, -5 },
  { 406, 18, 27, 17, 0, -24 },
  { 467, 15, 21, 17, 2, -21 },
  { 507, 14, 21, 17, 1, -21 },
  { 544, 16, 21, 17, 1, -21 },
  { 586, 15, 21, 17, 1, -21 },
  { 626, 14, 21, 17, 2, -21 },
  { 663, 14, 21, 17, 2, -21 },
  { 700, 15, 21, 17, 1, -21 },
  { 740, 15, 21, 17, 3, -21 },
  { 780, 15, 21, 17, 1, -21 },
  { 820, 15, 21, 17, 2, -21 },
  { 860, 7, 16, 17, 5, -16 },
  { 874, 9, 21, 17, 3, -16 },
  { 898, 15, 15, 17, 2, -17 },
  { 927, 14, 10, 17, 2, -15 },
  { 945, 15, 15, 17, 1, -17 },
  { 974, 12, 21, 17, 4, -21 },
  { 1006, 18, 26, 17, 0, -21 },
  { 1065, 15, 21, 17, 0, -21 },
  { 1105, 16, 21, 17, 1, -21 },
  { 1147, 15, 21, 17, 2, -21 },
  { 1187, 16, 21, 17, 1, -21 },
  { 1229, 16, 21, 17, 1, -21 },
  { 1271, 16, 21, 17, 1, -21 },
  { 1313, 15, 21, 17, 2, -21 },
  { 1353, 16, 21, 17, 1, -21 },
  { 1395, 15, 21, 17, 2, -21 },
  { 1435, 17, 21, 17, 0, -21 },
  { 1480, 17, 21, 17, 1, -21 },
  { 1525, 13, 21, 17, 2, -21 },
  { 1560, 17, 21, 17, 1, -21 },
  { 1605, 16, 21, 17, 1, -21 },
  { 1647, 15, 21, 17, 2, -21 },
  { 1687, 16, 21, 17, 1, -21 },
  { 1729, 15, 26, 17, 2, -21 },
  { 1778, 16, 21, 17, 1, -21 },
  { 1820, 16, 21, 17, 1, -21 },
  { 1862, 15, 21, 17, 3, -21 },
  { 1902, 15, 21, 17, 2, -21 },
  { 1942, 15, 21, 17, 3, -21 },
  { 1982, 17, 21, 17, 2, -21 },
  { 2027, 18, 21, 17, 0, -21 },
  { 2075, 16, 21, 17, 3, -21 },
  { 2117, 16, 21, 17, 1, -21 },
  { 2159, 12, 27, 17, 4, -24 },
  { 2200, 10, 27, 17, 4, -24 },
  { 2234, 12, 27, 17, 2, -24 },
  { 2275, 14, 11, 17, 2, -21 },
  { 2295, 14, 2, 17, 0, 1 },
  { 2299, 6, 4, 17, 7, -23 },
  { 2302, 14, 16, 17, 2, -16 },
  { 2330, 15, 21, 17, 1, -21 },
  { 2370, 14, 16, 17, 2, -16 },
  { 2398, 15, 21, 17, 2, -21 },
  { 2438, 14, 16, 17, 2, -16 },
  { 2466, 19, 26, 17, -1, -21 },
  { 2528, 14, 21, 17, 2, -16 },
  { 2565, 15, 21, 17, 1, -21 },
  { 2605, 14, 23, 17, 1, -23 },
  { 2646, 16, 28, 17, 0, -23 },
  { 2702, 16, 21, 17, 1, -21 },
  { 2744, 12, 21, 17, 3, -21 },
  { 2776, 17, 16, 17, 0, -16 },
  { 2810, 15, 16, 17, 1, -16 },
  { 2840, 14, 16, 17, 2, -16 },
  { 2868, 16, 21, 17, 0, -16 },
  { 2910, 14, 21, 17, 2, -16 },
  { 2947, 15, 16, 17, 2, -16 },
  { 2977, 15, 16, 17, 1, -16 },
  { 3007, 14, 20, 17, 2, -20 },
  { 3042, 14, 16, 17, 2, -16 },
  { 3070, 14, 16, 17, 3, -16 },
  { 3098, 16, 16, 17, 2, -16 },
  { 3130, 17, 16, 17, 0, -16 },
  { 3164, 14, 21, 17, 2, -16 },
  { 3201, 15, 16, 17, 1, -16 },
  { 3231, 15, 27, 17, 3, -24 },
  { 3282, 8, 27, 17, 5, -24 },
  { 3309, 15, 27, 17, 1, -24 },
  { 3360, 15, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_MEDIUMITALIC29PT7B_H_
