#ifndef _JETBRAINSMONO_MEDIUMITALIC34PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC3, 0xF1, 0xF8, 0x78, 0x00, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0F,
  0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x18,
  0x03, 0x83, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x60, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0C, 0x01, 0xC1,
  0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0x83, 0x80, 0x38,
  0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xB7, 0xC1, 0xE6, 0x78,
  0x78, 0xC7, 0x0F, 0x18, 0xE1, 0xE7, 0x00, 0x3C, 0xC0, 0x07, 0xD8, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0C, 0xF8, 0x01, 0x8F, 0x00, 0x31, 0xE3, 0x86, 0x3C, 0x70, 0xC7, 0x8F,
  0x39, 0xE1, 0xF6, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x07, 0xF0, 0x0E, 0x0F, 0x78, 0x1C, 0x1C, 0x38, 0x38,
  0x1C, 0x38, 0x70, 0x1C, 0x38, 0xE0, 0x1C, 0x39, 0xC0, 0x1C, 0x31, 0x80,
  0x1C, 0x73, 0x80, 0x1F, 0xE7, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x77, 0xE0, 0x00, 0xEF, 0xF0,
  0x01, 0xDE, 0x70, 0x03, 0x9C, 0x38, 0x07, 0x1C, 0x30, 0x0E, 0x18, 0x30,
  0x1C, 0x38, 0x70, 0x1C, 0x38, 0x70, 0x38, 0x1C, 0xF0, 0x70, 0x1F, 0xE0,
  0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xC7,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x02, 0xF3, 0x87,
  0x9E, 0x78, 0xE3, 0x87, 0xBC, 0xF0, 0xFF, 0x1E, 0x0F, 0xC3, 0xC1, 0xF8,
  0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE1, 0xFC, 0x3F, 0xFF, 0x83, 0xFE, 0x78,
  0x3F, 0x87, 0x80, 0x3B, 0xDE, 0xF7, 0xBD, 0xCE, 0x77, 0x80, 0x00, 0x02,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0x80,
  0x04, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x38, 0x6F,
  0x8C, 0x7F, 0xFB, 0x7F, 0x7F, 0xFF, 0x83, 0xFE, 0x00, 0x3C, 0x00, 0x1D,
  0x80, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC7, 0x81, 0xE0, 0xF0, 0x78, 0x38,
  0x04, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x8C, 0x79,
  0xE7, 0x9E, 0x7B, 0xE7, 0x1C, 0x79, 0xC7, 0x0C, 0x73, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x71, 0xE0, 0x70, 0xF0, 0x20,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x05, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0x1F, 0x1F,
  0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x0F,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xE3, 0xC0, 0xF3,
  0xE0, 0x79, 0xE0, 0x39, 0xE0, 0x1C, 0xF0, 0x1E, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC1,
  0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9,
  0xF0, 0x7C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xDC, 0x01,
  0xEE, 0x00, 0xE7, 0x80, 0xF3, 0xE0, 0xF0, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0x00,
  0xF7, 0x80, 0xF3, 0x80, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3E, 0x1F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0x79, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xF1, 0xF0, 0xF0, 0x3C, 0x38, 0x07, 0x1E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1F, 0x07, 0x87, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7,
  0xC3, 0xE7, 0xC0, 0xF3, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0x78, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xC7, 0xE7, 0xE3, 0xFF, 0xE0, 0xFE,
  0xF0, 0x08, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x1F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xFC, 0xFC, 0xFC, 0x78, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xC8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x30, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01, 0xE3, 0x80,
  0x0E, 0x3C, 0x04, 0x71, 0xC1, 0xFB, 0x8E, 0x1F, 0xFC, 0x70, 0xE1, 0xE3,
  0x8F, 0x0F, 0x1C, 0x70, 0x79, 0xE3, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0xE0,
  0xE3, 0x87, 0x07, 0x1C, 0x78, 0x38, 0xE3, 0xC3, 0xC7, 0x0F, 0x3C, 0x78,
  0x7F, 0x63, 0x81, 0xF7, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0x78, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xC7, 0x01, 0xE3, 0x80,
  0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0F,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0x07, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xC0, 0x3C, 0x38, 0x07,
  0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x7E,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x38,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F, 0x07, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x71,
  0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x00,
  0xE3, 0xC0, 0x38, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xC0, 0x3C, 0x70,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F,
  0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07,
  0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x1E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x78, 0x07, 0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0xC1, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xE0, 0xE0, 0x3C, 0x0E, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0xC0,
  0x38, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x01,
  0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x6E, 0x1F, 0x8E, 0xE1, 0xD8, 0xDC, 0x39, 0x9D, 0xC3, 0x9D, 0x9C, 0x39,
  0xF9, 0xC3, 0x9F, 0xBC, 0x39, 0xF3, 0xC3, 0x8F, 0x3C, 0x78, 0x03, 0x87,
  0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78,
  0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x00, 0x0F, 0x80, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xFC,
  0x1C, 0x3B, 0x83, 0x87, 0x70, 0x70, 0xEE, 0x0E, 0x1D, 0xC3, 0xC3, 0x9C,
  0x78, 0x73, 0x8E, 0x1E, 0x71, 0xC3, 0xCE, 0x38, 0x79, 0xC7, 0x0E, 0x1D,
  0xE1, 0xC3, 0xBC, 0x38, 0x77, 0x8F, 0x0E, 0xE1, 0xE1, 0xDC, 0x3C, 0x3F,
  0x87, 0x03, 0xF0, 0xE0, 0x7E, 0x1C, 0x0F, 0xC7, 0x81, 0xF0, 0xF0, 0x3E,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0x70,
  0x0F, 0x78, 0x07, 0x3C, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xE1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xE0, 0xFE, 0x0E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x03, 0xC3, 0xC0,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xE3,
  0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0x07, 0xE0, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x1F, 0x1E, 0x0F,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x38, 0x38,
  0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1C, 0x07, 0x83, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x80,
  0x70, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x80, 0xF0, 0xF8, 0x3E,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x1C,
  0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8E, 0x01,
  0xE3, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xC0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x3E, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF1,
  0xC0, 0x78, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0E, 0x0F, 0x0F,
  0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0xF1, 0xC0, 0x79, 0xE0, 0x1C,
  0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x70, 0x77, 0x07, 0x07, 0x70, 0xF0,
  0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x0E, 0x71, 0xB1, 0xC7, 0x1B,
  0x1C, 0x71, 0xB1, 0xC7, 0x33, 0x1C, 0x73, 0x33, 0x87, 0x33, 0x38, 0x77,
  0x33, 0x8F, 0x63, 0x38, 0xE6, 0x37, 0x0E, 0x63, 0x70, 0xEE, 0x37, 0x0E,
  0xC7, 0xE0, 0xEC, 0x7E, 0x0E, 0xC7, 0xE0, 0xF8, 0x6E, 0x0F, 0x86, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x00, 0x0F, 0x00, 0x78, 0x38,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x1E, 0x00, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0,
  0x03, 0xC0, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC3,
  0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x3C, 0x03,
  0xCF, 0x00, 0x39, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7B, 0x80,
  0xE7, 0x03, 0x8E, 0x0F, 0x1E, 0x1C, 0x1C, 0x78, 0x38, 0xE0, 0x73, 0x80,
  0xFF, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xF3, 0xC7,
  0x8F, 0x3C, 0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFF, 0xE7, 0xC3, 0xF3, 0xC0,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C,
  0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF0, 0xFC,
  0x7F, 0xFC, 0x3F, 0xEE, 0x0F, 0xEF, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0xE0, 0x7B,
  0xFC, 0x1F, 0xFF, 0x87, 0x63, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xC7,
  0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1F, 0x07, 0x87, 0x7F, 0xE1, 0xDF,
  0xF0, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3,
  0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xF3, 0xC0, 0x79,
  0xF0, 0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x3E,
  0x78, 0x3F, 0xDE, 0x1F, 0xFF, 0x8F, 0x87, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0E, 0x3C,
  0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x1F, 0x87, 0xFF,
  0xC1, 0xFF, 0x70, 0x3F, 0xBC, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x1F, 0xFE,
  0x1E, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E,
  0xF8, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFF, 0xE7, 0xC3, 0xF3, 0xC0,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C,
  0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xF3, 0xF8, 0xFF, 0xFC,
  0x3F, 0xDC, 0x07, 0x8E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0xE0,
  0x7B, 0xFC, 0x1F, 0xFF, 0x87, 0x43, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x0E, 0x01,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0xF0, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7E, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x78, 0xF0,
  0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x70, 0x3C, 0x0E, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x3D, 0xE7, 0x87, 0x7D, 0xF8, 0xFF, 0xBF,
  0x1E, 0x38, 0xE3, 0x86, 0x1C, 0x71, 0xC3, 0x9E, 0x38, 0x73, 0xC7, 0x1E,
  0x70, 0xE3, 0xCE, 0x1C, 0x71, 0xC3, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x39,
  0xE3, 0x8F, 0x3C, 0x71, 0xE7, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x30, 0xE3,
  0x8E, 0x1C, 0x00, 0x1E, 0x7E, 0x07, 0xBF, 0xC1, 0xFF, 0xF8, 0x74, 0x3E,
  0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0x8F, 0x01, 0xE0, 0x03, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x0F, 0x3F, 0x01, 0xEF, 0xF0, 0x3F, 0xFF, 0x07, 0x63, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x70, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xF0, 0x78, 0x3B, 0xFF, 0x07, 0x7F, 0xC1, 0xE7, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFF, 0xE7, 0xC3, 0xF3, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x9E,
  0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF0, 0xFC, 0x7F, 0xDC,
  0x3F, 0xEE, 0x0F, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x7C, 0x0E, 0xFF, 0x87, 0x7F,
  0xC7, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x04, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF8, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00,
  0xF3, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9C, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x78,
  0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF8,
  0x03, 0xDC, 0x03, 0xCE, 0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x9E, 0x03, 0xCE,
  0x01, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x87, 0x87, 0x70, 0xF0, 0xEE,
  0x1E, 0x1D, 0xC6, 0xC7, 0x38, 0xD8, 0xE7, 0x1B, 0x1C, 0xE7, 0x67, 0x1C,
  0xCC, 0xE3, 0x99, 0x9C, 0x73, 0x33, 0x0E, 0xC6, 0xE1, 0xD8, 0xDC, 0x3B,
  0x1B, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x0F,
  0x1E, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF8, 0xF8, 0x07, 0x80,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x9C,
  0x03, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x04, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1F,
  0xC1, 0xDF, 0xF0, 0xEE, 0x78, 0x7F, 0x1E, 0x7F, 0x07, 0xFB, 0x83, 0xF8,
  0x00, 0x70,
};

const GFXglyph JetBrainsMono_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 25, 20, 6, -25 },
  { 30, 12, 10, 20, 6, -25 },
  { 45, 20, 25, 20, 1, -25 },
  { 108, 19, 35, 20, 1, -30 },
  { 192, 24, 25, 20, -1, -25 },
  { 267, 19, 25, 20, 1, -25 },
  { 327, 5, 10, 20, 9, -25 },
  { 334, 15, 33, 20, 5, -29 },
  { 396, 14, 33, 20, 2, -29 },
  { 454, 18, 18, 20, 2, -21 },
  { 495, 17, 16, 20, 2, -19 },
  { 529, 9, 10, 20, 3, -5 },
  { 541, 11, 3, 20, 5, -13 },
  { 546, 6, 6, 20, 6, -6 },
  { 551, 21, 32, 20, 0, -28 },
  { 635, 18, 25, 20, 2, -25 },
  { 692, 17, 25, 20, 1, -25 },
  { 746, 18, 25, 20, 1, -25 },
  { 803, 18, 25, 20, 1, -25 },
  { 860, 17, 25, 20, 2, -25 },
  { 914, 17, 25, 20, 2, -25 },
  { 968, 17, 25, 20, 1, -25 },
  { 1022, 17, 25, 20, 4, -25 },
  { 1076, 18, 25, 20, 1, -25 },
  { 1133, 17, 25, 20, 3, -25 },
  { 1187, 8, 19, 20, 6, -19 },
  { 1206, 12, 24, 20, 3, -19 },
  { 1242, 16, 18, 20, 3, -20 },
  { 1278, 17, 12, 20, 2, -17 },
  { 1304, 16, 18, 20, 2, -20 },
  { 1340, 14, 25, 20, 5, -25 },
  { 1384, 21, 31, 20, 0, -25 },
  { 1466, 17, 25, 20, 0, -25 },
  { 1520, 19, 25, 20, 1, -25 },
  { 1580, 18, 25, 20, 2, -25 },
  { 1637, 18, 25, 20, 1, -25 },
  { 1694, 18, 25, 20, 2, -25 },
  { 1751, 19, 25, 20, 1, -25 },
  { 1811, 18, 25, 20, 2, -25 },
  { 1868, 19, 25, 20, 1, -25 },
  { 1928, 18, 25, 20, 2, -25 },
  { 1985, 20, 25, 20, 0, -25 },
  { 2048, 20, 25, 20, 1, -25 },
  { 2111, 15, 25, 20, 2, -25 },
  { 2158, 20, 25, 20, 1, -25 },
  { 2221, 19, 25, 20, 1, -25 },
  { 2281, 17, 25, 20, 2, -25 },
  { 2335, 20, 25, 20, 1, -25 },
  { 2398, 18, 31, 20, 2, -25 },
  { 2468, 19, 25, 20, 1, -25 },
  { 2528, 19, 25, 20, 1, -25 },
  { 2588, 17, 25, 20, 4, -25 },
  { 2642, 18, 25, 20, 2, -25 },
  { 2699, 17, 25, 20, 4, -25 },
  { 2753, 20, 25, 20, 2, -25 },
  { 2816, 21, 25, 20, 0, -25 },
  { 2882, 19, 25, 20, 3, -25 },
  { 2942, 19, 25, 20, 1, -25 },
  { 3002, 14, 32, 20, 5, -28 },
  { 3058, 11, 32, 20, 5, -28 },
  { 3102, 14, 32, 20, 3, -28 },
  { 3158, 15, 13, 20, 3, -25 },
  { 3183, 17, 3, 20, 0, 1 },
  { 3190, 6, 5, 20, 9, -27 },
  { 3194, 17, 19, 20, 2, -19 },
  { 3235, 18, 25, 20, 1, -25 },
  { 3292, 17, 19, 20, 2, -19 },
  { 3333, 18, 25, 20, 2, -25 },
  { 3390, 16, 19, 20, 2, -19 },
  { 3428, 23, 31, 20, -2, -25 },
  { 3518, 17, 25, 20, 2, -19 },
  { 3572, 18, 25, 20, 1, -25 },
  { 3629, 17, 27, 20, 1, -27 },
  { 3687, 18, 33, 20, 0, -27 },
  { 3762, 19, 25, 20, 1, -25 },
  { 3822, 15, 25, 20, 3, -25 },
  { 3869, 19, 19, 20, 1, -19 },
  { 3915, 18, 19, 20, 1, -19 },
  { 3958, 16, 19, 20, 2, -19 },
  { 3996, 19, 25, 20, 0, -19 },
  { 4056, 17, 25, 20, 2, -19 },
  { 4110, 17, 19, 20, 2, -19 },
  { 4151, 17, 19, 20, 2, -19 },
  { 4192, 16, 24, 20, 3, -24 },
  { 4240, 17, 19, 20, 2, -19 },
  { 4281, 17, 19, 20, 3, -19 },
  { 4322, 19, 19, 20, 2, -19 },
  { 4368, 20, 19, 20, 0, -19 },
  { 4416, 17, 25, 20, 2, -19 },
  { 4470, 18, 19, 20, 1, -19 },
  { 4513, 18, 32, 20, 3, -28 },
  { 4585, 9, 32, 20, 6, -28 },
  { 4621, 17, 32, 20, 1, -28 },
  { 4689, 17, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_MEDIUMITALIC34PT7B_H_
