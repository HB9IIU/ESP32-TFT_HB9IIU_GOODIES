#ifndef _JETBRAINSMONO_MEDIUMITALIC13PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x64, 0x04, 0xC0, 0x5E, 0xF4, 0x1B, 0x12, 0x7F, 0x24,
  0x24, 0x24, 0xFE, 0x48, 0xD8, 0x04, 0x0C, 0x3E, 0x2A, 0x28, 0x38, 0x1C,
  0x16, 0x56, 0x54, 0x7C, 0x10, 0x10, 0x18, 0x4B, 0x22, 0xD0, 0xA8, 0x34,
  0x02, 0x01, 0xF0, 0x54, 0x25, 0x31, 0xC0, 0x0C, 0x3E, 0x26, 0x20, 0x30,
  0x73, 0x5E, 0xCC, 0xCC, 0x76, 0xE8, 0x08, 0xC8, 0xC4, 0x23, 0x18, 0xC6,
  0x10, 0xE1, 0x00, 0x23, 0x86, 0x30, 0x8C, 0x62, 0x11, 0x99, 0x88, 0x00,
  0x10, 0x23, 0x5B, 0xC3, 0x0B, 0x22, 0x00, 0x10, 0x4F, 0xCC, 0x20, 0x80,
  0x36, 0x4C, 0xF0, 0x78, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0x19, 0xF4, 0x71, 0xD6, 0xD8, 0xE3, 0x8B, 0xC0,
  0x39, 0x69, 0x84, 0x10, 0x43, 0x0C, 0xFC, 0x19, 0xFC, 0x41, 0x0C, 0x63,
  0x18, 0xC7, 0xE0, 0x7C, 0x21, 0x0E, 0x0C, 0x38, 0xE2, 0xF0, 0x0C, 0x43,
  0x18, 0xCE, 0x3F, 0x82, 0x08, 0x7D, 0x04, 0x1E, 0xCC, 0x30, 0xE2, 0xF0,
  0x18, 0xC2, 0x1E, 0xCE, 0x18, 0xE2, 0xF0, 0x7F, 0x88, 0x30, 0x41, 0x82,
  0x0C, 0x30, 0x40, 0x19, 0xF4, 0x51, 0x79, 0xEC, 0xE3, 0x8B, 0xC0, 0x18,
  0xF9, 0x1E, 0x2C, 0x4F, 0x86, 0x08, 0x20, 0xC0, 0x66, 0x00, 0x06, 0xC0,
  0x31, 0x80, 0x00, 0x19, 0x88, 0xC0, 0x04, 0x37, 0x30, 0xE0, 0xE0, 0xC0,
  0x7F, 0xF0, 0x00, 0xFC, 0x83, 0x83, 0x83, 0x1D, 0x88, 0x00, 0xF8, 0xC2,
  0x37, 0x22, 0x18, 0xC0, 0x0C, 0x32, 0x61, 0x41, 0x4D, 0x52, 0xD2, 0xD2,
  0x9E, 0x80, 0xC0, 0x70, 0x1C, 0x28, 0x51, 0xA2, 0x4F, 0x9F, 0x23, 0xC6,
  0x7C, 0x89, 0x17, 0xCF, 0x91, 0xA3, 0x44, 0xF0, 0x18, 0xF9, 0x16, 0x0C,
  0x18, 0x20, 0x46, 0xC9, 0xE0, 0x3E, 0x44, 0x8B, 0x16, 0x28, 0xD1, 0xA6,
  0xF8, 0x7E, 0x81, 0x03, 0xEF, 0x98, 0x20, 0x40, 0xF8, 0x7E, 0xFD, 0x02,
  0x0C, 0x1F, 0xB0, 0x40, 0x81, 0x00, 0x18, 0xF9, 0x16, 0x0C, 0x1B, 0xA3,
  0x46, 0xC9, 0xE0, 0x46, 0x89, 0x17, 0xEF, 0xD1, 0xA3, 0x44, 0x88, 0x7C,
  0x41, 0x0C, 0x30, 0xC2, 0x08, 0xF8, 0x0E, 0x04, 0x08, 0x30, 0x60, 0xF1,
  0x66, 0x78, 0x46, 0x99, 0x27, 0xCF, 0x13, 0x26, 0x44, 0x8C, 0x61, 0x04,
  0x10, 0x43, 0x0C, 0x20, 0xFC, 0x33, 0x77, 0x56, 0x5A, 0x5A, 0x42, 0x46,
  0x46, 0xC4, 0x33, 0x32, 0x32, 0x7A, 0x6A, 0x4E, 0x4E, 0x4C, 0xCC, 0x19,
  0xF4, 0x71, 0xC7, 0x18, 0xE3, 0x8B, 0xC0, 0x7C, 0x8D, 0x1E, 0x2F, 0x90,
  0x20, 0x40, 0x80, 0x19, 0xF4, 0x71, 0xC6, 0x18, 0xE3, 0x8B, 0xC1, 0x06,
  0x7C, 0x8D, 0x16, 0x6F, 0x92, 0x26, 0x44, 0x8C, 0x0C, 0x3E, 0x22, 0x20,
  0x30, 0x1C, 0x06, 0x46, 0x44, 0x7C, 0x7F, 0xFC, 0x40, 0x83, 0x06, 0x0C,
  0x10, 0x20, 0x40, 0x46, 0x89, 0x16, 0x2C, 0xD1, 0xA3, 0x64, 0xF0, 0xC6,
  0x89, 0x12, 0x64, 0x8B, 0x14, 0x38, 0x60, 0x9B, 0x26, 0xDD, 0xAB, 0x5A,
  0xB7, 0x6C, 0x98, 0x23, 0x36, 0x14, 0x18, 0x18, 0x38, 0x2C, 0x44, 0xC6,
  0xC6, 0x89, 0xA1, 0xC3, 0x06, 0x08, 0x10, 0x20, 0x3F, 0x06, 0x04, 0x08,
  0x18, 0x30, 0x20, 0x40, 0xFC, 0x3B, 0x18, 0xC4, 0x21, 0x08, 0xC6, 0x21,
  0xC0, 0x8C, 0x44, 0x46, 0x62, 0x22, 0x31, 0x38, 0x42, 0x31, 0x8C, 0x42,
  0x10, 0x8D, 0xE0, 0x18, 0xA6, 0x93, 0x84, 0xFF, 0xF0, 0xCC, 0x7F, 0x3C,
  0xE3, 0x8E, 0x2F, 0x80, 0x41, 0x07, 0xF3, 0xCE, 0x38, 0xF2, 0xF8, 0x7F,
  0x1C, 0x20, 0x87, 0x2F, 0x00, 0x06, 0x09, 0xF6, 0x6C, 0xD1, 0xA3, 0x44,
  0xF8, 0x7B, 0x3C, 0x7F, 0x82, 0x2F, 0x00, 0x07, 0x86, 0x03, 0x07, 0xE0,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x3C, 0x00, 0x7F, 0x3C, 0xE3, 0x8F,
  0xE6, 0x82, 0xF0, 0x41, 0x07, 0xF3, 0xCE, 0x38, 0xE2, 0x88, 0x0C, 0x10,
  0x01, 0xC0, 0x81, 0x06, 0x0C, 0x19, 0xFC, 0x06, 0x08, 0x01, 0xE0, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x67, 0x80, 0x40, 0x81, 0x1E, 0x4D, 0x9E, 0x24,
  0x4C, 0x8C, 0xF0, 0xC2, 0x08, 0x20, 0x86, 0x18, 0x3C, 0x7E, 0x95, 0x2A,
  0x95, 0x3A, 0xF5, 0x80, 0x7F, 0x3C, 0xE3, 0x8E, 0x28, 0x80, 0x7B, 0x3C,
  0xE3, 0x8E, 0x2F, 0x00, 0x3E, 0xCD, 0x9A, 0x34, 0x6C, 0x9F, 0x60, 0xC0,
  0x77, 0x3C, 0xE3, 0x8E, 0x2F, 0x82, 0x18, 0x7D, 0x1C, 0x70, 0xC2, 0x08,
  0x00, 0x7F, 0x1C, 0x1E, 0x0E, 0x2F, 0x80, 0x30, 0xCF, 0xC8, 0x20, 0x86,
  0x18, 0x38, 0x47, 0x1C, 0xE3, 0x8F, 0x2F, 0x00, 0xC7, 0x99, 0x22, 0x45,
  0x0A, 0x18, 0x00, 0x93, 0x6A, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x67, 0x34,
  0x18, 0x18, 0x38, 0x6C, 0xC6, 0x47, 0x1C, 0xE3, 0x8F, 0xE0, 0x82, 0xF0,
  0x7C, 0x31, 0x8C, 0x63, 0x0F, 0x80, 0x06, 0x18, 0x60, 0xC1, 0x82, 0x38,
  0x08, 0x10, 0x60, 0xC1, 0xC0, 0x33, 0x22, 0x26, 0x66, 0x44, 0x4C, 0x30,
  0x30, 0x20, 0xC1, 0x83, 0x03, 0x88, 0x10, 0x60, 0xC7, 0x00, 0x66, 0xD9,
  0x80,
};

const GFXglyph JetBrainsMono_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 3, 8, 2, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 8, 13, 8, 0, -11 },
  { 30, 10, 10, 8, -1, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 2, 3, 8, 4, -9 },
  { 54, 5, 13, 8, 2, -11 },
  { 63, 5, 13, 8, 1, -11 },
  { 72, 7, 7, 8, 1, -8 },
  { 79, 6, 6, 8, 1, -7 },
  { 84, 4, 4, 8, 1, -2 },
  { 86, 4, 1, 8, 2, -5 },
  { 87, 3, 2, 8, 2, -2 },
  { 88, 8, 12, 8, 0, -11 },
  { 100, 6, 10, 8, 1, -10 },
  { 108, 6, 9, 8, 1, -9 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 6, 9, 8, 1, -9 },
  { 130, 6, 9, 8, 1, -9 },
  { 137, 6, 9, 8, 1, -9 },
  { 144, 6, 9, 8, 1, -9 },
  { 151, 7, 9, 8, 1, -9 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 7, 10, 8, 1, -10 },
  { 176, 4, 7, 8, 2, -7 },
  { 180, 5, 9, 8, 1, -7 },
  { 186, 6, 7, 8, 1, -8 },
  { 192, 6, 5, 8, 1, -7 },
  { 196, 6, 7, 8, 1, -8 },
  { 202, 5, 9, 8, 2, -9 },
  { 208, 8, 12, 8, 0, -10 },
  { 220, 7, 9, 8, 0, -9 },
  { 228, 7, 9, 8, 1, -9 },
  { 236, 7, 10, 8, 1, -10 },
  { 245, 7, 9, 8, 0, -9 },
  { 253, 7, 9, 8, 1, -9 },
  { 261, 7, 10, 8, 1, -10 },
  { 270, 7, 10, 8, 1, -10 },
  { 279, 7, 9, 8, 1, -9 },
  { 287, 6, 9, 8, 1, -9 },
  { 294, 7, 9, 8, 0, -9 },
  { 302, 7, 9, 8, 1, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 8, 9, 8, 0, -9 },
  { 326, 8, 9, 8, 0, -9 },
  { 335, 6, 10, 8, 1, -10 },
  { 343, 7, 9, 8, 1, -9 },
  { 351, 6, 12, 8, 1, -10 },
  { 360, 7, 9, 8, 1, -9 },
  { 368, 8, 10, 8, 0, -10 },
  { 378, 7, 10, 8, 1, -10 },
  { 387, 7, 9, 8, 1, -9 },
  { 395, 7, 9, 8, 1, -9 },
  { 403, 7, 9, 8, 1, -9 },
  { 411, 8, 9, 8, 0, -9 },
  { 420, 7, 9, 8, 1, -9 },
  { 428, 8, 9, 8, 0, -9 },
  { 437, 5, 12, 8, 2, -11 },
  { 445, 4, 12, 8, 2, -11 },
  { 451, 5, 12, 8, 1, -11 },
  { 459, 6, 5, 8, 1, -9 },
  { 463, 6, 2, 8, 0, 0 },
  { 465, 3, 2, 8, 3, -10 },
  { 466, 6, 7, 8, 1, -7 },
  { 472, 6, 9, 8, 1, -9 },
  { 479, 6, 7, 8, 1, -7 },
  { 485, 7, 9, 8, 1, -9 },
  { 493, 6, 7, 8, 1, -7 },
  { 499, 9, 11, 8, -1, -9 },
  { 512, 6, 9, 8, 1, -7 },
  { 519, 6, 9, 8, 1, -9 },
  { 526, 7, 10, 8, 0, -10 },
  { 535, 7, 12, 8, 0, -10 },
  { 546, 7, 9, 8, 1, -9 },
  { 554, 6, 9, 8, 1, -9 },
  { 561, 7, 7, 8, 0, -7 },
  { 568, 6, 7, 8, 1, -7 },
  { 574, 6, 7, 8, 1, -7 },
  { 580, 7, 9, 8, 0, -7 },
  { 588, 6, 9, 8, 1, -7 },
  { 595, 6, 7, 8, 1, -7 },
  { 601, 6, 7, 8, 1, -7 },
  { 607, 6, 9, 8, 1, -9 },
  { 614, 6, 7, 8, 1, -7 },
  { 620, 7, 7, 8, 1, -7 },
  { 627, 7, 7, 8, 1, -7 },
  { 634, 8, 7, 8, 0, -7 },
  { 641, 6, 9, 8, 1, -7 },
  { 648, 6, 7, 8, 1, -7 },
  { 654, 7, 12, 8, 1, -11 },
  { 665, 4, 12, 8, 2, -11 },
  { 671, 7, 12, 8, 0, -11 },
  { 682, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_MEDIUMITALIC13PT7B_H_
