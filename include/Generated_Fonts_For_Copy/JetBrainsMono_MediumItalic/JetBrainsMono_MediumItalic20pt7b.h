#ifndef _JETBRAINSMONO_MEDIUMITALIC20PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x19, 0x8C, 0x63, 0x18, 0x00, 0x73, 0x80, 0x67,
  0x67, 0x66, 0x66, 0x66, 0xC6, 0x02, 0x30, 0x62, 0x06, 0x20, 0x46, 0x3F,
  0xF3, 0xFF, 0x08, 0xC1, 0x88, 0x19, 0x81, 0x18, 0xFF, 0xE3, 0x30, 0x23,
  0x06, 0x20, 0x66, 0x00, 0x03, 0x00, 0x40, 0x1C, 0x0F, 0xE3, 0xAC, 0x6D,
  0x9D, 0x03, 0xA0, 0x3C, 0x07, 0xE0, 0x1E, 0x06, 0xC0, 0x9D, 0x93, 0x32,
  0x67, 0xF8, 0x7E, 0x03, 0x00, 0x60, 0x08, 0x00, 0x0E, 0x04, 0x7C, 0x23,
  0x31, 0x8C, 0xCC, 0x33, 0x60, 0xDB, 0x01, 0xD8, 0x00, 0x40, 0x02, 0x60,
  0x1F, 0xC0, 0xD9, 0x06, 0x44, 0x31, 0x11, 0x86, 0xCC, 0x1E, 0x00, 0x07,
  0x80, 0xFC, 0x18, 0xC1, 0x8C, 0x18, 0x01, 0x80, 0x0C, 0x03, 0xC1, 0x66,
  0x66, 0x6C, 0x63, 0xC6, 0x38, 0x63, 0x87, 0xFC, 0x7C, 0xE0, 0xFF, 0xF0,
  0x01, 0x83, 0x83, 0x83, 0x83, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x1E, 0x07, 0x00, 0x80, 0x10,
  0x1C, 0x0E, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06,
  0x06, 0x0E, 0x0C, 0x38, 0xF0, 0xE0, 0x80, 0x06, 0x00, 0xC2, 0x18, 0xF2,
  0x7F, 0xFC, 0x18, 0x07, 0x81, 0xB8, 0x73, 0x0C, 0x70, 0x06, 0x01, 0x80,
  0xE1, 0xFF, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x39, 0x9C, 0xCE,
  0x60, 0xFF, 0xF8, 0x77, 0x70, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x03,
  0xF8, 0xE3, 0x18, 0x66, 0x0C, 0xC1, 0x99, 0x33, 0x76, 0x6C, 0xDC, 0x3B,
  0x06, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x07, 0x07, 0x8E, 0xC6, 0x64,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC7, 0xFF, 0xFE,
  0x07, 0x07, 0xF3, 0x9D, 0xC3, 0x60, 0xC0, 0x30, 0x18, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x3F, 0xEF, 0xF8, 0x3F, 0xCF, 0xF0, 0x0C, 0x0E,
  0x07, 0x03, 0x00, 0xF0, 0x3E, 0x01, 0x80, 0x60, 0x1B, 0x06, 0xC3, 0xBF,
  0xC7, 0xE0, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x84, 0xC6,
  0x61, 0xB8, 0x6F, 0xFB, 0xFE, 0x03, 0x80, 0xE0, 0x30, 0x3F, 0xCF, 0xF3,
  0x00, 0xC0, 0x30, 0x0D, 0x86, 0xF9, 0xC6, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0xE3, 0x9F, 0xC7, 0xE0, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x71, 0xFE, 0x61, 0xF0, 0x3C, 0x1F, 0x06, 0xE3, 0x9F, 0xC3, 0xE0, 0x7F,
  0xDF, 0xF6, 0x0F, 0x06, 0xC1, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x1C, 0x06, 0x00, 0x0F, 0x07, 0xF3, 0x8C, 0xC3, 0x30,
  0xCC, 0x73, 0xB8, 0x78, 0x3B, 0x98, 0x6C, 0x1B, 0x06, 0xE1, 0xBF, 0xC7,
  0xE0, 0x0E, 0x0F, 0xE7, 0x1B, 0x87, 0xC1, 0xF0, 0x6C, 0x1B, 0x9E, 0x7F,
  0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x00, 0x38, 0xE3, 0x80, 0x00,
  0x00, 0x00, 0x71, 0xC7, 0x00, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x61, 0xC3, 0x06, 0x18, 0x00, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x04,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0x40, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xEF, 0xF8, 0x20, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30,
  0x78, 0x78, 0x78, 0x38, 0x08, 0x00, 0x78, 0x7E, 0x0F, 0x07, 0x03, 0x07,
  0x0E, 0x7C, 0x78, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xFE,
  0x18, 0x33, 0x03, 0x30, 0x36, 0x1B, 0x63, 0xF6, 0x63, 0x66, 0x26, 0x66,
  0x44, 0x6C, 0xC6, 0xC7, 0xEC, 0x76, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x61, 0xD8, 0x63,
  0x18, 0xCC, 0x33, 0xFD, 0xC3, 0x60, 0xD8, 0x3C, 0x0C, 0x3F, 0x07, 0xF8,
  0xC7, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0xE3, 0xF8, 0x63, 0x8C, 0x39, 0x87,
  0x60, 0xCC, 0x39, 0xFE, 0x3F, 0x80, 0x07, 0x03, 0xF8, 0xE3, 0x18, 0x67,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0xCE, 0x38,
  0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0xE3, 0x1C, 0xC3, 0x70, 0xD8, 0x36, 0x0D,
  0x83, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xC3, 0xBF, 0xCF, 0xC0, 0x3F, 0xE7,
  0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x13, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x07, 0x03, 0xF8, 0xE3, 0x18, 0x67, 0x00, 0xC0,
  0x18, 0x03, 0x3E, 0x67, 0xCC, 0x3B, 0x86, 0x60, 0xCE, 0x38, 0xFE, 0x0F,
  0x80, 0x30, 0x66, 0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC1, 0x9F, 0xF3, 0xFE,
  0x61, 0x8C, 0x31, 0x86, 0x70, 0xCC, 0x19, 0x83, 0x30, 0xE0, 0x3F, 0xCF,
  0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x3F, 0xCF, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x70, 0xE6, 0x18, 0xFF,
  0x0F, 0x80, 0x30, 0x73, 0x0E, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x30, 0x7F,
  0x07, 0xE0, 0x66, 0x06, 0x70, 0x63, 0x0E, 0x30, 0xC3, 0x8C, 0x18, 0xC1,
  0x80, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFE, 0x18, 0x71, 0xC7, 0x3C, 0xF3, 0xCF,
  0x3C, 0xA3, 0x5E, 0x35, 0x63, 0x76, 0x66, 0x66, 0x06, 0x60, 0xE6, 0x0C,
  0x60, 0xC6, 0x0C, 0xE0, 0xC0, 0x38, 0x67, 0x0C, 0xE3, 0x14, 0x66, 0xCC,
  0xD9, 0x9B, 0x33, 0x66, 0x64, 0xCC, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x87,
  0x30, 0xE0, 0x07, 0x07, 0xF3, 0x8C, 0xC3, 0x70, 0xD8, 0x36, 0x0D, 0x83,
  0x61, 0xD8, 0x6E, 0x1B, 0x06, 0xE3, 0x9F, 0xC3, 0xE0, 0x3F, 0x07, 0xF8,
  0xC3, 0x98, 0x37, 0x06, 0xC1, 0xD8, 0x33, 0xFE, 0x7F, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x07, 0x03, 0xF8, 0xE3, 0x18, 0x66,
  0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xDC, 0x3B, 0x06, 0x60, 0xCE, 0x38,
  0xFE, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x3F, 0x07, 0xF8,
  0xC7, 0x18, 0x77, 0x0E, 0xC1, 0x98, 0x73, 0xFC, 0x7F, 0x0C, 0xC1, 0x9C,
  0x71, 0x8C, 0x31, 0x87, 0x30, 0x60, 0x07, 0x03, 0xF8, 0xE3, 0x18, 0x67,
  0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x07, 0x80, 0x30, 0x07, 0x60, 0xCC, 0x19,
  0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0x30, 0x66,
  0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x33,
  0x86, 0x70, 0xCE, 0x38, 0xFE, 0x1F, 0x80, 0xC0, 0xFC, 0x1B, 0x83, 0x30,
  0xC6, 0x18, 0xC6, 0x18, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x06,
  0xC0, 0x70, 0x0E, 0x00, 0x66, 0x36, 0x63, 0x66, 0x26, 0x66, 0x4E, 0x64,
  0xA6, 0x4A, 0x45, 0xAC, 0xD2, 0xCD, 0x2C, 0xD2, 0x8F, 0x38, 0xE3, 0x8E,
  0x30, 0xE3, 0x00, 0x38, 0x38, 0xC3, 0x86, 0x18, 0x19, 0x80, 0xDC, 0x07,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0xE0, 0x73, 0x03, 0x18,
  0x30, 0x63, 0x83, 0x00, 0xC0, 0x7C, 0x19, 0x87, 0x30, 0xC6, 0x30, 0x6E,
  0x0D, 0x81, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x00, 0x3F, 0xE7, 0xF8, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70,
  0x1C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0x3F,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0xF8, 0xF8, 0xC3, 0x06, 0x18, 0x61, 0x87, 0x0C, 0x30,
  0xC3, 0x06, 0x18, 0x61, 0x87, 0x0C, 0x30, 0xC0, 0x1F, 0x3F, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0xF8, 0xF8, 0x0E, 0x07, 0x07, 0x82, 0x43, 0x33, 0x19, 0x8D, 0x83,
  0xFF, 0xFF, 0xF0, 0xC6, 0x30, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0x61, 0x98,
  0x6E, 0x1B, 0x06, 0xE3, 0x9F, 0x67, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x7F, 0x9B, 0xE7, 0x1D, 0x83, 0x61, 0xD8, 0x66, 0x1B, 0x86, 0xE3, 0xBF,
  0xCD, 0xE0, 0x1F, 0x8F, 0xE7, 0x1D, 0x83, 0x60, 0x18, 0x0E, 0x03, 0x06,
  0xE3, 0x9F, 0xC3, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x61, 0xEC, 0x7F,
  0x9C, 0x73, 0x0E, 0x61, 0x8C, 0x33, 0x86, 0x60, 0xCE, 0x38, 0xFB, 0x1F,
  0xE0, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0x61, 0xDF, 0xEE, 0x03, 0x00, 0xE1,
  0x9F, 0xC3, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x7F, 0xC1, 0xFF, 0x08, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x86, 0x7F,
  0x9F, 0x60, 0x38, 0x0C, 0x07, 0x1F, 0x87, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x7F, 0x9B, 0xE7, 0x1D, 0x87, 0x61, 0xD8, 0x66, 0x1B, 0x86, 0xC1,
  0xB0, 0x6C, 0x38, 0x03, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFE, 0x00,
  0x40, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x01, 0xC3,
  0xF0, 0x78, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x0E, 0xE3, 0x98,
  0xE3, 0x18, 0x7E, 0x0F, 0xC1, 0x98, 0x73, 0x8C, 0x31, 0x87, 0x30, 0x60,
  0xFC, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xFC, 0x7C, 0x3E, 0xE6, 0xEC, 0xC9, 0xB3, 0x36, 0x66,
  0xCC, 0xD9, 0x9B, 0x22, 0x64, 0xC8, 0x9B, 0x33, 0x00, 0x7F, 0x9B, 0xE7,
  0x1D, 0x87, 0x61, 0xD8, 0x66, 0x1B, 0x86, 0xC1, 0xB0, 0x6C, 0x38, 0x1F,
  0x0F, 0xE7, 0x1D, 0x83, 0x61, 0xD8, 0x6E, 0x1B, 0x06, 0xE3, 0x9F, 0xC3,
  0xE0, 0x3F, 0xC6, 0xF8, 0xE3, 0x98, 0x33, 0x0E, 0x61, 0x8C, 0x33, 0x86,
  0x71, 0xCF, 0xF1, 0xBC, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x00, 0x1E, 0xCF,
  0xF7, 0x1D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x06, 0xE3, 0x9F, 0x67, 0xF8,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x37, 0x8F, 0xF3, 0x0D, 0xC3, 0x60, 0xD8,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x00, 0x1F, 0x8F, 0xF6, 0x0D, 0x80,
  0x78, 0x0F, 0xC0, 0x38, 0x06, 0xC1, 0xBF, 0xC7, 0xE0, 0x1C, 0x0C, 0x06,
  0x1F, 0xFF, 0xF9, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF1,
  0xF0, 0x70, 0xD8, 0x36, 0x0D, 0x83, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xE3,
  0x9F, 0xC3, 0xE0, 0xC1, 0xF0, 0x6C, 0x3B, 0x8C, 0x63, 0x19, 0x86, 0x61,
  0xB0, 0x6C, 0x1E, 0x03, 0x80, 0xC6, 0x79, 0xCF, 0x29, 0xE5, 0x6D, 0xAD,
  0xA5, 0xB4, 0xA6, 0x9C, 0xE3, 0x9C, 0x63, 0x8C, 0x00, 0x38, 0x71, 0x8C,
  0x1D, 0xC0, 0xD8, 0x0F, 0x00, 0x60, 0x0F, 0x01, 0xB0, 0x39, 0x87, 0x18,
  0xE0, 0xC0, 0x70, 0xD8, 0x36, 0x0D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x8E,
  0x7F, 0x9F, 0x60, 0x30, 0x0C, 0x07, 0x1F, 0x87, 0x80, 0x3F, 0xDF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xEF, 0xF8, 0x00,
  0xC0, 0xF0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x3E, 0x0F,
  0x80, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x07, 0x80, 0xE0, 0x19,
  0xCC, 0x63, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x30, 0x1C,
  0x03, 0xC0, 0x1C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x7C, 0x1F, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0xDF, 0x3C, 0xFF, 0x1E,
};

const GFXglyph JetBrainsMono_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 8, 6, 12, 3, -15 },
  { 17, 12, 15, 12, 0, -15 },
  { 40, 11, 20, 12, 1, -17 },
  { 68, 14, 15, 12, -1, -15 },
  { 95, 12, 15, 12, 0, -15 },
  { 118, 2, 6, 12, 6, -15 },
  { 120, 9, 20, 12, 3, -17 },
  { 143, 8, 20, 12, 1, -17 },
  { 163, 11, 10, 12, 1, -12 },
  { 177, 10, 9, 12, 1, -11 },
  { 189, 5, 6, 12, 2, -3 },
  { 193, 7, 2, 12, 3, -8 },
  { 195, 4, 3, 12, 3, -3 },
  { 197, 12, 19, 12, 0, -17 },
  { 226, 11, 15, 12, 1, -15 },
  { 247, 9, 15, 12, 1, -15 },
  { 264, 10, 15, 12, 1, -15 },
  { 283, 10, 15, 12, 1, -15 },
  { 302, 10, 15, 12, 1, -15 },
  { 321, 10, 15, 12, 1, -15 },
  { 340, 10, 15, 12, 1, -15 },
  { 359, 10, 15, 12, 2, -15 },
  { 378, 10, 15, 12, 1, -15 },
  { 397, 10, 15, 12, 2, -15 },
  { 416, 6, 11, 12, 3, -11 },
  { 425, 7, 14, 12, 2, -11 },
  { 438, 9, 11, 12, 2, -12 },
  { 451, 10, 7, 12, 1, -10 },
  { 460, 10, 11, 12, 1, -12 },
  { 474, 8, 15, 12, 3, -15 },
  { 489, 12, 19, 12, 0, -15 },
  { 518, 10, 15, 12, 0, -15 },
  { 537, 11, 15, 12, 1, -15 },
  { 558, 11, 15, 12, 1, -15 },
  { 579, 10, 15, 12, 1, -15 },
  { 598, 11, 15, 12, 1, -15 },
  { 619, 11, 15, 12, 1, -15 },
  { 640, 11, 15, 12, 1, -15 },
  { 661, 11, 15, 12, 1, -15 },
  { 682, 10, 15, 12, 1, -15 },
  { 701, 11, 15, 12, 0, -15 },
  { 722, 12, 15, 12, 1, -15 },
  { 745, 9, 15, 12, 1, -15 },
  { 762, 12, 15, 12, 0, -15 },
  { 785, 11, 15, 12, 1, -15 },
  { 806, 10, 15, 12, 1, -15 },
  { 825, 11, 15, 12, 1, -15 },
  { 846, 11, 19, 12, 1, -15 },
  { 873, 11, 15, 12, 1, -15 },
  { 894, 11, 15, 12, 1, -15 },
  { 915, 10, 15, 12, 2, -15 },
  { 934, 11, 15, 12, 1, -15 },
  { 955, 11, 15, 12, 2, -15 },
  { 976, 12, 15, 12, 1, -15 },
  { 999, 13, 15, 12, 0, -15 },
  { 1024, 11, 15, 12, 2, -15 },
  { 1045, 11, 15, 12, 1, -15 },
  { 1066, 8, 19, 12, 3, -17 },
  { 1085, 6, 19, 12, 3, -17 },
  { 1100, 8, 19, 12, 2, -17 },
  { 1119, 9, 8, 12, 2, -15 },
  { 1128, 10, 2, 12, 0, 0 },
  { 1131, 4, 3, 12, 5, -16 },
  { 1133, 10, 11, 12, 1, -11 },
  { 1147, 10, 15, 12, 1, -15 },
  { 1166, 10, 11, 12, 1, -11 },
  { 1180, 11, 15, 12, 1, -15 },
  { 1201, 10, 11, 12, 1, -11 },
  { 1215, 14, 19, 12, -1, -15 },
  { 1249, 10, 15, 12, 1, -11 },
  { 1268, 10, 15, 12, 1, -15 },
  { 1287, 10, 16, 12, 1, -16 },
  { 1307, 11, 20, 12, 0, -16 },
  { 1335, 11, 15, 12, 1, -15 },
  { 1356, 9, 15, 12, 2, -15 },
  { 1373, 11, 11, 12, 0, -11 },
  { 1389, 10, 11, 12, 1, -11 },
  { 1403, 10, 11, 12, 1, -11 },
  { 1417, 11, 15, 12, 0, -11 },
  { 1438, 10, 15, 12, 1, -11 },
  { 1457, 10, 11, 12, 1, -11 },
  { 1471, 10, 11, 12, 1, -11 },
  { 1485, 9, 14, 12, 2, -14 },
  { 1501, 10, 11, 12, 1, -11 },
  { 1515, 10, 11, 12, 2, -11 },
  { 1529, 11, 11, 12, 1, -11 },
  { 1545, 12, 11, 12, 0, -11 },
  { 1562, 10, 15, 12, 1, -11 },
  { 1581, 10, 11, 12, 1, -11 },
  { 1595, 10, 19, 12, 2, -17 },
  { 1619, 5, 19, 12, 4, -17 },
  { 1631, 11, 19, 12, 0, -17 },
  { 1658, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_MEDIUMITALIC20PT7B_H_
