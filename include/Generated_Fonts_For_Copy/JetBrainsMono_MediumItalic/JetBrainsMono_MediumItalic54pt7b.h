#ifndef _JETBRAINSMONO_MEDIUMITALIC54PT7B_H_
#define _JETBRAINSMONO_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xEE, 0xFF, 0x01, 0xFC, 0x71, 0xFC,
  0x0F, 0xC7, 0x8F, 0xE0, 0xFC, 0x3C, 0x3F, 0x07, 0xE1, 0xC1, 0xF8, 0x3F,
  0x0E, 0x0F, 0xC1, 0xF0, 0x70, 0x00, 0x1F, 0xC3, 0x80, 0x00, 0xFE, 0x3C,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F, 0xCE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xE7, 0xF8, 0x00, 0x07, 0x1F, 0xC0, 0x00, 0x78, 0x7E,
  0x00, 0x03, 0xC3, 0xF0, 0x00, 0x1C, 0x1F, 0x80, 0x00, 0xE0, 0xFC, 0x3F,
  0x07, 0x07, 0xE1, 0xF8, 0x38, 0x3F, 0x0F, 0xC3, 0xC3, 0xF0, 0x7F, 0x1E,
  0x3F, 0x83, 0xFC, 0xF3, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0xFF,
  0x80, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x7C,
  0x01, 0xF1, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x3C, 0x07,
  0x80, 0xF8, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x1E, 0x00,
  0x1F, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x3C,
  0x3E, 0x00, 0x07, 0x80, 0xF1, 0xF0, 0x00, 0x1F, 0x07, 0xCF, 0x80, 0x00,
  0x7F, 0xFE, 0x3C, 0x00, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x03, 0xFF, 0x8F,
  0x00, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xF9, 0xFF, 0x80, 0x00,
  0x07, 0xCF, 0xFF, 0x00, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x01, 0xF1, 0xF0,
  0xF8, 0x00, 0x07, 0x8F, 0x83, 0xE0, 0x00, 0x3C, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x07, 0x81, 0xF0, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFE,
  0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x7E,
  0x03, 0xF3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x07, 0xE3,
  0xF0, 0xF8, 0x1F, 0x9F, 0x87, 0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0xFF, 0xE0,
  0x7E, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x1F,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xFC, 0x07, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0x80, 0xFF, 0xFE,
  0x3F, 0x01, 0xFF, 0xF0, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x01, 0xF0, 0x02, 0x38, 0x0F, 0x80,
  0xF3, 0xF8, 0x3C, 0x3F, 0x9F, 0xE1, 0xC7, 0xFD, 0xFF, 0xCE, 0x7F, 0xEF,
  0xFF, 0x6F, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFC, 0x0F, 0x87,
  0xF8, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x3F, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0xF0, 0x7E, 0x3F, 0x1F,
  0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x3F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC7, 0xE0, 0x60, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xFE, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xBF, 0x00, 0x7F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xC0, 0xF8,
  0x01, 0xE0, 0x7E, 0x00, 0x60, 0x1F, 0x80, 0x10, 0x07, 0xE0, 0x08, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x9F, 0xFC, 0x01, 0xFB, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x82, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x9F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x03,
  0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xEF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x81,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0x80, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0xFE, 0x7C, 0x1F, 0x01, 0xFF, 0xBE,
  0x1F, 0x01, 0xFF, 0xEF, 0x0F, 0x80, 0xFE, 0xFF, 0x87, 0xC0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x3E, 0x01,
  0xF0, 0xF8, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x7C, 0x3E, 0x07, 0xC0,
  0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x3E,
  0x03, 0xF0, 0xF8, 0x1F, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x07,
  0xFF, 0xFC, 0x1F, 0x01, 0xFF, 0xDE, 0x1F, 0x00, 0xFF, 0xDF, 0x0F, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00,
  0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x83, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xFC, 0x3F, 0x07, 0xFF,
  0xC3, 0xF0, 0x7F, 0xFC, 0x3F, 0x07, 0xFF, 0xC3, 0xE0, 0xFF, 0xFC, 0x7E,
  0x0F, 0xFF, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xDE, 0x07, 0xFC, 0x03, 0xDE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xDE,
  0x07, 0xBC, 0x07, 0xDE, 0x0F, 0xBC, 0x07, 0xDE, 0x0F, 0x3C, 0x07, 0x9E,
  0x1F, 0x7C, 0x07, 0x9E, 0x1E, 0x7C, 0x0F, 0x9E, 0x3E, 0x7C, 0x0F, 0x9F,
  0x3C, 0x7C, 0x0F, 0x8F, 0x3C, 0xF8, 0x0F, 0x8F, 0x78, 0xF8, 0x0F, 0x8F,
  0x78, 0xF8, 0x0F, 0x8F, 0xF0, 0xF8, 0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x8F,
  0xF1, 0xF8, 0x1F, 0x87, 0xE1, 0xF0, 0x1F, 0x07, 0xE1, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xF0,
  0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0x3E, 0x07, 0xFC, 0x00,
  0xF8, 0x1F, 0xF8, 0x03, 0xE0, 0x7F, 0xE0, 0x1F, 0x81, 0xFF, 0x80, 0x7E,
  0x07, 0xFE, 0x01, 0xF8, 0x1F, 0x78, 0x07, 0xC0, 0x7D, 0xF0, 0x1F, 0x03,
  0xF7, 0xC0, 0x7C, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF8,
  0xF0, 0x3F, 0x03, 0xE3, 0xE0, 0xF8, 0x0F, 0x8F, 0x83, 0xE0, 0x7E, 0x3E,
  0x0F, 0x81, 0xF8, 0xF8, 0x7E, 0x07, 0xE1, 0xE1, 0xF8, 0x1F, 0x07, 0xC7,
  0xE0, 0x7C, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x7C, 0x0F, 0xC1, 0xF1, 0xF0,
  0x3F, 0x03, 0xC7, 0xC0, 0xFC, 0x0F, 0xBF, 0x03, 0xE0, 0x3E, 0xFC, 0x0F,
  0x80, 0xFB, 0xF0, 0x3E, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xBE, 0x07, 0xE0,
  0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x81, 0xF0, 0x07,
  0xFE, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0xFF,
  0x03, 0xF0, 0x03, 0xFC, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x01, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F,
  0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x7E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x3E,
  0x03, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x3E, 0x3E, 0x07, 0xF0, 0x3E, 0x3E,
  0x07, 0xF0, 0x3E, 0x3E, 0x07, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E,
  0x0F, 0xF0, 0x7C, 0x3E, 0x0E, 0xE0, 0x7C, 0x3C, 0x0E, 0xE0, 0x78, 0x7C,
  0x1E, 0xE0, 0xF8, 0x7C, 0x1C, 0xE0, 0xF8, 0x7C, 0x1C, 0xE0, 0xF8, 0x7C,
  0x3C, 0xE0, 0xF0, 0x7C, 0x3C, 0xE1, 0xF0, 0x7C, 0x38, 0xE1, 0xF0, 0x7C,
  0x38, 0xE1, 0xF0, 0x7C, 0x78, 0xE3, 0xE0, 0x7C, 0x78, 0xE3, 0xE0, 0x7C,
  0x70, 0xE3, 0xE0, 0x7C, 0x70, 0xE3, 0xC0, 0x7C, 0xF0, 0xE7, 0xC0, 0x7C,
  0xE1, 0xE7, 0xC0, 0x7C, 0xE1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7, 0x80, 0x79,
  0xE1, 0xEF, 0x80, 0x79, 0xC1, 0xEF, 0x80, 0x79, 0xC1, 0xEF, 0x80, 0x7B,
  0xC1, 0xEF, 0x00, 0xFB, 0x81, 0xDF, 0x00, 0xFB, 0x81, 0xDF, 0x00, 0xFF,
  0x81, 0xDF, 0x00, 0xFF, 0x81, 0xDE, 0x00, 0xFF, 0x01, 0xDE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7D, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xFC,
  0xFC, 0x0F, 0xFF, 0xDF, 0x83, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0x7E, 0x1F,
  0xE0, 0x6F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0xE7, 0xE0, 0x1F, 0xF0, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x1F, 0xE0, 0x07, 0xC7, 0xFF, 0x00, 0x7C, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7C, 0xFF, 0xF8,
  0x0F, 0xCF, 0xFF, 0x00, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xF9, 0xF8,
  0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0x7E, 0x07, 0xFF, 0xFB, 0xF0, 0x3F,
  0xC0, 0xDF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF,
  0x3F, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFD,
  0xFF, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3E, 0x00, 0x0F, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xFC, 0xFC, 0x0F, 0xFF, 0xDF, 0x83,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0x7E, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF,
  0xBE, 0x03, 0xFF, 0xEF, 0xC0, 0x3F, 0xF9, 0xF8, 0x03, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x3F, 0xC0, 0x1F, 0x9F, 0xFC, 0x03, 0xE7, 0xFF, 0xC0, 0xFD, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0x8F, 0x83, 0xE0, 0x3E,
  0x7F, 0x1F, 0xE0, 0xFB, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xC7,
  0xF1, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0xF8,
  0x3E, 0x1F, 0x03, 0xC0, 0xF8, 0x7C, 0x0F, 0x03, 0xE1, 0xF0, 0x3C, 0x0F,
  0x87, 0xC0, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xF8, 0xFC, 0x1F, 0x07, 0xC3,
  0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8,
  0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x3F, 0x1F, 0x83, 0xE0, 0xFC, 0x7E, 0x0F,
  0x83, 0xE1, 0xF0, 0x3C, 0x0F, 0x87, 0xC0, 0xF0, 0x3E, 0x1F, 0x03, 0xC0,
  0xF8, 0x7C, 0x0F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0x7C,
  0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0xC3, 0xE0, 0x78, 0x1F, 0x00,
  0x07, 0xE1, 0xFE, 0x00, 0xF8, 0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x07, 0xEF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0x7F, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF0, 0xFF, 0x00, 0x1F, 0x1F, 0xFC, 0x01, 0xF9, 0xFF, 0xF0, 0x0F, 0xDF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF,
  0x80, 0x7C, 0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0x80, 0x3F, 0x0F, 0xF8, 0x01,
  0xF8, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x87, 0xE0, 0x3F, 0xFC, 0xFC, 0x0F, 0xFF, 0xDF, 0x83, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0x7E, 0x1F, 0xC0, 0x6F, 0x87, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0x01, 0xBE,
  0x0F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xBF, 0x01, 0xFF,
  0xE7, 0xE0, 0x1F, 0xF0, 0xFC, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xC1, 0xFE, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0xCF,
  0xFF, 0x80, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0xE0, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07,
  0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x1F, 0x7C,
  0x1F, 0xC0, 0xFB, 0xE0, 0xEE, 0x07, 0x9F, 0x07, 0x70, 0x7C, 0xF8, 0x7B,
  0x83, 0xE7, 0x83, 0x9C, 0x1E, 0x3C, 0x1C, 0xE1, 0xF1, 0xE1, 0xE7, 0x0F,
  0x8F, 0x0E, 0x38, 0x78, 0x78, 0x71, 0xC7, 0xC3, 0xC7, 0x8E, 0x3E, 0x1E,
  0x38, 0x71, 0xE0, 0xF1, 0xC3, 0x8F, 0x07, 0x8E, 0x1C, 0xF8, 0x3C, 0xF0,
  0xE7, 0x81, 0xE7, 0x07, 0x3C, 0x0F, 0x38, 0x3B, 0xE0, 0x7B, 0xC1, 0xDE,
  0x03, 0xDC, 0x0E, 0xF0, 0x1E, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFF, 0xFD, 0xF0, 0x3F, 0xFF, 0xBE, 0x03, 0xFF, 0xEF, 0xC0, 0x3F, 0xF1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0x1F, 0xFE, 0x03, 0xE3, 0xFF, 0xE0, 0x3E,
  0x7F, 0xFF, 0x03, 0xE7, 0xE3, 0xF8, 0x3E, 0x7C, 0x1F, 0x87, 0xEF, 0xC0,
  0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xF8, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 20, 16, 32, 9, -39 },
  { 105, 32, 39, 32, 1, -39 },
  { 261, 29, 55, 32, 2, -47 },
  { 461, 38, 40, 32, -2, -40 },
  { 651, 30, 41, 32, 1, -40 },
  { 805, 8, 16, 32, 15, -39 },
  { 821, 23, 53, 32, 8, -46 },
  { 974, 22, 53, 32, 3, -46 },
  { 1120, 29, 28, 32, 3, -33 },
  { 1222, 27, 26, 32, 3, -31 },
  { 1310, 15, 17, 32, 5, -8 },
  { 1342, 19, 5, 32, 7, -20 },
  { 1354, 11, 10, 32, 9, -9 },
  { 1368, 33, 51, 32, 0, -45 },
  { 1579, 28, 41, 32, 3, -40 },
  { 1723, 26, 39, 32, 2, -39 },
  { 1850, 29, 40, 32, 2, -40 },
  { 1995, 29, 40, 32, 2, -39 },
  { 2140, 27, 39, 32, 3, -39 },
  { 2272, 28, 40, 32, 3, -39 },
  { 2412, 27, 40, 32, 2, -39 },
  { 2547, 27, 39, 32, 6, -39 },
  { 2679, 29, 41, 32, 2, -40 },
  { 2828, 27, 40, 32, 5, -40 },
  { 2963, 14, 31, 32, 9, -30 },
  { 3018, 18, 39, 32, 5, -30 },
  { 3106, 27, 29, 32, 4, -32 },
  { 3204, 26, 18, 32, 4, -27 },
  { 3263, 27, 29, 32, 2, -32 },
  { 3361, 23, 39, 32, 7, -39 },
  { 3474, 33, 50, 32, 0, -40 },
  { 3681, 28, 39, 32, 0, -39 },
  { 3818, 29, 39, 32, 2, -39 },
  { 3960, 28, 41, 32, 3, -40 },
  { 4104, 29, 39, 32, 2, -39 },
  { 4246, 29, 39, 32, 3, -39 },
  { 4388, 30, 39, 32, 2, -39 },
  { 4535, 28, 41, 32, 3, -40 },
  { 4679, 30, 39, 32, 2, -39 },
  { 4826, 28, 39, 32, 3, -39 },
  { 4963, 30, 40, 32, 1, -39 },
  { 5113, 32, 39, 32, 2, -39 },
  { 5269, 23, 39, 32, 4, -39 },
  { 5382, 32, 39, 32, 1, -39 },
  { 5538, 30, 39, 32, 2, -39 },
  { 5685, 28, 41, 32, 3, -40 },
  { 5829, 31, 39, 32, 2, -39 },
  { 5981, 28, 50, 32, 3, -40 },
  { 6156, 30, 39, 32, 2, -39 },
  { 6303, 29, 41, 32, 2, -40 },
  { 6452, 28, 39, 32, 6, -39 },
  { 6589, 29, 40, 32, 3, -39 },
  { 6734, 28, 39, 32, 6, -39 },
  { 6871, 32, 39, 32, 3, -39 },
  { 7027, 35, 39, 32, -1, -39 },
  { 7198, 30, 39, 32, 5, -39 },
  { 7345, 29, 39, 32, 2, -39 },
  { 7487, 22, 51, 32, 7, -45 },
  { 7628, 17, 51, 32, 8, -45 },
  { 7737, 23, 51, 32, 4, -45 },
  { 7884, 24, 21, 32, 5, -39 },
  { 7947, 27, 5, 32, 0, 1 },
  { 7964, 11, 7, 32, 14, -42 },
  { 7974, 27, 31, 32, 3, -30 },
  { 8079, 28, 40, 32, 2, -39 },
  { 8219, 27, 31, 32, 3, -30 },
  { 8324, 29, 40, 32, 3, -39 },
  { 8469, 26, 31, 32, 3, -30 },
  { 8570, 37, 49, 32, -3, -39 },
  { 8797, 27, 40, 32, 3, -30 },
  { 8932, 27, 39, 32, 2, -39 },
  { 9064, 26, 42, 32, 2, -42 },
  { 9201, 28, 52, 32, 1, -42 },
  { 9383, 30, 39, 32, 2, -39 },
  { 9530, 23, 39, 32, 5, -39 },
  { 9643, 30, 30, 32, 1, -30 },
  { 9756, 27, 30, 32, 2, -30 },
  { 9858, 26, 31, 32, 3, -30 },
  { 9959, 29, 40, 32, 1, -30 },
  { 10104, 27, 40, 32, 3, -30 },
  { 10239, 28, 30, 32, 3, -30 },
  { 10344, 26, 31, 32, 3, -30 },
  { 10445, 27, 38, 32, 4, -38 },
  { 10574, 27, 31, 32, 3, -30 },
  { 10679, 27, 30, 32, 5, -30 },
  { 10781, 29, 30, 32, 4, -30 },
  { 10890, 32, 30, 32, 0, -30 },
  { 11010, 27, 40, 32, 3, -30 },
  { 11145, 28, 30, 32, 2, -30 },
  { 11250, 28, 51, 32, 5, -45 },
  { 11429, 14, 51, 32, 10, -45 },
  { 11519, 28, 51, 32, 1, -45 },
  { 11698, 28, 12, 32, 3, -25 },
};

const GFXfont JetBrainsMono_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_MediumItalic54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_MEDIUMITALIC54PT7B_H_
