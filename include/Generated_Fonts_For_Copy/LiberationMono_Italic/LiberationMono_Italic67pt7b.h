#ifndef _LIBERATIONMONO_ITALIC67PT7B_H_
#define _LIBERATIONMONO_ITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0x9F, 0xF8, 0x03,
  0xF8, 0x1E, 0x0F, 0xF0, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x1F, 0x80, 0x78,
  0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0x80, 0x30, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x1E,
  0x00, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC7, 0xFE, 0x00, 0x00, 0x0F, 0x83, 0xFC,
  0x00, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x60, 0x07, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x00, 0x3F, 0x1F, 0x80,
  0x1E, 0x00, 0xFC, 0x3F, 0x80, 0x3C, 0x01, 0xF8, 0x7F, 0x00, 0xF8, 0x07,
  0xE0, 0x7F, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xC0, 0xFF, 0x00, 0xFF,
  0x87, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xFF,
  0xE0, 0x00, 0x7C, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00,
  0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x18, 0x01, 0xFF, 0xE0,
  0x01, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0x07, 0xF3, 0xF0, 0x03, 0xE0, 0xFE,
  0x3F, 0x00, 0x3E, 0x1F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x1F, 0x80, 0x7C,
  0x3F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0x7C,
  0x1F, 0x07, 0xC0, 0x07, 0xE1, 0xF0, 0xFC, 0x00, 0x3F, 0x3E, 0x0F, 0xC0,
  0x03, 0xF7, 0xE0, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3C, 0x3F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x20, 0x1E, 0x02, 0x78, 0x1E, 0x0F, 0x7E, 0x1C,
  0x3F, 0xFF, 0x9D, 0xFF, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xCF,
  0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0x80, 0x3F, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x3C, 0x07, 0xC0, 0x1C, 0x03, 0x80, 0x08, 0x02, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE0, 0x3F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x0F, 0xE0,
  0x3F, 0x7E, 0x03, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE7, 0xE0, 0x7F,
  0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0xBF, 0x01,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF7, 0xE0,
  0x03, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0x87, 0xE0, 0x03, 0xFC, 0x07, 0xE0,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x00,
  0x00, 0xF8, 0xFF, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFE,
  0x00, 0x1F, 0x87, 0xFF, 0xE0, 0x0F, 0xC7, 0xFF, 0xF8, 0x07, 0xCF, 0xFF,
  0xFE, 0x07, 0xEF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x07,
  0xFE, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xFF,
  0xDF, 0x81, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF,
  0x07, 0xE0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x03, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x07, 0x80, 0x7F, 0x8F, 0x3C, 0x07, 0xC0, 0xFF, 0xE7, 0x9E, 0x03,
  0xC0, 0xF8, 0x73, 0xCF, 0x03, 0xE0, 0xF8, 0x1B, 0xC7, 0x81, 0xE0, 0xF8,
  0x0F, 0xE3, 0xC1, 0xF0, 0xF8, 0x07, 0xE1, 0xE0, 0xF0, 0x78, 0x03, 0xF0,
  0xF0, 0xF8, 0x78, 0x01, 0xF8, 0x78, 0x78, 0x7C, 0x00, 0xF8, 0x3C, 0x3C,
  0x3C, 0x00, 0x7C, 0x3C, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x1E, 0x1E, 0x00,
  0x3E, 0x0F, 0x0F, 0x0F, 0x00, 0x1F, 0x07, 0x8F, 0x8F, 0x80, 0x0F, 0x03,
  0xC7, 0x87, 0x80, 0x07, 0x83, 0xC3, 0xC3, 0xC0, 0x07, 0x81, 0xE1, 0xE3,
  0xE0, 0x03, 0xC0, 0xF1, 0xF1, 0xE0, 0x03, 0xE0, 0x70, 0xF0, 0xF0, 0x01,
  0xE0, 0x78, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x3C, 0x7C, 0x00, 0xF0, 0x3C,
  0x1E, 0x3E, 0x00, 0x78, 0x1E, 0x0F, 0x1F, 0x00, 0x7C, 0x0E, 0x0F, 0x8F,
  0x80, 0x7C, 0x0F, 0x07, 0xC7, 0xC0, 0x3E, 0x0F, 0x03, 0xE3, 0xE0, 0x37,
  0x07, 0x01, 0xF0, 0xF0, 0x3F, 0x87, 0x80, 0xF8, 0x7C, 0x7B, 0xC7, 0x80,
  0x7C, 0x3F, 0xF9, 0xFF, 0x80, 0x3E, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x87, 0xE0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x02, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x18, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xE0,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x9F,
  0xC0, 0x0F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x00,
  0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x03, 0xF1,
  0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xFF, 0x00,
  0x00, 0x00, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x03,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0xFC, 0x03, 0xE7, 0xE0, 0x7C, 0xF8,
  0x03, 0xE7, 0xE0, 0x78, 0xF8, 0x07, 0xE3, 0xE0, 0xF8, 0xF8, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x07, 0xC3, 0xE1, 0xF1, 0xF8, 0x07, 0xC3, 0xE3, 0xE1,
  0xF8, 0x07, 0xC3, 0xE3, 0xE1, 0xF0, 0x0F, 0xC1, 0xF7, 0xC1, 0xF0, 0x0F,
  0x81, 0xF7, 0xC1, 0xF0, 0x0F, 0x81, 0xFF, 0x83, 0xF0, 0x0F, 0x81, 0xFF,
  0x03, 0xF0, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xE0,
  0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x01,
  0xF0, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0xFD,
  0xF8, 0x00, 0xFC, 0x03, 0xE3, 0xE0, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x07, 0xE1,
  0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07,
  0xE1, 0xF8, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x00, 0xFC, 0x7C, 0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x07,
  0xCF, 0xC0, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0xF8, 0x00, 0x7E, 0xFC, 0x03,
  0xE0, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x0F,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00,
  0xFF, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x38, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xDE, 0x03, 0xE0,
  0x1F, 0x81, 0xF7, 0x81, 0xF8, 0x07, 0xE0, 0x79, 0xE0, 0x7C, 0x01, 0xF8,
  0x3E, 0x78, 0x1F, 0x00, 0x7E, 0x0F, 0x1E, 0x0F, 0xC0, 0x1F, 0x87, 0xC7,
  0x83, 0xE0, 0x07, 0xE1, 0xF1, 0xE0, 0xF8, 0x01, 0xF8, 0xF8, 0x7C, 0x7E,
  0x00, 0x7C, 0x3E, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC1, 0xF3, 0xF0, 0x01, 0xF1, 0xE0, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xC1, 0xFE,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x77, 0xE0, 0xFE, 0x00, 0xF3, 0xF0,
  0x7F, 0x81, 0xF1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F,
  0xE3, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x1F, 0x83, 0xFF,
  0xC0, 0x07, 0xE3, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x7E, 0xF8,
  0x1F, 0xE0, 0x3F, 0x78, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0xFF, 0x80, 0x07, 0xE0, 0x7E, 0xE0, 0x07, 0xF0, 0x1F, 0xBE, 0x03, 0xFC,
  0x07, 0xE7, 0xFF, 0xFE, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x07,
  0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xE0, 0x7D, 0xF8,
  0x03, 0xF8, 0x01, 0xDF, 0x80, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3B,
  0xF0, 0x07, 0xF8, 0x1F, 0x3E, 0x00, 0x3F, 0xFF, 0xE7, 0xE0, 0x03, 0xFF,
  0xFC, 0x7E, 0x00, 0x0F, 0xFF, 0x87, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x04, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFC,
  0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0xE3, 0xE0, 0x1F, 0xF0, 0x3E,
  0xFC, 0x03, 0xF8, 0x03, 0xDF, 0x80, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80,
  0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x7E, 0x01, 0xFE, 0x07, 0xCF, 0xC0, 0x1F,
  0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xFC, 0x3E, 0x00, 0x1F, 0xFE, 0x0F, 0xC0,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC1, 0xFF, 0xF0, 0x07, 0xE3, 0xFF, 0xFC,
  0x03, 0xF3, 0xFF, 0xFF, 0x01, 0xF3, 0xE0, 0x7F, 0x81, 0xFB, 0xC0, 0x1F,
  0xE0, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xC3, 0xFC, 0x1F, 0xF0,
  0x0F, 0x9F, 0xFC, 0x7F, 0xF0, 0x1F, 0x7F, 0xF9, 0xFF, 0xE0, 0x3E, 0xE3,
  0xF7, 0x8F, 0xE0, 0x7F, 0x83, 0xEC, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xF8, 0x3F, 0xFE, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x7E,
  0x7F, 0xFF, 0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x1F, 0x78, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x8F,
  0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xEF, 0x81, 0xFE, 0x00,
  0x3E, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x03,
  0xF7, 0x00, 0x1F, 0xC0, 0x1F, 0xBE, 0x03, 0xFC, 0x00, 0xFC, 0xFF, 0xFF,
  0xC0, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x3F, 0x0F, 0xFF, 0x80, 0x01, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x83,
  0xF0, 0x07, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xFE, 0x7E, 0x03, 0xFE, 0x07,
  0xDF, 0x80, 0xFE, 0x00, 0x77, 0xE0, 0x7E, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xEF, 0xC0, 0x7F, 0x81, 0xF3, 0xE0,
  0x0F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFC, 0x7E, 0x00, 0x3F, 0xFE, 0x1F,
  0x80, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x7F,
  0xFE, 0x07, 0xE1, 0xFF, 0xFE, 0x07, 0xE3, 0xFF, 0xFE, 0x07, 0xE3, 0xF0,
  0x02, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x38, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xBF, 0x01, 0xFE, 0x03, 0xEF, 0xC0,
  0x7F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xF8, 0x3E,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x7C, 0x01,
  0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xFC, 0x07,
  0xE0, 0x7C, 0x07, 0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xBC, 0x07, 0xC0, 0x7C,
  0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x0F, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x3E,
  0x1F, 0x80, 0x7C, 0x3E, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x1E, 0x1F, 0x00,
  0x7C, 0x7C, 0x1E, 0x3F, 0x00, 0x7C, 0x7C, 0x1E, 0x3F, 0x00, 0x7C, 0xF8,
  0x1E, 0x3E, 0x00, 0xFC, 0xF0, 0x1E, 0x7E, 0x00, 0xFD, 0xF0, 0x1F, 0x7C,
  0x00, 0xFD, 0xE0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFB,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x17, 0xFF, 0xFF, 0xC0, 0x3D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x01, 0xFF, 0xFF, 0xE8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
};

const GFXglyph LiberationMono_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 15, 44, 40, 13, -44 },
  { 84, 25, 21, 40, 12, -49 },
  { 150, 40, 44, 40, 1, -44 },
  { 370, 39, 53, 40, 1, -48 },
  { 629, 44, 46, 40, -1, -45 },
  { 882, 36, 46, 40, 0, -45 },
  { 1089, 10, 21, 40, 20, -49 },
  { 1116, 25, 63, 40, 10, -49 },
  { 1313, 25, 63, 40, 5, -49 },
  { 1510, 24, 24, 40, 12, -49 },
  { 1582, 32, 33, 40, 4, -39 },
  { 1714, 18, 22, 40, 3, -10 },
  { 1764, 20, 5, 40, 10, -20 },
  { 1777, 9, 10, 40, 13, -10 },
  { 1789, 42, 50, 40, 0, -49 },
  { 2052, 34, 46, 40, 4, -45 },
  { 2248, 32, 44, 40, 2, -44 },
  { 2424, 37, 45, 40, 1, -45 },
  { 2633, 35, 46, 40, 3, -45 },
  { 2835, 34, 44, 40, 2, -44 },
  { 3022, 35, 45, 40, 3, -44 },
  { 3219, 33, 46, 40, 5, -45 },
  { 3409, 31, 44, 40, 9, -44 },
  { 3580, 35, 46, 40, 3, -45 },
  { 3782, 33, 46, 40, 4, -45 },
  { 3972, 14, 35, 40, 13, -35 },
  { 4034, 21, 47, 40, 6, -35 },
  { 4158, 32, 34, 40, 4, -39 },
  { 4294, 32, 22, 40, 4, -33 },
  { 4382, 32, 34, 40, 4, -39 },
  { 4518, 32, 45, 40, 6, -45 },
  { 4698, 41, 57, 40, 0, -49 },
  { 4991, 40, 44, 40, -3, -44 },
  { 5211, 36, 44, 40, 2, -44 },
  { 5409, 36, 46, 40, 4, -45 },
  { 5616, 36, 44, 40, 2, -44 },
  { 5814, 39, 44, 40, 2, -44 },
  { 6029, 38, 44, 40, 3, -44 },
  { 6238, 35, 46, 40, 4, -45 },
  { 6440, 38, 44, 40, 2, -44 },
  { 6649, 36, 44, 40, 3, -44 },
  { 6847, 32, 45, 40, 5, -44 },
  { 7027, 41, 44, 40, 2, -44 },
  { 7253, 30, 44, 40, 4, -44 },
  { 7418, 40, 44, 40, 1, -44 },
  { 7638, 38, 44, 40, 2, -44 },
  { 7847, 36, 46, 40, 3, -45 },
  { 8054, 37, 44, 40, 2, -44 },
  { 8258, 36, 58, 40, 3, -45 },
  { 8519, 38, 44, 40, 2, -44 },
  { 8728, 38, 46, 40, 1, -45 },
  { 8947, 36, 44, 40, 7, -44 },
  { 9145, 37, 45, 40, 4, -44 },
  { 9354, 40, 44, 40, 5, -44 },
  { 9574, 42, 44, 40, 3, -44 },
  { 9805, 45, 44, 40, -2, -44 },
  { 10053, 38, 44, 40, 6, -44 },
  { 10262, 42, 44, 40, -1, -44 },
  { 10493, 30, 63, 40, 7, -49 },
  { 10730, 23, 50, 40, 10, -49 },
  { 10874, 30, 63, 40, 3, -49 },
  { 11111, 31, 30, 40, 4, -44 },
  { 11228, 41, 3, 40, -5, 4 },
  { 11244, 12, 8, 40, 19, -47 },
  { 11256, 33, 37, 40, 2, -36 },
  { 11409, 34, 50, 40, 2, -49 },
  { 11622, 33, 37, 40, 4, -36 },
  { 11775, 36, 50, 40, 4, -49 },
  { 12000, 32, 37, 40, 4, -36 },
  { 12148, 35, 49, 40, 7, -49 },
  { 12363, 35, 50, 40, 3, -36 },
  { 12582, 33, 49, 40, 3, -49 },
  { 12785, 33, 49, 40, 1, -49 },
  { 12988, 35, 63, 40, -2, -49 },
  { 13264, 35, 49, 40, 4, -49 },
  { 13479, 33, 49, 40, 1, -49 },
  { 13682, 39, 36, 40, 0, -36 },
  { 13858, 33, 36, 40, 3, -36 },
  { 14007, 33, 37, 40, 4, -36 },
  { 14160, 37, 50, 40, 0, -36 },
  { 14392, 34, 50, 40, 4, -36 },
  { 14605, 32, 36, 40, 6, -36 },
  { 14749, 32, 37, 40, 4, -36 },
  { 14897, 26, 45, 40, 9, -44 },
  { 15044, 34, 36, 40, 4, -35 },
  { 15197, 35, 35, 40, 6, -35 },
  { 15351, 40, 35, 40, 3, -35 },
  { 15526, 40, 35, 40, 0, -35 },
  { 15701, 42, 49, 40, -1, -35 },
  { 15959, 36, 35, 40, 1, -35 },
  { 16117, 34, 63, 40, 7, -49 },
  { 16385, 6, 63, 40, 17, -49 },
  { 16433, 34, 63, 40, -1, -49 },
  { 16701, 34, 8, 40, 4, -26 },
};

const GFXfont LiberationMono_Italic67pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic67pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic67pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _LIBERATIONMONO_ITALIC67PT7B_H_
