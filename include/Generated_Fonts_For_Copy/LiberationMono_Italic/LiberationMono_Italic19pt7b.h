#ifndef _LIBERATIONMONO_ITALIC19PT7B_H_
#define _LIBERATIONMONO_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x64, 0x40, 0x0C, 0xC0, 0x66, 0x66, 0x66, 0x46,
  0x44, 0x44, 0x02, 0x20, 0x46, 0x04, 0x40, 0x84, 0x3F, 0xE0, 0x88, 0x10,
  0x81, 0x10, 0xFF, 0xC2, 0x20, 0x22, 0x04, 0x20, 0x44, 0x00, 0x01, 0x00,
  0x20, 0x3F, 0x0D, 0x33, 0x22, 0x64, 0x0C, 0x80, 0x78, 0x05, 0xC0, 0x88,
  0x11, 0x62, 0x2C, 0x4C, 0xCB, 0x0F, 0xC0, 0x40, 0x08, 0x00, 0x3C, 0x36,
  0x42, 0x44, 0x44, 0x48, 0x4D, 0x07, 0xA0, 0x06, 0x00, 0xDE, 0x0B, 0x21,
  0x22, 0x22, 0x24, 0x24, 0xC3, 0xC0, 0x07, 0x82, 0x31, 0x8C, 0x62, 0x1B,
  0x03, 0x83, 0x81, 0xB1, 0xC4, 0xF1, 0xAC, 0x33, 0x1C, 0x7D, 0xC0, 0xFF,
  0xA0, 0x04, 0x18, 0x61, 0x82, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81,
  0x02, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x30, 0xC0, 0x08, 0x11, 0x49,
  0xE3, 0x8D, 0x12, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x39, 0x98, 0xCC, 0x40, 0xF8, 0xFC, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x04, 0x62, 0x0D, 0x83, 0x60,
  0xD3, 0x3C, 0xCB, 0x02, 0xC1, 0xB0, 0x6C, 0x31, 0x88, 0x3C, 0x00, 0x01,
  0x81, 0xC3, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x7F, 0xC0, 0x07, 0x81, 0x08, 0x61, 0x98, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x07, 0xF8, 0x0F, 0x84,
  0x72, 0x0D, 0x83, 0x00, 0x80, 0xC0, 0xC0, 0x0C, 0x01, 0xB0, 0x6C, 0x1B,
  0x0C, 0x7C, 0x00, 0x01, 0x81, 0xC1, 0xE1, 0xB0, 0x90, 0x98, 0x8C, 0x86,
  0xC3, 0x7F, 0xC0, 0x80, 0xC0, 0x60, 0x3F, 0xCC, 0x02, 0x01, 0x80, 0x7F,
  0x18, 0xE0, 0x18, 0x06, 0x01, 0xB0, 0x6C, 0x33, 0x08, 0x7C, 0x00, 0x0F,
  0x86, 0x23, 0x0C, 0x80, 0x60, 0x1B, 0xC5, 0x1B, 0x86, 0xC1, 0xB0, 0x64,
  0x11, 0x8C, 0x3C, 0x00, 0xFF, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x0F, 0x0C, 0x22, 0x0D, 0x83, 0x60, 0x8C,
  0x61, 0xE1, 0x86, 0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x7C, 0x00, 0x0F, 0x0C,
  0x62, 0x09, 0x83, 0x60, 0xD8, 0x26, 0x19, 0x8A, 0x3D, 0x80, 0x4C, 0x33,
  0x18, 0x7C, 0x00, 0x76, 0x60, 0x00, 0x0C, 0xCC, 0x1C, 0x61, 0x80, 0x00,
  0x00, 0x0E, 0x31, 0x84, 0x30, 0x80, 0x00, 0x81, 0x83, 0x0E, 0x08, 0x03,
  0x80, 0x30, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x08, 0x18, 0x30, 0xE0, 0x80, 0x00, 0x1F, 0x30,
  0xF0, 0x70, 0x30, 0x30, 0x30, 0x30, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0xC0, 0xC6, 0x18, 0x23, 0x37, 0x2C, 0xF6, 0x8B, 0x58, 0xA5,
  0x12, 0xD1, 0x2B, 0x12, 0xB3, 0x4B, 0x64, 0x9B, 0x8C, 0x00, 0x61, 0x03,
  0xE0, 0x01, 0x80, 0x70, 0x0B, 0x03, 0x60, 0x4C, 0x19, 0x82, 0x10, 0xC2,
  0x1F, 0xE6, 0x0D, 0x81, 0xB0, 0x3C, 0x02, 0x3F, 0x88, 0x36, 0x0D, 0x83,
  0x61, 0x9F, 0x84, 0x19, 0x02, 0xC0, 0xB0, 0x2C, 0x1B, 0x0C, 0xFE, 0x00,
  0x0F, 0x86, 0x33, 0x0D, 0x83, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x2C, 0x19, 0x8C, 0x3C, 0x00, 0x3F, 0x08, 0x66, 0x0D, 0x83, 0x60, 0xD8,
  0x36, 0x0D, 0x02, 0xC1, 0xB0, 0x6C, 0x33, 0x18, 0xFC, 0x00, 0x3F, 0xC8,
  0x06, 0x01, 0x80, 0x60, 0x1F, 0xE4, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0x80, 0x3F, 0xC6, 0x00, 0x80, 0x10, 0x06, 0x00, 0xFF, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x84, 0x33,
  0x0D, 0x83, 0x60, 0x11, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x19, 0x8C,
  0x3E, 0x00, 0x30, 0xC8, 0x36, 0x0D, 0x83, 0x60, 0xDF, 0xE4, 0x19, 0x06,
  0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x83, 0x00, 0x3F, 0xC1, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0xFF, 0x00,
  0x07, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x30,
  0xCC, 0x31, 0x98, 0x3C, 0x00, 0x30, 0xE4, 0x39, 0x8E, 0x33, 0x86, 0xC0,
  0xF0, 0x1F, 0x03, 0x60, 0xC6, 0x18, 0xE3, 0x0C, 0x60, 0xC8, 0x18, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0F, 0xF0, 0x18, 0x73, 0x86, 0x38, 0xA2, 0x8E, 0x2D, 0xE2, 0xD6, 0x6E,
  0x46, 0x64, 0x64, 0x44, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x80, 0x30, 0x4C,
  0x37, 0x8D, 0xE3, 0x68, 0xDA, 0x24, 0xC9, 0x36, 0xC5, 0xB1, 0x6C, 0x72,
  0x1C, 0x83, 0x00, 0x0F, 0x0C, 0x62, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F,
  0x02, 0xC1, 0xB0, 0x6C, 0x31, 0x88, 0x3C, 0x00, 0x3F, 0x88, 0x36, 0x0D,
  0x83, 0x60, 0xD8, 0x67, 0xE1, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x00, 0x0F, 0x0C, 0x62, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x02, 0xC1,
  0xB0, 0x6C, 0x31, 0x88, 0x3C, 0x06, 0x01, 0x80, 0x30, 0x07, 0x00, 0x3F,
  0x88, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x67, 0xE1, 0x18, 0xC6, 0x30, 0x8C,
  0x33, 0x0C, 0x81, 0x80, 0x0F, 0xC3, 0x0C, 0xC1, 0x98, 0x03, 0x00, 0x38,
  0x03, 0xE0, 0x0E, 0x00, 0xD8, 0x19, 0x03, 0x30, 0xC3, 0xF0, 0xFF, 0xC3,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x4C, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x10,
  0x26, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x87, 0xC0, 0x80, 0x58, 0x1B,
  0x02, 0x60, 0xCC, 0x11, 0x86, 0x11, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xE0,
  0x18, 0x03, 0x00, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x06, 0xCC, 0x4C, 0xCC,
  0xDC, 0xCD, 0x48, 0xD6, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xC3, 0x00, 0x18,
  0x18, 0x61, 0x83, 0x18, 0x0D, 0x80, 0x68, 0x01, 0xC0, 0x0C, 0x00, 0xF0,
  0x0D, 0x80, 0xC4, 0x0C, 0x30, 0x40, 0x86, 0x06, 0x00, 0xC0, 0xD8, 0x31,
  0x84, 0x31, 0x83, 0x60, 0x78, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x1F, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xC0, 0x1F,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x7C, 0x00, 0xC3, 0x04, 0x18, 0x60,
  0x83, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x30, 0x1F, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0xF8, 0x06, 0x07, 0x02, 0xC2, 0x23, 0x11, 0x09, 0x07, 0x83, 0xFF, 0xE0,
  0xE6, 0x30, 0x1F, 0x18, 0xD8, 0x60, 0x33, 0xF3, 0x1B, 0x0D, 0x06, 0xCF,
  0x79, 0xC0, 0x30, 0x18, 0x0C, 0x04, 0x02, 0xF3, 0x8D, 0x82, 0xC1, 0x61,
  0xA0, 0xF0, 0x78, 0x2E, 0x35, 0xE0, 0x1F, 0x18, 0xD8, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x82, 0x43, 0x1E, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x1E,
  0x8C, 0x66, 0x19, 0x06, 0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0xC7, 0x1E, 0xC0,
  0x1F, 0x18, 0xD8, 0x28, 0x1F, 0xFE, 0x03, 0x01, 0x82, 0x63, 0x1E, 0x00,
  0x07, 0xC2, 0x01, 0x80, 0x40, 0xFF, 0x8C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x1E, 0xCC, 0x66, 0x19, 0x06, 0xC1,
  0xB0, 0x6C, 0x13, 0x0C, 0xC7, 0x1E, 0xC0, 0x33, 0x08, 0xC6, 0x1E, 0x00,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0xF3, 0x8D, 0x86, 0xC3, 0x61, 0xA0, 0xF0,
  0x58, 0x2C, 0x36, 0x18, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x3F, 0xF0, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x3E, 0x00, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0xC8, 0xC2, 0x61, 0xA0, 0x7C, 0x1B, 0x04, 0x61, 0x18,
  0x43, 0x30, 0xC0, 0x0F, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x3F, 0xF0, 0x2E, 0xE6, 0xED,
  0x99, 0xB3, 0x36, 0x66, 0x88, 0x91, 0x16, 0x66, 0xCC, 0xD9, 0x98, 0x2F,
  0x38, 0xD8, 0x6C, 0x36, 0x1A, 0x0F, 0x05, 0x82, 0xC3, 0x61, 0x80, 0x1F,
  0x18, 0xD8, 0x28, 0x1C, 0x0E, 0x0F, 0x07, 0x82, 0xC2, 0x3E, 0x00, 0x17,
  0x8E, 0x33, 0x04, 0xC1, 0x30, 0xC8, 0x36, 0x0D, 0x82, 0x71, 0x93, 0xC4,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x1E, 0xCC, 0x66, 0x19, 0x06, 0xC1, 0xB0,
  0x6C, 0x13, 0x0C, 0xC7, 0x1E, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x67,
  0xBC, 0x1C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F,
  0x18, 0xD8, 0x2C, 0x03, 0xC0, 0x78, 0x05, 0x82, 0xC3, 0x3E, 0x00, 0x10,
  0x10, 0x30, 0x7F, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7E,
  0x20, 0xD8, 0x26, 0x09, 0x86, 0x41, 0x90, 0x6C, 0x13, 0x0C, 0xC7, 0x1E,
  0xC0, 0xC0, 0xB0, 0x6C, 0x33, 0x0C, 0x46, 0x19, 0x06, 0xC1, 0xA0, 0x78,
  0x0C, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0x66, 0x6D, 0xCD, 0xA9, 0x3D, 0x65,
  0x38, 0xE7, 0x18, 0x60, 0x30, 0x63, 0x18, 0x66, 0x07, 0x80, 0x60, 0x1C,
  0x06, 0xC1, 0x98, 0x61, 0x98, 0x30, 0x20, 0x23, 0x06, 0x30, 0x43, 0x0C,
  0x11, 0x81, 0x90, 0x1B, 0x01, 0xA0, 0x0E, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x0E, 0x00, 0x1F, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x0F, 0xF0, 0x07, 0x83, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0xC0, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x20, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x06, 0x01, 0x81, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x78, 0x00, 0x78, 0x23, 0x10, 0x38,
};

const GFXglyph LiberationMono_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 13, 11, 4, -13 },
  { 8, 8, 6, 11, 3, -14 },
  { 14, 12, 13, 11, 0, -13 },
  { 34, 11, 17, 11, 0, -15 },
  { 58, 12, 13, 11, 0, -13 },
  { 78, 10, 13, 11, 0, -13 },
  { 95, 2, 6, 11, 6, -14 },
  { 97, 7, 18, 11, 3, -14 },
  { 113, 7, 18, 11, 1, -14 },
  { 129, 7, 7, 11, 3, -14 },
  { 136, 9, 9, 11, 1, -11 },
  { 147, 5, 6, 11, 1, -3 },
  { 151, 5, 1, 11, 3, -5 },
  { 152, 2, 3, 11, 4, -3 },
  { 153, 12, 14, 11, 0, -14 },
  { 174, 10, 13, 11, 1, -13 },
  { 191, 10, 13, 11, 0, -13 },
  { 208, 11, 13, 11, 0, -13 },
  { 226, 10, 13, 11, 1, -13 },
  { 243, 9, 13, 11, 1, -13 },
  { 258, 10, 13, 11, 1, -13 },
  { 275, 10, 13, 11, 1, -13 },
  { 292, 8, 13, 11, 3, -13 },
  { 305, 10, 13, 11, 1, -13 },
  { 322, 10, 13, 11, 1, -13 },
  { 339, 4, 10, 11, 4, -10 },
  { 344, 6, 13, 11, 2, -10 },
  { 354, 9, 9, 11, 1, -11 },
  { 365, 9, 5, 11, 1, -9 },
  { 371, 9, 9, 11, 1, -11 },
  { 382, 9, 13, 11, 2, -13 },
  { 397, 12, 16, 11, 0, -14 },
  { 421, 11, 13, 11, -1, -13 },
  { 439, 10, 13, 11, 1, -13 },
  { 456, 10, 13, 11, 1, -13 },
  { 473, 10, 13, 11, 1, -13 },
  { 490, 10, 13, 11, 1, -13 },
  { 507, 11, 13, 11, 1, -13 },
  { 525, 10, 13, 11, 1, -13 },
  { 542, 10, 13, 11, 1, -13 },
  { 559, 10, 13, 11, 1, -13 },
  { 576, 10, 13, 11, 1, -13 },
  { 593, 11, 13, 11, 1, -13 },
  { 611, 9, 13, 11, 1, -13 },
  { 626, 12, 13, 11, 0, -13 },
  { 646, 10, 13, 11, 1, -13 },
  { 663, 10, 13, 11, 1, -13 },
  { 680, 10, 13, 11, 1, -13 },
  { 697, 10, 17, 11, 1, -13 },
  { 719, 10, 13, 11, 1, -13 },
  { 736, 11, 13, 11, 0, -13 },
  { 754, 10, 13, 11, 2, -13 },
  { 771, 11, 13, 11, 1, -13 },
  { 789, 11, 13, 11, 2, -13 },
  { 807, 12, 13, 11, 1, -13 },
  { 827, 13, 13, 11, -1, -13 },
  { 849, 11, 13, 11, 2, -13 },
  { 867, 12, 13, 11, 0, -13 },
  { 887, 9, 18, 11, 2, -14 },
  { 908, 6, 14, 11, 3, -14 },
  { 919, 8, 18, 11, 1, -14 },
  { 937, 9, 8, 11, 1, -13 },
  { 946, 11, 1, 11, -1, 1 },
  { 948, 4, 3, 11, 5, -14 },
  { 950, 9, 10, 11, 1, -10 },
  { 962, 9, 14, 11, 1, -14 },
  { 978, 9, 10, 11, 1, -10 },
  { 990, 10, 14, 11, 1, -14 },
  { 1008, 9, 10, 11, 1, -10 },
  { 1020, 10, 14, 11, 2, -14 },
  { 1038, 10, 14, 11, 1, -10 },
  { 1056, 9, 14, 11, 1, -14 },
  { 1072, 10, 14, 11, 0, -14 },
  { 1090, 10, 18, 11, -1, -14 },
  { 1113, 10, 14, 11, 1, -14 },
  { 1131, 10, 14, 11, 0, -14 },
  { 1149, 11, 10, 11, 0, -10 },
  { 1163, 9, 10, 11, 1, -10 },
  { 1175, 9, 10, 11, 1, -10 },
  { 1187, 10, 14, 11, 0, -10 },
  { 1205, 10, 14, 11, 1, -10 },
  { 1223, 9, 10, 11, 2, -10 },
  { 1235, 9, 10, 11, 1, -10 },
  { 1247, 8, 13, 11, 2, -13 },
  { 1260, 10, 10, 11, 1, -10 },
  { 1273, 10, 10, 11, 2, -10 },
  { 1286, 11, 10, 11, 1, -10 },
  { 1300, 11, 10, 11, 0, -10 },
  { 1314, 12, 14, 11, 0, -10 },
  { 1335, 11, 10, 11, 0, -10 },
  { 1349, 10, 18, 11, 2, -14 },
  { 1372, 1, 18, 11, 5, -14 },
  { 1375, 9, 18, 11, 0, -14 },
  { 1396, 10, 3, 11, 1, -8 },
};

const GFXfont LiberationMono_Italic19pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic19pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _LIBERATIONMONO_ITALIC19PT7B_H_
