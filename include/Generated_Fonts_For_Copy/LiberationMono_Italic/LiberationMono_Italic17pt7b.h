#ifndef _LIBERATIONMONO_ITALIC17PT7B_H_
#define _LIBERATIONMONO_ITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x26, 0x04, 0xC0, 0x6D, 0x3C, 0xF2, 0x88, 0x04,
  0x42, 0x20, 0x89, 0xFF, 0x11, 0x04, 0x42, 0x23, 0xFE, 0x22, 0x11, 0x04,
  0x40, 0x02, 0x03, 0xE3, 0x2C, 0x99, 0x24, 0x0D, 0x01, 0xE0, 0x16, 0x04,
  0xB2, 0x24, 0x98, 0xF8, 0x08, 0x00, 0x38, 0x49, 0x99, 0x36, 0x24, 0x87,
  0x20, 0x08, 0x02, 0xF0, 0xB2, 0x24, 0x48, 0x9A, 0x1E, 0x00, 0x0F, 0x0C,
  0xC4, 0x62, 0x61, 0xC1, 0xC5, 0x27, 0x9A, 0x86, 0x63, 0x9E, 0x60, 0x5B,
  0x68, 0x08, 0x63, 0x08, 0x61, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x83, 0x0C,
  0x18, 0x08, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x41,
  0x86, 0x08, 0x20, 0x10, 0x4D, 0x5E, 0x31, 0x65, 0x00, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x36, 0x6C, 0x80, 0xF0, 0x78, 0x00,
  0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x60, 0x00, 0x1E, 0x18, 0x98, 0x68, 0x3D, 0x9E, 0xCB, 0x05,
  0x86, 0xC2, 0x63, 0x1E, 0x00, 0x03, 0x07, 0x0C, 0x80, 0x40, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x1F, 0xE0, 0x0F, 0x86, 0x23, 0x0C, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0F, 0xF0, 0x1F, 0x18, 0xD8, 0x60,
  0x20, 0x30, 0xE0, 0x0C, 0x06, 0x83, 0x63, 0x1F, 0x00, 0x01, 0x81, 0xC1,
  0x61, 0x21, 0x11, 0x19, 0x8C, 0xFF, 0x02, 0x01, 0x01, 0x80, 0x3F, 0x90,
  0x18, 0x0C, 0x05, 0xE3, 0x18, 0x0C, 0x06, 0x83, 0x63, 0x1F, 0x00, 0x0F,
  0x18, 0xC8, 0x0C, 0x05, 0xE7, 0x1B, 0x0D, 0x86, 0xC3, 0x23, 0x1F, 0x00,
  0xFF, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0x1F,
  0x18, 0x98, 0x6C, 0x26, 0x30, 0xE1, 0x8D, 0x86, 0x83, 0x63, 0x1F, 0x00,
  0x1E, 0x19, 0x98, 0x48, 0x34, 0x13, 0x18, 0xFC, 0x06, 0xC2, 0x62, 0x1E,
  0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x30, 0x86, 0x10, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x18, 0x60,
  0x80, 0x1F, 0x30, 0xD0, 0x60, 0x20, 0x30, 0x70, 0x60, 0x20, 0x00, 0x18,
  0x0C, 0x00, 0x07, 0x86, 0x31, 0x04, 0x9B, 0x49, 0x54, 0x55, 0x16, 0x89,
  0xA2, 0xA9, 0xAB, 0xB3, 0x00, 0x43, 0x0F, 0x00, 0x03, 0x00, 0xE0, 0x78,
  0x32, 0x0C, 0x86, 0x21, 0x0C, 0xFF, 0x20, 0xD8, 0x3C, 0x04, 0x1F, 0x8C,
  0x33, 0x0C, 0xC2, 0x21, 0x8F, 0x86, 0x19, 0x82, 0x60, 0x90, 0x67, 0xE0,
  0x1F, 0x18, 0xD8, 0x68, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0x63, 0x1F,
  0x00, 0x1F, 0x0C, 0x63, 0x0C, 0xC3, 0x20, 0xC8, 0x36, 0x09, 0x86, 0x61,
  0x10, 0xC7, 0xC0, 0x1F, 0xCC, 0x03, 0x00, 0xC0, 0x20, 0x0F, 0xE6, 0x01,
  0x80, 0x60, 0x10, 0x07, 0xF8, 0x3F, 0x90, 0x18, 0x0C, 0x06, 0x03, 0xF9,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x1F, 0x18, 0xD8, 0x68, 0x0C, 0x06,
  0x7B, 0x05, 0x86, 0xC3, 0x63, 0x9F, 0x00, 0x10, 0xCC, 0x33, 0x0C, 0xC2,
  0x20, 0x8F, 0xE6, 0x19, 0x86, 0x61, 0x10, 0x44, 0x30, 0x3F, 0x86, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x3F, 0x80, 0x0F, 0x01,
  0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0xC6, 0xC4, 0x78, 0x10, 0xC6, 0x30,
  0xCC, 0x13, 0x02, 0xC0, 0x78, 0x1D, 0x83, 0x30, 0x63, 0x08, 0x21, 0x06,
  0x00, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xFE,
  0x30, 0xCE, 0x32, 0x94, 0xAF, 0x6A, 0xDB, 0x24, 0xC9, 0x02, 0x41, 0xB0,
  0x6C, 0x10, 0x18, 0x4E, 0x32, 0x8C, 0xA2, 0x2C, 0x89, 0x26, 0x59, 0x96,
  0x47, 0x10, 0xC4, 0x30, 0x1E, 0x18, 0x98, 0x68, 0x3C, 0x1E, 0x0F, 0x05,
  0x86, 0xC2, 0x63, 0x1E, 0x00, 0x1F, 0x8C, 0x33, 0x0C, 0x83, 0x21, 0x8F,
  0xC6, 0x01, 0x80, 0x40, 0x10, 0x04, 0x00, 0x1E, 0x18, 0x98, 0x68, 0x3C,
  0x1E, 0x0F, 0x05, 0x86, 0xC2, 0x63, 0x1E, 0x02, 0x01, 0x80, 0xC0, 0x38,
  0x1F, 0x8C, 0x33, 0x0C, 0xC3, 0x21, 0x8F, 0xC6, 0x61, 0x88, 0x63, 0x10,
  0xC4, 0x18, 0x0F, 0x84, 0x33, 0x0C, 0xC0, 0x38, 0x03, 0xC0, 0x18, 0x02,
  0xC1, 0x98, 0xC3, 0xE0, 0xFF, 0x8C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x00, 0x60, 0xB0, 0xD8, 0x68, 0x34, 0x16, 0x0B,
  0x0D, 0x86, 0xC2, 0x63, 0x1F, 0x00, 0xC0, 0xD0, 0x34, 0x19, 0x84, 0x63,
  0x18, 0x82, 0x60, 0x90, 0x28, 0x0A, 0x03, 0x00, 0xC0, 0x58, 0x1B, 0x03,
  0x66, 0x4D, 0xD9, 0xAB, 0x2D, 0x45, 0x38, 0xA6, 0x18, 0xC3, 0x18, 0x00,
  0x18, 0x20, 0x86, 0x0C, 0xC0, 0x58, 0x07, 0x00, 0x60, 0x0F, 0x00, 0x90,
  0x11, 0x82, 0x08, 0x60, 0xC0, 0xC1, 0xE1, 0x91, 0x8C, 0x82, 0x81, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x00, 0x3F, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0xFE, 0x00, 0x1E, 0x20,
  0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x7C,
  0x41, 0x86, 0x08, 0x30, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x1E, 0x0C, 0x18,
  0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x78, 0x0C,
  0x0E, 0x12, 0x12, 0x22, 0x62, 0x43, 0x81, 0xFF, 0xC0, 0xC9, 0x80, 0x1E,
  0x23, 0x63, 0x03, 0x7E, 0xC2, 0x86, 0x8E, 0xF7, 0x20, 0x20, 0x20, 0x6E,
  0x73, 0x61, 0x41, 0x43, 0xC3, 0xC2, 0xC6, 0xBC, 0x1E, 0x63, 0x41, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC2, 0x7C, 0x00, 0x80, 0xC0, 0x67, 0xA6, 0x32, 0x1B,
  0x0D, 0x86, 0xC2, 0x63, 0x31, 0x8F, 0xC0, 0x1E, 0x63, 0x41, 0xC1, 0xFF,
  0xC0, 0xC0, 0xC2, 0x7C, 0x0F, 0x88, 0x0C, 0x1F, 0xE2, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x00, 0x3D, 0xB1, 0x90, 0xD8, 0x6C, 0x36,
  0x1B, 0x09, 0x8C, 0x7E, 0x03, 0x01, 0x11, 0x8F, 0x80, 0x20, 0x20, 0x20,
  0x6E, 0x73, 0x61, 0x43, 0x43, 0xC3, 0xC2, 0x82, 0x86, 0x03, 0x01, 0x00,
  0x03, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x1F, 0xF0, 0x00,
  0x80, 0x40, 0x01, 0xF0, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x30, 0x30, 0xF0, 0x30, 0x18, 0x08, 0x04, 0x22, 0x63, 0x61,
  0xE0, 0xF0, 0x4C, 0x26, 0x31, 0x98, 0xC0, 0x0F, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x1F, 0xF0, 0x3D, 0xD9, 0xB6,
  0x4D, 0x13, 0x4C, 0x93, 0x2C, 0x8B, 0x26, 0xC9, 0x80, 0x6F, 0x73, 0x61,
  0x43, 0x43, 0xC3, 0xC2, 0x82, 0x86, 0x1E, 0x63, 0x41, 0xC1, 0xC1, 0xC3,
  0xC2, 0xC6, 0x78, 0x37, 0x1C, 0xCC, 0x24, 0x12, 0x0B, 0x0D, 0x84, 0xC6,
  0x5E, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x3D, 0x31, 0x90, 0xD8, 0x6C, 0x36,
  0x1B, 0x19, 0x8C, 0x7E, 0x03, 0x01, 0x80, 0x80, 0x40, 0x4E, 0x50, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x1E, 0x21, 0x60, 0x70, 0x3E, 0x06,
  0x02, 0x86, 0x7C, 0x10, 0x43, 0xF9, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x81,
  0xF0, 0x61, 0x30, 0x90, 0x48, 0x64, 0x36, 0x1B, 0x09, 0x8C, 0x7A, 0x00,
  0x40, 0x90, 0x66, 0x31, 0x88, 0x66, 0x09, 0x02, 0xC0, 0xA0, 0x30, 0x00,
  0xC0, 0xE0, 0x29, 0x8A, 0x66, 0x9D, 0x29, 0xCA, 0x73, 0x18, 0xC6, 0x00,
  0x30, 0xC4, 0x61, 0xB0, 0x38, 0x0C, 0x07, 0x83, 0x21, 0x8C, 0xC1, 0x00,
  0x20, 0x44, 0x18, 0xC2, 0x18, 0x81, 0x30, 0x24, 0x05, 0x80, 0xA0, 0x18,
  0x03, 0x00, 0x40, 0x10, 0x0C, 0x00, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0x00, 0x0F, 0x08, 0x18, 0x10, 0x10, 0x10, 0x20,
  0xC0, 0x60, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x02, 0x02, 0x06, 0x06, 0x04, 0x06, 0x03, 0x06, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0xF0, 0xF8, 0x87, 0x80,
};

const GFXglyph LiberationMono_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 11, 10, 3, -11 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 10, 13, 10, 0, -12 },
  { 42, 11, 11, 10, 0, -11 },
  { 58, 9, 11, 10, 0, -11 },
  { 71, 3, 5, 10, 5, -12 },
  { 73, 6, 16, 10, 3, -12 },
  { 85, 7, 16, 10, 1, -12 },
  { 99, 6, 7, 10, 3, -12 },
  { 105, 8, 9, 10, 1, -10 },
  { 114, 4, 5, 10, 1, -2 },
  { 117, 5, 1, 10, 3, -5 },
  { 118, 3, 2, 10, 3, -2 },
  { 119, 11, 12, 10, 0, -12 },
  { 136, 9, 11, 10, 1, -11 },
  { 149, 9, 11, 10, 0, -11 },
  { 162, 10, 11, 10, 0, -11 },
  { 176, 9, 11, 10, 1, -11 },
  { 189, 9, 11, 10, 0, -11 },
  { 202, 9, 11, 10, 1, -11 },
  { 215, 9, 11, 10, 1, -11 },
  { 228, 8, 11, 10, 2, -11 },
  { 239, 9, 11, 10, 1, -11 },
  { 252, 9, 11, 10, 1, -11 },
  { 265, 4, 9, 10, 3, -9 },
  { 270, 6, 12, 10, 1, -9 },
  { 279, 8, 9, 10, 1, -10 },
  { 288, 8, 4, 10, 1, -7 },
  { 292, 8, 9, 10, 1, -10 },
  { 301, 9, 11, 10, 1, -11 },
  { 314, 10, 14, 10, 0, -12 },
  { 332, 10, 11, 10, -1, -11 },
  { 346, 10, 11, 10, 0, -11 },
  { 360, 9, 11, 10, 1, -11 },
  { 373, 10, 11, 10, 0, -11 },
  { 387, 10, 11, 10, 0, -11 },
  { 401, 9, 11, 10, 1, -11 },
  { 414, 9, 11, 10, 1, -11 },
  { 427, 10, 11, 10, 0, -11 },
  { 441, 9, 11, 10, 1, -11 },
  { 454, 8, 11, 10, 1, -11 },
  { 465, 11, 11, 10, 0, -11 },
  { 481, 8, 11, 10, 1, -11 },
  { 492, 10, 11, 10, 0, -11 },
  { 506, 10, 11, 10, 0, -11 },
  { 520, 9, 11, 10, 1, -11 },
  { 533, 10, 11, 10, 0, -11 },
  { 547, 9, 15, 10, 1, -11 },
  { 564, 10, 11, 10, 0, -11 },
  { 578, 10, 11, 10, 0, -11 },
  { 592, 9, 11, 10, 2, -11 },
  { 605, 9, 11, 10, 1, -11 },
  { 618, 10, 11, 10, 1, -11 },
  { 632, 11, 11, 10, 1, -11 },
  { 648, 12, 11, 10, -1, -11 },
  { 665, 9, 11, 10, 2, -11 },
  { 678, 11, 11, 10, 0, -11 },
  { 694, 7, 16, 10, 2, -12 },
  { 708, 6, 12, 10, 2, -12 },
  { 717, 7, 16, 10, 1, -12 },
  { 731, 8, 8, 10, 1, -11 },
  { 739, 10, 1, 10, -1, 1 },
  { 741, 3, 3, 10, 5, -13 },
  { 743, 8, 9, 10, 1, -9 },
  { 752, 8, 12, 10, 1, -12 },
  { 764, 8, 9, 10, 1, -9 },
  { 773, 9, 12, 10, 1, -12 },
  { 787, 8, 9, 10, 1, -9 },
  { 796, 9, 12, 10, 2, -12 },
  { 810, 9, 13, 10, 1, -9 },
  { 825, 8, 12, 10, 1, -12 },
  { 837, 9, 12, 10, 0, -12 },
  { 851, 9, 16, 10, -1, -12 },
  { 869, 9, 12, 10, 1, -12 },
  { 883, 9, 12, 10, 0, -12 },
  { 897, 10, 9, 10, 0, -9 },
  { 909, 8, 9, 10, 1, -9 },
  { 918, 8, 9, 10, 1, -9 },
  { 927, 9, 13, 10, 0, -9 },
  { 942, 9, 13, 10, 1, -9 },
  { 957, 8, 9, 10, 2, -9 },
  { 966, 8, 9, 10, 1, -9 },
  { 975, 7, 11, 10, 2, -11 },
  { 985, 9, 9, 10, 1, -9 },
  { 996, 10, 9, 10, 1, -9 },
  { 1008, 10, 9, 10, 1, -9 },
  { 1020, 10, 9, 10, 0, -9 },
  { 1032, 11, 13, 10, 0, -9 },
  { 1050, 9, 9, 10, 0, -9 },
  { 1061, 8, 16, 10, 2, -12 },
  { 1077, 2, 16, 10, 4, -12 },
  { 1081, 8, 16, 10, 0, -12 },
  { 1097, 9, 2, 10, 1, -7 },
};

const GFXfont LiberationMono_Italic17pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic17pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic17pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _LIBERATIONMONO_ITALIC17PT7B_H_
