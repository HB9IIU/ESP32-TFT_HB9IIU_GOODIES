#ifndef _LIBERATIONMONO_ITALIC20PT7B_H_
#define _LIBERATIONMONO_ITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x62, 0x11, 0x8C, 0x60, 0x01, 0x8C, 0x00, 0xE7, 0x8F,
  0x16, 0x68, 0xD1, 0x80, 0x02, 0x20, 0x42, 0x04, 0x20, 0x44, 0x3F, 0xF0,
  0x88, 0x10, 0x81, 0x08, 0xFF, 0xE2, 0x10, 0x22, 0x04, 0x20, 0x46, 0x00,
  0x01, 0x00, 0x10, 0x0F, 0xE1, 0x97, 0x33, 0x33, 0x20, 0x3A, 0x00, 0xF0,
  0x02, 0xC0, 0x66, 0x06, 0x6C, 0x46, 0xC4, 0x66, 0x4C, 0x3F, 0x00, 0xC0,
  0x08, 0x00, 0x3C, 0x13, 0x31, 0x11, 0x98, 0x89, 0x84, 0xD8, 0x3D, 0x80,
  0x08, 0x00, 0xBC, 0x09, 0x30, 0x99, 0x88, 0x88, 0x84, 0x4C, 0x3C, 0x00,
  0x07, 0x81, 0x98, 0x21, 0x0C, 0x61, 0x98, 0x1C, 0x0F, 0x03, 0x63, 0xC4,
  0x58, 0xD3, 0x0E, 0x61, 0xC7, 0xCE, 0x7B, 0x6D, 0x00, 0x06, 0x18, 0x60,
  0xC3, 0x04, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60,
  0xC0, 0xC0, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x06, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x10, 0x22, 0x5B,
  0xC3, 0x0F, 0x36, 0x44, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC3, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x39, 0x8C, 0xC4, 0x40, 0xFC, 0xFB, 0x00, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0F, 0x86, 0x33, 0x0D, 0x81, 0x60, 0x53, 0xBC, 0xCF, 0x03, 0xC0, 0xB0,
  0x6C, 0x11, 0x8C, 0x3C, 0x00, 0x03, 0x07, 0x9C, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x8F, 0xF8, 0x07, 0xC1, 0x8C, 0x61,
  0x88, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x07, 0xFC, 0x0F, 0x86, 0x33, 0x0D, 0x83, 0x00, 0xC0, 0x60, 0xE0, 0x06,
  0x00, 0xB0, 0x2C, 0x1B, 0x8C, 0x3E, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x16,
  0x09, 0x84, 0x63, 0x11, 0x84, 0xC3, 0x3F, 0xF0, 0x30, 0x08, 0x06, 0x00,
  0x3F, 0xCC, 0x03, 0x00, 0x80, 0x7F, 0x18, 0x60, 0x0C, 0x03, 0x00, 0xF0,
  0x6C, 0x1B, 0x8C, 0x7C, 0x00, 0x07, 0x86, 0x33, 0x04, 0xC0, 0x60, 0x1B,
  0xC7, 0x19, 0x83, 0xC0, 0xF0, 0x24, 0x19, 0x8C, 0x3E, 0x00, 0xFF, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x00, 0x0F, 0x84, 0x33, 0x0C, 0x83, 0x20, 0xCC, 0x61, 0xE1, 0x86, 0xC0,
  0xB0, 0x2C, 0x1B, 0x0C, 0x7E, 0x00, 0x0F, 0x86, 0x33, 0x0D, 0x83, 0x60,
  0xD8, 0x36, 0x0D, 0xC7, 0x3E, 0x80, 0x6C, 0x13, 0x08, 0x7C, 0x00, 0x33,
  0x70, 0x00, 0x00, 0xEC, 0xC0, 0x0C, 0x31, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0xC6, 0x18, 0xC2, 0x00, 0x00, 0x40, 0xE0, 0xC1, 0xC0, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x40, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0xE0, 0xC1, 0xC0, 0x80, 0x00, 0x1F,
  0x30, 0xF0, 0x38, 0x30, 0x18, 0x38, 0x30, 0x30, 0x30, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x03, 0xC0, 0x42, 0x08, 0x31, 0x01, 0x23, 0x52, 0x4D, 0x68,
  0xD5, 0x89, 0x50, 0x9D, 0x1B, 0xD1, 0x2B, 0x32, 0x93, 0x49, 0xD8, 0xC0,
  0x04, 0x08, 0x61, 0x03, 0xE0, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x64, 0x06,
  0x40, 0xC6, 0x0C, 0x61, 0x86, 0x1F, 0xE3, 0x02, 0x60, 0x36, 0x03, 0xC0,
  0x30, 0x3F, 0x8C, 0x32, 0x0D, 0x83, 0x61, 0x9F, 0x86, 0x19, 0x03, 0xC0,
  0xF0, 0x3C, 0x0B, 0x06, 0xFE, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x26,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1B, 0x06, 0x31, 0x83, 0xE0,
  0x3F, 0x0C, 0x72, 0x0D, 0x81, 0x60, 0x58, 0x16, 0x0D, 0x83, 0xC0, 0xF0,
  0x6C, 0x1B, 0x1C, 0xFC, 0x00, 0x3F, 0xE6, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xF8, 0x3F,
  0xE6, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xFF, 0x98, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x26, 0x00,
  0xCF, 0xB0, 0x36, 0x06, 0xC0, 0x98, 0x33, 0x06, 0x31, 0xC3, 0xE0, 0x30,
  0x66, 0x0C, 0x81, 0x30, 0x66, 0x0C, 0xFF, 0x98, 0x32, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0x60, 0xCC, 0x10, 0x3F, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x0F, 0xF0, 0x07,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xB0, 0xCC,
  0x31, 0x98, 0x3C, 0x00, 0x30, 0x63, 0x0C, 0x21, 0x86, 0x30, 0x6E, 0x07,
  0xC0, 0x7C, 0x06, 0x60, 0xC6, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC1, 0xC0,
  0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0F, 0xF8, 0x18, 0x31, 0x87, 0x3C, 0x73, 0xCF, 0x2C, 0xA2, 0x52,
  0x25, 0x66, 0x66, 0x66, 0x64, 0x04, 0x40, 0x44, 0x0C, 0xC0, 0xC0, 0x30,
  0x67, 0x0C, 0xE1, 0x34, 0x26, 0xCC, 0xD9, 0x93, 0x32, 0x24, 0xC6, 0x98,
  0xF3, 0x1E, 0x61, 0xC8, 0x30, 0x0F, 0x83, 0x18, 0xC3, 0x30, 0x36, 0x07,
  0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0x31, 0x83, 0xC0, 0x3F,
  0x86, 0x1C, 0x81, 0xB0, 0x36, 0x0C, 0xC3, 0x1F, 0xC2, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x83, 0x18, 0xC3, 0x30, 0x36, 0x07,
  0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0x31, 0x83, 0xC0, 0x30,
  0x03, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xC6, 0x1C, 0x81, 0xB0, 0x36, 0x04,
  0xC1, 0x9F, 0xC2, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x60, 0xCC, 0x18, 0x07,
  0xC1, 0x86, 0x10, 0x33, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x0E, 0x00,
  0x6C, 0x06, 0x60, 0xC6, 0x1C, 0x3F, 0x00, 0xFF, 0xE1, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x30, 0x64, 0x0D, 0x81, 0xB0, 0x26, 0x0C, 0xC1, 0x98, 0x36, 0x06,
  0xC0, 0x98, 0x33, 0x06, 0x61, 0x87, 0xE0, 0xC0, 0x78, 0x0F, 0x03, 0x60,
  0x4C, 0x18, 0x86, 0x18, 0xC3, 0x30, 0x66, 0x0D, 0x80, 0xA0, 0x1C, 0x03,
  0x00, 0x40, 0x16, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x66, 0x67, 0x33, 0x39,
  0x1B, 0xD8, 0xD2, 0xC7, 0x94, 0x38, 0xE1, 0xC6, 0x0C, 0x30, 0x00, 0x0C,
  0x18, 0x30, 0x40, 0x43, 0x01, 0x98, 0x06, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xE0, 0x0C, 0x80, 0x63, 0x01, 0x0C, 0x0C, 0x18, 0x60, 0x60, 0xC0, 0x6C,
  0x19, 0x86, 0x11, 0x83, 0x60, 0x78, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x1F, 0xF0, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xC0,
  0x0F, 0x84, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x3F, 0x00, 0xC1, 0x81,
  0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0x81, 0x80,
  0x1F, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x3E, 0x00, 0x07, 0x01,
  0xC0, 0x90, 0x64, 0x11, 0x8C, 0x62, 0x19, 0x02, 0xC0, 0x80, 0x7F, 0xF8,
  0xCC, 0x80, 0x1F, 0x0C, 0x66, 0x18, 0x06, 0x3F, 0x98, 0x6C, 0x1B, 0x0C,
  0xC3, 0x31, 0xC7, 0x98, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8A, 0x37,
  0x0D, 0x83, 0x60, 0xD8, 0x34, 0x0B, 0x06, 0xC1, 0xB8, 0xCD, 0xE0, 0x0F,
  0x8C, 0x36, 0x0D, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0x98, 0xC3,
  0xE0, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x21, 0xEC, 0x63, 0x98, 0x33, 0x06,
  0x40, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x39, 0x8A, 0x1E, 0x40, 0x0F, 0x0C,
  0x66, 0x0D, 0x83, 0x40, 0xFF, 0xFC, 0x03, 0x00, 0xC1, 0x98, 0xC3, 0xE0,
  0x07, 0xC3, 0x01, 0x80, 0x60, 0xFF, 0x84, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x00, 0x1E, 0x4C, 0x76, 0x1D, 0x83,
  0x40, 0xB0, 0x2C, 0x1B, 0x06, 0xC3, 0xB9, 0x67, 0x90, 0x0C, 0xC3, 0x31,
  0x87, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8A, 0x77, 0x0D, 0x83,
  0x60, 0x98, 0x64, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x10, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x87, 0xFC, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC3, 0xF0, 0x00, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x0C, 0x63, 0x09, 0x81, 0x60, 0x7C, 0x0C, 0xC1, 0x98, 0x21, 0x04,
  0x30, 0x86, 0x30, 0x60, 0x0F, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x8F, 0xFC, 0x2E,
  0xE3, 0x33, 0x23, 0x36, 0x22, 0x66, 0x66, 0x66, 0x46, 0x64, 0x46, 0xC4,
  0x4C, 0xC4, 0xCC, 0xC0, 0x27, 0x8A, 0x77, 0x0D, 0x83, 0x60, 0x98, 0x64,
  0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x10, 0x0F, 0x0C, 0x66, 0x0D, 0x83, 0x40,
  0xF0, 0x3C, 0x0B, 0x06, 0xC1, 0x98, 0xC3, 0xC0, 0x13, 0xC2, 0x8C, 0xE1,
  0x98, 0x33, 0x06, 0x60, 0xC8, 0x13, 0x06, 0x60, 0xCE, 0x31, 0xBC, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x1E, 0xCC, 0x76, 0x0D, 0x83, 0x40, 0xF0,
  0x6C, 0x1B, 0x06, 0xC3, 0xB1, 0x47, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x67, 0xB4, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x00, 0x0F, 0x0C, 0x22, 0x0D, 0x80, 0x38, 0x07, 0xC0, 0x38, 0x06, 0xC1,
  0xB0, 0xC7, 0xE0, 0x30, 0x30, 0x20, 0xFE, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x7C, 0x30, 0xC8, 0x36, 0x0D, 0x83, 0x60, 0x98,
  0x64, 0x1B, 0x06, 0xC1, 0xB1, 0xC7, 0x90, 0xC0, 0xF0, 0x2C, 0x1B, 0x0C,
  0x43, 0x19, 0x86, 0x61, 0xB0, 0x68, 0x0E, 0x03, 0x00, 0xC0, 0x3C, 0x02,
  0xC0, 0x6C, 0xC6, 0xCE, 0x4D, 0xEC, 0xD6, 0xCF, 0x28, 0xE3, 0x8E, 0x30,
  0xC3, 0x00, 0x30, 0x61, 0x84, 0x18, 0xC0, 0xD8, 0x07, 0x00, 0x60, 0x0F,
  0x01, 0xB0, 0x31, 0x86, 0x18, 0xC0, 0xC0, 0x30, 0x33, 0x02, 0x30, 0x63,
  0x04, 0x10, 0xC1, 0x98, 0x19, 0x81, 0xB0, 0x0A, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0x00, 0x03, 0xC1,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x30, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x30, 0x30, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x0F, 0x00, 0x78, 0x23, 0x10, 0x38,
};

const GFXglyph LiberationMono_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 13, 12, 4, -13 },
  { 10, 7, 6, 12, 4, -15 },
  { 16, 12, 13, 12, 0, -13 },
  { 36, 12, 17, 12, 0, -15 },
  { 62, 13, 13, 12, 0, -13 },
  { 84, 11, 13, 12, 0, -13 },
  { 102, 3, 6, 12, 6, -15 },
  { 105, 7, 19, 12, 3, -15 },
  { 122, 8, 19, 12, 1, -15 },
  { 141, 7, 8, 12, 4, -15 },
  { 148, 10, 9, 12, 1, -11 },
  { 160, 5, 6, 12, 1, -3 },
  { 164, 6, 1, 12, 3, -6 },
  { 165, 3, 3, 12, 4, -3 },
  { 167, 13, 15, 12, 0, -15 },
  { 192, 10, 13, 12, 1, -13 },
  { 209, 9, 13, 12, 1, -13 },
  { 224, 11, 13, 12, 0, -13 },
  { 242, 10, 13, 12, 1, -13 },
  { 259, 10, 13, 12, 1, -13 },
  { 276, 10, 13, 12, 1, -13 },
  { 293, 10, 13, 12, 1, -13 },
  { 310, 9, 13, 12, 3, -13 },
  { 325, 10, 13, 12, 1, -13 },
  { 342, 10, 13, 12, 1, -13 },
  { 359, 4, 11, 12, 4, -11 },
  { 365, 6, 14, 12, 2, -11 },
  { 376, 10, 9, 12, 1, -11 },
  { 388, 10, 5, 12, 1, -9 },
  { 395, 10, 9, 12, 1, -11 },
  { 407, 9, 13, 12, 2, -13 },
  { 422, 12, 18, 12, 0, -15 },
  { 449, 12, 13, 12, -1, -13 },
  { 469, 10, 13, 12, 1, -13 },
  { 486, 11, 13, 12, 1, -13 },
  { 504, 10, 13, 12, 1, -13 },
  { 521, 11, 13, 12, 1, -13 },
  { 539, 11, 13, 12, 1, -13 },
  { 557, 11, 13, 12, 1, -13 },
  { 575, 11, 13, 12, 1, -13 },
  { 593, 11, 13, 12, 1, -13 },
  { 611, 10, 13, 12, 1, -13 },
  { 628, 12, 13, 12, 1, -13 },
  { 648, 9, 13, 12, 1, -13 },
  { 663, 12, 13, 12, 0, -13 },
  { 683, 11, 13, 12, 1, -13 },
  { 701, 11, 13, 12, 1, -13 },
  { 719, 11, 13, 12, 1, -13 },
  { 737, 11, 17, 12, 1, -13 },
  { 761, 11, 13, 12, 1, -13 },
  { 779, 12, 13, 12, 0, -13 },
  { 799, 11, 13, 12, 2, -13 },
  { 817, 11, 13, 12, 1, -13 },
  { 835, 11, 13, 12, 2, -13 },
  { 853, 13, 13, 12, 1, -13 },
  { 875, 14, 13, 12, -1, -13 },
  { 898, 11, 13, 12, 2, -13 },
  { 916, 12, 13, 12, 0, -13 },
  { 936, 9, 19, 12, 2, -15 },
  { 958, 7, 15, 12, 3, -15 },
  { 972, 9, 19, 12, 1, -15 },
  { 994, 10, 9, 12, 1, -13 },
  { 1006, 13, 1, 12, -2, 1 },
  { 1008, 3, 3, 12, 6, -15 },
  { 1010, 10, 11, 12, 1, -11 },
  { 1024, 10, 15, 12, 1, -15 },
  { 1043, 10, 11, 12, 1, -11 },
  { 1057, 11, 15, 12, 1, -15 },
  { 1078, 10, 11, 12, 1, -11 },
  { 1092, 10, 15, 12, 2, -15 },
  { 1111, 10, 15, 12, 1, -11 },
  { 1130, 10, 15, 12, 1, -15 },
  { 1149, 10, 15, 12, 0, -15 },
  { 1168, 11, 19, 12, -1, -15 },
  { 1195, 11, 15, 12, 1, -15 },
  { 1216, 10, 15, 12, 0, -15 },
  { 1235, 12, 11, 12, 0, -11 },
  { 1252, 10, 11, 12, 1, -11 },
  { 1266, 10, 11, 12, 1, -11 },
  { 1280, 11, 15, 12, 0, -11 },
  { 1301, 10, 15, 12, 1, -11 },
  { 1320, 9, 11, 12, 2, -11 },
  { 1333, 10, 11, 12, 1, -11 },
  { 1347, 8, 14, 12, 3, -14 },
  { 1361, 10, 11, 12, 1, -11 },
  { 1375, 10, 11, 12, 2, -11 },
  { 1389, 12, 11, 12, 1, -11 },
  { 1406, 12, 11, 12, 0, -11 },
  { 1423, 12, 15, 12, 0, -11 },
  { 1446, 11, 11, 12, 0, -11 },
  { 1462, 10, 19, 12, 2, -15 },
  { 1486, 2, 19, 12, 5, -15 },
  { 1491, 10, 19, 12, 0, -15 },
  { 1515, 10, 3, 12, 1, -8 },
};

const GFXfont LiberationMono_Italic20pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic20pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _LIBERATIONMONO_ITALIC20PT7B_H_
