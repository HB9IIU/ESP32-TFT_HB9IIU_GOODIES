#ifndef _LIBERATIONMONO_ITALIC55PT7B_H_
#define _LIBERATIONMONO_ITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xF3, 0xF0, 0x3F,
  0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03,
  0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFC,
  0x79, 0xFE, 0x03, 0xF0, 0x78, 0x7E, 0x03, 0xE0, 0x70, 0x3E, 0x07, 0xC0,
  0x70, 0x1E, 0x07, 0xC0, 0x70, 0x1C, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0xE0,
  0xE0, 0x00, 0x03, 0xFD, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x03,
  0x80, 0xF8, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x38, 0x07,
  0x80, 0xF8, 0xF8, 0x07, 0x80, 0xF8, 0xF8, 0x07, 0x00, 0xF8, 0xF8, 0x07,
  0x01, 0xF0, 0xFC, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x7F, 0x8F,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x03, 0xFF, 0xE0, 0x01, 0xE0,
  0x3C, 0x3E, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x1E, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x0F, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x8F, 0x00, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x07, 0xFE,
  0x3C, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x3C, 0x3F,
  0xF0, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x00, 0xF0, 0xF0, 0xF8, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x78, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x3C, 0x3E, 0x03,
  0x80, 0x03, 0xFF, 0xC0, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF3, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x3F, 0xE0, 0x07,
  0x81, 0xF7, 0xC0, 0x1E, 0x0F, 0x8F, 0x00, 0x78, 0x7C, 0x3E, 0x03, 0xC3,
  0xE0, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x78, 0x7C, 0x07, 0xC1, 0xE1, 0xE0,
  0x0F, 0x8F, 0x0F, 0x80, 0x3E, 0x3C, 0x3E, 0x00, 0x7D, 0xE0, 0xF8, 0x01,
  0xFF, 0x03, 0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x1F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xC0,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x02, 0x07, 0x02,
  0x78, 0x71, 0xE7, 0xEF, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xF3, 0x80, 0x1E, 0x3C, 0x03, 0xC3,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x10, 0x08, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0xFC, 0x1F, 0x3C, 0x1F, 0xC1, 0xF7, 0xC1, 0xFC,
  0x1F, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7,
  0x83, 0xF8, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xEF, 0x80, 0x1F,
  0xF1, 0xF0, 0x03, 0xF8, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0x80,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x1F, 0xE0,
  0x00, 0xFB, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0x81, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x1F, 0xC0, 0x0F, 0x8F, 0xFF, 0x01, 0xE7, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF,
  0x0F, 0xFC, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xCF, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x00,
  0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0x7F, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0xFB,
  0xE0, 0xFF, 0xFF, 0x3C, 0x07, 0xFF, 0xE7, 0xC0, 0x3F, 0xFC, 0x7C, 0x00,
  0xFE, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xE0,
  0x03, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x03, 0xF8, 0xEF, 0x03, 0x81,
  0xFF, 0x7B, 0xC1, 0xE0, 0xF1, 0xDC, 0xF0, 0x70, 0x78, 0x37, 0x3C, 0x3C,
  0x3C, 0x0F, 0x8F, 0x0E, 0x1E, 0x03, 0xE3, 0xC3, 0x87, 0x00, 0xF8, 0xE1,
  0xE3, 0xC0, 0x3C, 0x38, 0x70, 0xE0, 0x0F, 0x0E, 0x3C, 0x78, 0x03, 0xC3,
  0x8F, 0x1C, 0x01, 0xE1, 0xE3, 0x8F, 0x00, 0x78, 0x78, 0xE3, 0xC0, 0x1C,
  0x1C, 0x78, 0xE0, 0x0F, 0x07, 0x1E, 0x38, 0x03, 0xC3, 0xC7, 0x1E, 0x00,
  0xE0, 0xE1, 0xC7, 0x80, 0x78, 0x38, 0x71, 0xE0, 0x1E, 0x1E, 0x1C, 0x70,
  0x0F, 0x07, 0x0F, 0x1C, 0x03, 0xC1, 0xC3, 0xC7, 0x01, 0xF0, 0xE0, 0xF1,
  0xC0, 0xF8, 0x38, 0x3C, 0x78, 0x7E, 0x1C, 0x0F, 0x1E, 0x3B, 0x8E, 0x03,
  0xC7, 0xFC, 0xFF, 0x00, 0xF0, 0xFE, 0x1F, 0x80, 0x1C, 0x1F, 0x07, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x3F,
  0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x30, 0x3F, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x06, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xCF, 0xC0, 0x3F, 0xFE, 0x7E, 0x01, 0xFF,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x03, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF0, 0x7F, 0x00,
  0x00, 0xF8, 0x7F, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x1E, 0x7F, 0x00, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x01, 0xFE, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0,
  0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x07,
  0xBC, 0x07, 0xBE, 0x03, 0xDE, 0x03, 0xCF, 0x03, 0xCF, 0x01, 0xE7, 0x81,
  0xEF, 0x81, 0xF3, 0xC1, 0xE7, 0xC0, 0xF9, 0xE1, 0xF3, 0xC0, 0x78, 0xF8,
  0xF1, 0xE0, 0x3C, 0x7C, 0xF0, 0xF0, 0x1E, 0x1E, 0x78, 0xF8, 0x1F, 0x0F,
  0x78, 0x7C, 0x0F, 0x87, 0xBC, 0x3C, 0x07, 0x83, 0xFC, 0x1E, 0x03, 0xC1,
  0xFC, 0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x3E, 0x07, 0xF0, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0xF0, 0x1F, 0xC0, 0x01,
  0xE0, 0x3F, 0xC0, 0x07, 0xC0, 0xFF, 0x80, 0x0F, 0x81, 0xFF, 0x00, 0x1F,
  0x03, 0xDF, 0x00, 0x3C, 0x07, 0xBE, 0x00, 0x78, 0x0F, 0x3C, 0x01, 0xF0,
  0x3E, 0x78, 0x03, 0xE0, 0x7C, 0xF8, 0x07, 0xC0, 0xF9, 0xF0, 0x0F, 0x01,
  0xE1, 0xE0, 0x1E, 0x03, 0xC3, 0xC0, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0x7C, 0x1F, 0x07, 0x80, 0xF0,
  0x3E, 0x1F, 0x01, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0x78, 0x7C, 0x0F, 0x80,
  0xF8, 0xF0, 0x1F, 0x01, 0xF1, 0xE0, 0x3C, 0x01, 0xE7, 0xC0, 0x78, 0x03,
  0xCF, 0x81, 0xF0, 0x07, 0xDF, 0x03, 0xE0, 0x0F, 0xBC, 0x07, 0xC0, 0x0F,
  0x78, 0x0F, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x7F,
  0xC0, 0xF8, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0xFE, 0x03, 0xC0, 0x01, 0xFC,
  0x07, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x3F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7F,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1E, 0x03, 0xF0, 0x1E, 0x07, 0x80,
  0xFC, 0x0F, 0x81, 0xE0, 0x7F, 0x03, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x1E,
  0x0F, 0x70, 0x7C, 0x0F, 0x83, 0xDC, 0x1F, 0x03, 0xE1, 0xE7, 0x87, 0x80,
  0xF8, 0x79, 0xE1, 0xE0, 0x3E, 0x3C, 0x78, 0xF8, 0x0F, 0x8F, 0x1E, 0x3C,
  0x03, 0xE7, 0x87, 0x8F, 0x00, 0xF9, 0xE1, 0xE7, 0xC0, 0x3E, 0x70, 0x79,
  0xE0, 0x0F, 0x3C, 0x1E, 0x78, 0x03, 0xCE, 0x07, 0xBE, 0x00, 0xF7, 0x81,
  0xEF, 0x00, 0x3D, 0xC0, 0x7B, 0xC0, 0x0F, 0xF0, 0x0E, 0xE0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x03, 0xC1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0x87, 0xE0, 0x01, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0xC3,
  0xF8, 0x3E, 0xFC, 0x7F, 0xFF, 0x9F, 0xF7, 0xFF, 0xE3, 0xFE, 0x7F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x3C, 0x3F, 0xF8, 0x07,
  0xCF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0x80,
  0x3E, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x07, 0xF8, 0x03, 0xF0, 0x7F,
  0xC0, 0xFE, 0x07, 0xBF, 0xFF, 0xC0, 0xF9, 0xFF, 0xF8, 0x0F, 0x8F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x7C, 0x01,
  0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0xEF, 0x80, 0x7F, 0x03, 0xFE, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0xF8,
  0x03, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x7C, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC7,
  0xC0, 0x3F, 0xFF, 0x3E, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0x83, 0xFF, 0x03,
  0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x3E, 0x00, 0xEF, 0x01,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0x3E, 0x00, 0xFF,
  0xE1, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x01,
  0xE1, 0xFF, 0xC0, 0x7C, 0xFF, 0xFC, 0x0F, 0xBF, 0xFF, 0xC1, 0xFF, 0x83,
  0xF8, 0x3D, 0xC0, 0x1F, 0x07, 0xF0, 0x03, 0xE1, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x7E, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x7C,
  0x07, 0x8F, 0xE1, 0xFE, 0x07, 0x9F, 0xE3, 0xFE, 0x07, 0xBF, 0xF7, 0xFF,
  0x07, 0xF1, 0xFE, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1E,
  0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0x3E, 0x1F, 0x01, 0xE0, 0x3E,
  0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0x3C,
  0x1E, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C,
  0x3E, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x0F, 0x80, 0xF0,
  0x78, 0x0F, 0x80, 0xF0, 0x78, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x01, 0xF0,
  0xF8, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x78, 0x7F, 0xF0, 0x1F, 0x3F, 0xFF, 0x03, 0xEF, 0xFF, 0xF0, 0x7F, 0xE0,
  0xFE, 0x0F, 0x70, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xC3, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0x00, 0x7D,
  0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x3F,
  0x01, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3E, 0x7F, 0xFE, 0x00,
  0xF8, 0xFF, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0x1F, 0x01, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xBE, 0x07,
  0xF0, 0x3F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x00,
  0xFE, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0x07, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x3F,
  0xFF, 0x3C, 0x01, 0xFF, 0xC7, 0xC0, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC3, 0xE0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0x9F,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F,
  0xE0, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x03, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF0, 0xF8, 0x03,
  0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xFF, 0xFD, 0xF0, 0x3F, 0xFF, 0x3E, 0x03,
  0xFF, 0x87, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x78, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0xC0, 0xF8, 0xF8, 0x1F, 0xC0,
  0xF0, 0xF8, 0x3F, 0xC1, 0xF0, 0xF8, 0x3F, 0xC1, 0xF0, 0xF8, 0x7B, 0xC1,
  0xE0, 0xF8, 0x7B, 0xC3, 0xE0, 0xF8, 0xF1, 0xC3, 0xE0, 0xF0, 0xF1, 0xC3,
  0xC0, 0xF1, 0xE1, 0xC7, 0xC0, 0xF1, 0xE1, 0xE7, 0x80, 0xF3, 0xC1, 0xE7,
  0x80, 0xF3, 0xC1, 0xEF, 0x80, 0xF7, 0x81, 0xEF, 0x00, 0xF7, 0x01, 0xEF,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0x7F,
  0xFF, 0xC0, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 12, 36, 33, 11, -36 },
  { 55, 20, 17, 33, 10, -40 },
  { 98, 32, 36, 33, 1, -36 },
  { 242, 32, 44, 33, 1, -40 },
  { 418, 36, 38, 33, -1, -37 },
  { 589, 30, 38, 33, 0, -37 },
  { 732, 8, 17, 33, 16, -40 },
  { 749, 21, 51, 33, 8, -40 },
  { 883, 21, 51, 33, 4, -40 },
  { 1017, 20, 19, 33, 10, -40 },
  { 1065, 27, 28, 33, 3, -32 },
  { 1160, 15, 18, 33, 2, -8 },
  { 1194, 15, 4, 33, 9, -16 },
  { 1202, 8, 8, 33, 10, -8 },
  { 1210, 35, 41, 33, 0, -40 },
  { 1390, 28, 38, 33, 3, -37 },
  { 1523, 27, 36, 33, 1, -36 },
  { 1645, 30, 37, 33, 1, -37 },
  { 1784, 29, 38, 33, 2, -37 },
  { 1922, 28, 36, 33, 2, -36 },
  { 2048, 30, 37, 33, 2, -36 },
  { 2187, 27, 38, 33, 4, -37 },
  { 2316, 25, 36, 33, 8, -36 },
  { 2429, 29, 38, 33, 2, -37 },
  { 2567, 28, 38, 33, 3, -37 },
  { 2700, 12, 29, 33, 10, -29 },
  { 2744, 17, 39, 33, 5, -29 },
  { 2827, 27, 28, 33, 3, -32 },
  { 2922, 27, 18, 33, 3, -27 },
  { 2983, 27, 28, 33, 3, -32 },
  { 3078, 26, 37, 33, 5, -37 },
  { 3199, 34, 48, 33, 0, -40 },
  { 3403, 33, 36, 33, -3, -36 },
  { 3552, 29, 36, 33, 2, -36 },
  { 3683, 30, 38, 33, 3, -37 },
  { 3826, 30, 36, 33, 2, -36 },
  { 3961, 31, 36, 33, 2, -36 },
  { 4101, 31, 36, 33, 2, -36 },
  { 4241, 29, 38, 33, 3, -37 },
  { 4379, 31, 36, 33, 2, -36 },
  { 4519, 29, 36, 33, 3, -36 },
  { 4650, 27, 37, 33, 4, -36 },
  { 4775, 33, 36, 33, 2, -36 },
  { 4924, 24, 36, 33, 4, -36 },
  { 5032, 33, 36, 33, 1, -36 },
  { 5181, 31, 36, 33, 2, -36 },
  { 5321, 29, 38, 33, 3, -37 },
  { 5459, 30, 36, 33, 2, -36 },
  { 5594, 29, 48, 33, 3, -37 },
  { 5768, 31, 36, 33, 2, -36 },
  { 5908, 31, 38, 33, 1, -37 },
  { 6056, 30, 36, 33, 5, -36 },
  { 6191, 30, 37, 33, 3, -36 },
  { 6330, 33, 36, 33, 4, -36 },
  { 6479, 34, 36, 33, 3, -36 },
  { 6632, 37, 36, 33, -2, -36 },
  { 6799, 31, 36, 33, 5, -36 },
  { 6939, 35, 36, 33, -1, -36 },
  { 7097, 25, 51, 33, 6, -40 },
  { 7257, 19, 41, 33, 8, -40 },
  { 7355, 25, 51, 33, 2, -40 },
  { 7515, 26, 24, 33, 3, -36 },
  { 7593, 34, 3, 33, -4, 3 },
  { 7606, 11, 7, 33, 15, -39 },
  { 7616, 27, 31, 33, 2, -30 },
  { 7721, 28, 41, 33, 2, -40 },
  { 7865, 27, 31, 33, 3, -30 },
  { 7970, 30, 41, 33, 3, -40 },
  { 8124, 27, 31, 33, 3, -30 },
  { 8229, 28, 40, 33, 6, -40 },
  { 8369, 29, 41, 33, 2, -30 },
  { 8518, 27, 40, 33, 2, -40 },
  { 8653, 27, 40, 33, 1, -40 },
  { 8788, 29, 51, 33, -2, -40 },
  { 8973, 28, 40, 33, 4, -40 },
  { 9113, 27, 40, 33, 1, -40 },
  { 9248, 32, 30, 33, 0, -30 },
  { 9368, 27, 30, 33, 2, -30 },
  { 9470, 27, 31, 33, 3, -30 },
  { 9575, 30, 41, 33, 0, -30 },
  { 9729, 28, 41, 33, 3, -30 },
  { 9873, 26, 30, 33, 5, -30 },
  { 9971, 26, 31, 33, 3, -30 },
  { 10072, 22, 38, 33, 7, -37 },
  { 10177, 27, 30, 33, 4, -29 },
  { 10279, 29, 29, 33, 5, -29 },
  { 10385, 32, 29, 33, 3, -29 },
  { 10501, 33, 29, 33, 0, -29 },
  { 10621, 34, 40, 33, 0, -29 },
  { 10791, 30, 29, 33, 1, -29 },
  { 10900, 27, 51, 33, 6, -40 },
  { 11073, 5, 51, 33, 14, -40 },
  { 11105, 28, 51, 33, -1, -40 },
  { 11284, 28, 7, 33, 3, -22 },
};

const GFXfont LiberationMono_Italic55pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic55pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic55pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _LIBERATIONMONO_ITALIC55PT7B_H_
