#ifndef _LIBERATIONMONO_ITALIC31PT7B_H_
#define _LIBERATIONMONO_ITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3,
  0x06, 0x00, 0x00, 0x00, 0xE3, 0x87, 0x00, 0x70, 0xEE, 0x1D, 0xC7, 0xB0,
  0xEE, 0x1D, 0xC3, 0xB8, 0x76, 0x0C, 0xC1, 0x98, 0x30, 0x00, 0x60, 0xC0,
  0x08, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x06,
  0x04, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30,
  0x20, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x7F, 0x81, 0xFF, 0xE1, 0xE6, 0x78, 0xE3, 0x1C, 0xE1, 0x86,
  0x70, 0xC0, 0x38, 0xC0, 0x0F, 0x60, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x0C, 0x78, 0x06, 0x1C, 0x03, 0x0E, 0xC1, 0x87, 0x60, 0xC3, 0xB8,
  0x63, 0x9E, 0x63, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x0F, 0x80, 0x61, 0xFC, 0x0E, 0x38, 0xC1, 0xC3, 0x0C, 0x38, 0x30, 0xC3,
  0x07, 0x0C, 0x60, 0x61, 0xCC, 0x07, 0x19, 0x80, 0x3F, 0x30, 0x01, 0xE6,
  0x00, 0x00, 0xCF, 0x80, 0x19, 0xFC, 0x03, 0xB8, 0xC0, 0x73, 0x0C, 0x06,
  0x70, 0xC0, 0xC6, 0x0C, 0x18, 0x61, 0xC3, 0x07, 0x38, 0x60, 0x3F, 0x0C,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xE1, 0xC0, 0x60, 0xE0, 0x70,
  0x70, 0x38, 0x70, 0x1C, 0x70, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC1, 0x8E,
  0xE0, 0xCE, 0x30, 0x66, 0x1C, 0x67, 0x07, 0x73, 0x83, 0xB1, 0xC0, 0xF0,
  0xE0, 0x38, 0x78, 0x7E, 0x1F, 0xF7, 0xE7, 0xE0, 0xE0, 0x7B, 0x9C, 0xE7,
  0x31, 0x9C, 0xE6, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x62, 0x2E, 0xDE, 0xFF,
  0x87, 0x80, 0xB0, 0x36, 0x0C, 0x61, 0x08, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x07,
  0x07, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x00, 0xFF,
  0xFF, 0x80, 0x77, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x38,
  0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06, 0x63, 0xC6, 0xE3, 0xCE, 0xE3,
  0x8E, 0xE3, 0x8E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x30, 0x70, 0xF0, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x0F,
  0xE0, 0xFD, 0x81, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x81, 0xC3, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0xE0, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xC1, 0xC1, 0xC0,
  0xF1, 0xC0, 0x38, 0xE0, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x1C, 0x70, 0x1C, 0x3C, 0x1E, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xCC, 0x03,
  0x8C, 0x07, 0x1C, 0x06, 0x1C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x18, 0x60,
  0x38, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x33, 0xF0, 0x3F, 0xFC, 0x1F, 0x0F,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x39, 0xC0,
  0x1C, 0xF0, 0x1C, 0x3C, 0x3C, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xFE, 0x0F, 0x0E, 0x0C, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x73, 0xF0, 0x77, 0xF8, 0x7C, 0x3C, 0x70, 0x1C, 0xF0, 0x0C, 0xE0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x3F, 0xE0,
  0x1F, 0x80, 0x7F, 0xFD, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xC3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x3C, 0x1C, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0x07, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x1C, 0x70, 0x1C, 0x3C, 0x1C, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0xF8, 0x78, 0x79, 0xE0, 0x73, 0x80, 0xEE, 0x00, 0xDC, 0x01,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3C, 0xE0, 0xF9, 0xFF, 0x60, 0xF9, 0xC0,
  0x03, 0x80, 0x06, 0x70, 0x1C, 0xE0, 0x71, 0xE1, 0xC1, 0xFF, 0x01, 0xF8,
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x0E, 0x3C, 0x78, 0xF0, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x02, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xF0, 0x73, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0x07, 0x01, 0x80,
  0x60, 0x60, 0x0E, 0x18, 0x00, 0xC3, 0x1E, 0x58, 0xC7, 0xDB, 0x19, 0xCE,
  0x66, 0x70, 0xCC, 0xCC, 0x39, 0xB3, 0x06, 0x36, 0x60, 0xCC, 0xDC, 0x11,
  0x9B, 0x06, 0x36, 0x60, 0xCC, 0xCC, 0x31, 0x99, 0x8E, 0x63, 0x33, 0xCC,
  0x67, 0xDF, 0x0C, 0x71, 0xC1, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x40,
  0x38, 0x3C, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x38,
  0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0E, 0x06, 0x03, 0x80,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x70, 0x0F, 0xFC, 0x07, 0xFF,
  0x87, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x60, 0x1C, 0x70,
  0x3C, 0x3F, 0xF8, 0x1F, 0xFE, 0x0E, 0x07, 0x86, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x1E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x02, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xF0,
  0x38, 0x78, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x07,
  0x07, 0x83, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x38, 0x70, 0x38, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x06, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x1C, 0x78, 0x7C, 0x3F, 0xF0, 0x1F, 0x80,
  0x0E, 0x01, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87,
  0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00,
  0xE0, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70,
  0x60, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x70,
  0xE1, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x0E, 0x01, 0xC1, 0x80, 0x70, 0x70,
  0x1C, 0x0E, 0x0F, 0x01, 0xC3, 0xC0, 0x38, 0xF0, 0x06, 0x3C, 0x01, 0xCF,
  0x00, 0x3B, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0x70, 0x07, 0x8F,
  0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x03, 0x81, 0xC0, 0x60, 0x1C, 0x1C, 0x03,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F,
  0x87, 0xC3, 0xE1, 0xF8, 0x6C, 0x3B, 0x1F, 0x86, 0x63, 0x70, 0xCC, 0xCE,
  0x19, 0xB9, 0x87, 0x3E, 0x30, 0xE7, 0xCE, 0x18, 0x71, 0xC3, 0x0C, 0x38,
  0x60, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE1,
  0x80, 0x18, 0x70, 0x03, 0x00, 0x0E, 0x01, 0x83, 0xC0, 0x61, 0xF0, 0x38,
  0x7C, 0x0E, 0x1B, 0x03, 0x86, 0xE0, 0xC1, 0xB8, 0x30, 0xE6, 0x1C, 0x39,
  0xC7, 0x0E, 0x71, 0xC3, 0x1C, 0x60, 0xC3, 0x18, 0x70, 0xEE, 0x1C, 0x3B,
  0x87, 0x06, 0xE1, 0x81, 0xB0, 0x60, 0x7C, 0x38, 0x1F, 0x0E, 0x03, 0xC3,
  0x80, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x38, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38,
  0xF0, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0x01,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38,
  0x07, 0x1C, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xF0,
  0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0x01, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x0E, 0x38, 0x0E,
  0x1F, 0xFE, 0x0F, 0xFC, 0x06, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x60, 0x3C, 0x70, 0x0E, 0x38, 0x07, 0x9C, 0x01, 0xC0,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E,
  0x78, 0x1E, 0x1F, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70,
  0xE0, 0x38, 0x78, 0x38, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x03, 0xF8,
  0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x18, 0x03, 0x87, 0x01,
  0xC1, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0xC3, 0x80,
  0x38, 0xE0, 0x0E, 0x70, 0x03, 0x98, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x70, 0xE7, 0x1E,
  0x18, 0xE3, 0xC7, 0x1C, 0xF8, 0xE3, 0x9B, 0x18, 0x73, 0x67, 0x0C, 0xCC,
  0xE1, 0x99, 0x98, 0x36, 0x37, 0x06, 0xC6, 0xC0, 0xF0, 0xD8, 0x1E, 0x1F,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x07, 0x00, 0x70, 0x38, 0x07, 0x80,
  0xE0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x03, 0xB8,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0xE0,
  0x03, 0xB8, 0x03, 0x9C, 0x03, 0x87, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xC0,
  0x71, 0xC0, 0x39, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0xC0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0xC0, 0x1B, 0x00, 0xCC,
  0x07, 0x30, 0x18, 0xC0, 0xC3, 0x83, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x01,
  0x9C, 0x07, 0x60, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xE0, 0xE1, 0xC3, 0x86,
  0x03, 0xF8, 0x0F, 0xF8, 0x38, 0x78, 0xE0, 0x71, 0x80, 0xE0, 0x01, 0xC0,
  0x03, 0x83, 0xFE, 0x1F, 0xFC, 0x78, 0x39, 0xC0, 0x77, 0x00, 0xEE, 0x03,
  0x9C, 0x0F, 0x3C, 0x3E, 0x3F, 0xDF, 0x3E, 0x1E, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x7C, 0x1D, 0xFE,
  0x1F, 0x0E, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x78, 0x1C,
  0x78, 0x38, 0xEF, 0xF0, 0xE7, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x71,
  0xC0, 0x77, 0x00, 0xEE, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x01, 0xDC, 0x07, 0x3C, 0x1C, 0x3F, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x1F, 0x18, 0x3F, 0xFC, 0x3C, 0x3E, 0x1C, 0x0F, 0x1C,
  0x07, 0x8E, 0x03, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x18, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0F, 0x0F, 0x83, 0xFD,
  0xC0, 0xF8, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x77, 0x00,
  0xEE, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x01, 0x9C, 0x07, 0x1C, 0x3C, 0x3F, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0x01, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x7F,
  0xFE, 0xFF, 0xFC, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0xE3, 0x07,
  0xF9, 0x83, 0x87, 0xC3, 0x81, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE1, 0xE1, 0xF0, 0x7F, 0xB8, 0x1F, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x1C, 0x0E, 0x0F, 0x0F, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x7C,
  0x1D, 0xFE, 0x1F, 0x0E, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x06, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x81, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x07, 0x1C, 0x1E, 0x18, 0x3C, 0x18, 0x70, 0x38, 0xE0,
  0x39, 0xC0, 0x3B, 0x80, 0x37, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x71, 0xC0,
  0x71, 0xC0, 0x70, 0xE0, 0x60, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x19, 0xC7,
  0x86, 0xFB, 0xF1, 0xC7, 0x9C, 0x71, 0xC7, 0x38, 0x71, 0xCE, 0x18, 0x73,
  0x8E, 0x18, 0xC3, 0x86, 0x30, 0xE3, 0x9C, 0x30, 0xE7, 0x0C, 0x39, 0xC7,
  0x0C, 0x61, 0xC3, 0x18, 0x70, 0xCE, 0x18, 0x73, 0x86, 0x1C, 0xE1, 0x87,
  0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1F, 0x0E, 0x1E, 0x07, 0x1C, 0x07, 0x38,
  0x06, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0x03,
  0xF0, 0x1F, 0xF8, 0x70, 0x71, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x77, 0x00, 0xEE, 0x03, 0x9C,
  0x07, 0x3C, 0x3C, 0x3F, 0xF0, 0x1F, 0x80, 0x0E, 0x7E, 0x07, 0x7F, 0x83,
  0xE1, 0xC1, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x8C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xE0,
  0x70, 0xD0, 0x70, 0xEF, 0xF0, 0x73, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC6, 0x1F, 0xFE,
  0x3C, 0x3E, 0x38, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78,
  0xF0, 0xF8, 0x7F, 0xB0, 0x3E, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x7C, 0xE7, 0xF3, 0xBF, 0xCF,
  0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x71, 0xC0, 0x73, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0xCC, 0x01,
  0x98, 0x07, 0x38, 0x1C, 0x3F, 0xF0, 0x3F, 0x80, 0x04, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x70,
  0x07, 0xFC, 0x3F, 0x80, 0x38, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x73,
  0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B, 0x80,
  0x67, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x3C, 0x3E, 0x3F, 0xDC, 0x3E, 0x30,
  0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x60, 0x1C, 0x70, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x30, 0xE0, 0x39, 0xC0, 0x39, 0x80,
  0x3B, 0x80, 0x3B, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0xEE, 0x00, 0x19, 0xC0, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC3, 0xC7,
  0x18, 0x78, 0xE3, 0x1B, 0x18, 0x63, 0x67, 0x0C, 0xCC, 0xE1, 0x99, 0x98,
  0x36, 0x37, 0x06, 0xC6, 0xC0, 0xF0, 0xD8, 0x1E, 0x1F, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x70, 0x1C, 0x38,
  0x03, 0x9C, 0x00, 0xE6, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x07, 0x03, 0x81,
  0xC1, 0xC0, 0x38, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x01, 0xC0, 0xC0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0x80, 0x70,
  0x70, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x1C, 0xE0, 0x03, 0x98, 0x00, 0x77,
  0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0xC2, 0xC3, 0xFE, 0x00, 0x7C,
};

const GFXglyph LiberationMono_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 20, 19, 6, -20 },
  { 19, 11, 10, 19, 6, -23 },
  { 33, 19, 20, 19, 0, -20 },
  { 81, 17, 24, 19, 1, -22 },
  { 132, 20, 20, 19, 0, -20 },
  { 182, 17, 20, 19, 0, -20 },
  { 225, 5, 10, 19, 9, -23 },
  { 232, 11, 29, 19, 5, -23 },
  { 272, 12, 29, 19, 2, -23 },
  { 316, 11, 11, 19, 6, -23 },
  { 332, 15, 14, 19, 2, -17 },
  { 359, 9, 10, 19, 1, -5 },
  { 371, 9, 2, 19, 5, -9 },
  { 374, 4, 5, 19, 6, -5 },
  { 377, 20, 23, 19, 0, -23 },
  { 435, 16, 20, 19, 2, -20 },
  { 475, 15, 20, 19, 1, -20 },
  { 513, 17, 20, 19, 1, -20 },
  { 556, 17, 20, 19, 1, -20 },
  { 599, 16, 20, 19, 1, -20 },
  { 639, 17, 20, 19, 1, -20 },
  { 682, 16, 20, 19, 2, -20 },
  { 722, 15, 20, 19, 4, -20 },
  { 760, 17, 20, 19, 1, -20 },
  { 803, 15, 20, 19, 2, -20 },
  { 841, 7, 17, 19, 6, -17 },
  { 856, 10, 22, 19, 3, -17 },
  { 884, 15, 16, 19, 2, -18 },
  { 914, 15, 9, 19, 2, -14 },
  { 931, 15, 16, 19, 2, -18 },
  { 961, 15, 20, 19, 3, -20 },
  { 999, 19, 27, 19, 0, -23 },
  { 1064, 19, 20, 19, -2, -20 },
  { 1112, 17, 20, 19, 1, -20 },
  { 1155, 16, 20, 19, 2, -20 },
  { 1195, 17, 20, 19, 1, -20 },
  { 1238, 18, 20, 19, 1, -20 },
  { 1283, 18, 20, 19, 1, -20 },
  { 1328, 16, 20, 19, 2, -20 },
  { 1368, 18, 20, 19, 1, -20 },
  { 1413, 17, 20, 19, 1, -20 },
  { 1456, 15, 20, 19, 2, -20 },
  { 1494, 19, 20, 19, 1, -20 },
  { 1542, 14, 20, 19, 2, -20 },
  { 1577, 19, 20, 19, 0, -20 },
  { 1625, 18, 20, 19, 1, -20 },
  { 1670, 16, 20, 19, 2, -20 },
  { 1710, 17, 20, 19, 1, -20 },
  { 1753, 16, 26, 19, 2, -20 },
  { 1805, 17, 20, 19, 1, -20 },
  { 1848, 17, 20, 19, 1, -20 },
  { 1891, 17, 20, 19, 3, -20 },
  { 1934, 17, 20, 19, 2, -20 },
  { 1977, 18, 20, 19, 3, -20 },
  { 2022, 19, 20, 19, 2, -20 },
  { 2070, 21, 20, 19, -1, -20 },
  { 2123, 17, 20, 19, 3, -20 },
  { 2166, 19, 20, 19, 0, -20 },
  { 2214, 14, 29, 19, 3, -23 },
  { 2265, 10, 23, 19, 5, -23 },
  { 2294, 14, 29, 19, 1, -23 },
  { 2345, 14, 14, 19, 2, -20 },
  { 2370, 19, 1, 19, -2, 2 },
  { 2373, 6, 4, 19, 9, -22 },
  { 2376, 15, 17, 19, 1, -17 },
  { 2408, 16, 23, 19, 1, -23 },
  { 2454, 15, 17, 19, 2, -17 },
  { 2486, 17, 23, 19, 2, -23 },
  { 2535, 15, 17, 19, 2, -17 },
  { 2567, 16, 23, 19, 3, -23 },
  { 2613, 17, 23, 19, 1, -17 },
  { 2662, 16, 23, 19, 1, -23 },
  { 2708, 15, 23, 19, 1, -23 },
  { 2752, 16, 29, 19, -1, -23 },
  { 2810, 16, 23, 19, 2, -23 },
  { 2856, 16, 23, 19, 0, -23 },
  { 2902, 18, 17, 19, 0, -17 },
  { 2941, 16, 17, 19, 1, -17 },
  { 2975, 15, 17, 19, 2, -17 },
  { 3007, 17, 23, 19, 0, -17 },
  { 3056, 16, 23, 19, 2, -17 },
  { 3102, 14, 17, 19, 3, -17 },
  { 3132, 15, 17, 19, 2, -17 },
  { 3164, 12, 21, 19, 4, -21 },
  { 3196, 15, 17, 19, 2, -17 },
  { 3228, 16, 17, 19, 3, -17 },
  { 3262, 19, 17, 19, 1, -17 },
  { 3303, 18, 17, 19, 0, -17 },
  { 3342, 19, 23, 19, 0, -17 },
  { 3397, 16, 17, 19, 1, -17 },
  { 3431, 16, 29, 19, 3, -23 },
  { 3489, 3, 29, 19, 8, -23 },
  { 3500, 15, 29, 19, 0, -23 },
  { 3555, 16, 4, 19, 2, -12 },
};

const GFXfont LiberationMono_Italic31pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic31pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic31pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _LIBERATIONMONO_ITALIC31PT7B_H_
