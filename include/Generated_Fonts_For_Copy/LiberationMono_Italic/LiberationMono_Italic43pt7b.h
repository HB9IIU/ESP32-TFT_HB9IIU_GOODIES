#ifndef _LIBERATIONMONO_ITALIC43PT7B_H_
#define _LIBERATIONMONO_ITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x70,
  0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0x00,
  0x0C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x00, 0x30, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x03,
  0x80, 0x06, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE7, 0x3F,
  0x0F, 0x87, 0x0F, 0x0F, 0x07, 0x0F, 0x0E, 0x06, 0x07, 0x0E, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x7C,
  0x00, 0x18, 0x3C, 0x00, 0x18, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E,
  0x60, 0x38, 0x1C, 0xF0, 0x30, 0x3C, 0xF0, 0x30, 0x3C, 0xF8, 0x70, 0x78,
  0x7C, 0x71, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x70, 0x1F, 0xE0, 0x07, 0x01, 0xC3, 0x80, 0x70, 0x1C, 0x1C, 0x07, 0x00,
  0xE0, 0xE0, 0x78, 0x0E, 0x07, 0x03, 0x80, 0x70, 0x38, 0x38, 0x03, 0x81,
  0xC3, 0x80, 0x1C, 0x0E, 0x38, 0x00, 0xE0, 0xE3, 0x80, 0x07, 0x07, 0x38,
  0x00, 0x3C, 0x73, 0x80, 0x00, 0xFF, 0x38, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0x00, 0x3C, 0xFC, 0x00, 0x01, 0xCF, 0xF0, 0x00, 0x1C, 0xE3, 0xC0, 0x01,
  0xCE, 0x0E, 0x00, 0x1C, 0x70, 0x70, 0x01, 0xC7, 0x03, 0x80, 0x1C, 0x38,
  0x1C, 0x01, 0xC1, 0xC0, 0xE0, 0x1C, 0x0E, 0x0F, 0x01, 0xC0, 0x70, 0x70,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0x1E, 0x38, 0x0E, 0x00, 0x7F, 0x80, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0E, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0xC0, 0xFE, 0x01, 0xC7, 0xDE, 0x07, 0x0E, 0x3C,
  0x0E, 0x38, 0x38, 0x3C, 0xF0, 0x78, 0x71, 0xC0, 0x79, 0xE7, 0x80, 0xF3,
  0x8F, 0x00, 0xFE, 0x1E, 0x01, 0xFC, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xF0,
  0xFC, 0x1F, 0xFA, 0xFF, 0xFD, 0xFC, 0xFF, 0xE3, 0xF8, 0x7F, 0x01, 0xE0,
  0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0xCE, 0x38, 0xE0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x06, 0x18, 0x7F, 0x77, 0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0x80,
  0x1F, 0x80, 0x77, 0x01, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x08, 0x10, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xF7,
  0xDF, 0x7B, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0,
  0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x3B,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C,
  0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0E, 0xF0, 0x00, 0xF7, 0x00, 0x07, 0xB8,
  0x00, 0x39, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x07, 0xF9, 0xE0, 0x3F, 0x0E, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x0F, 0x83, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xF8, 0x3F,
  0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x00,
  0xE7, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xF0, 0x01, 0xC3, 0xC0, 0x0E, 0x0F,
  0x00, 0x70, 0x3C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1E, 0x07,
  0x00, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x79, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C,
  0x38, 0x00, 0xC3, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x1F,
  0xC0, 0xF3, 0xFF, 0x87, 0xBF, 0xFE, 0x3F, 0x81, 0xF1, 0xF0, 0x07, 0xDF,
  0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C,
  0x1F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF8, 0x1F, 0x07, 0x80, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xE0, 0x7C, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x07,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3E,
  0x00, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x3E,
  0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00,
  0x7C, 0x78, 0x03, 0xE1, 0xF0, 0x3F, 0x87, 0xFF, 0xDE, 0x0F, 0xFE, 0x78,
  0x0F, 0xE1, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE1, 0xC0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x7C, 0x1F, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3E,
  0x07, 0xE3, 0xE0, 0x0F, 0x3C, 0x00, 0x7D, 0xE0, 0x01, 0xFE, 0x00, 0x0E,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x03, 0xCE, 0xC1, 0x83,
  0xFB, 0x30, 0xE1, 0xC7, 0xCC, 0x30, 0xE1, 0xE3, 0x1C, 0x70, 0x78, 0xC6,
  0x38, 0x1E, 0x33, 0x8E, 0x07, 0x1C, 0xE7, 0x01, 0xC7, 0x31, 0xC0, 0x71,
  0xDC, 0x60, 0x38, 0x67, 0x38, 0x0E, 0x19, 0xCE, 0x03, 0x0E, 0x63, 0x81,
  0xC3, 0x19, 0xC0, 0x70, 0xCE, 0x70, 0x38, 0x73, 0x9C, 0x0E, 0x18, 0xE7,
  0x07, 0x8E, 0x39, 0xC3, 0x63, 0x0E, 0x39, 0xB9, 0x83, 0x8F, 0xEF, 0xC0,
  0xE1, 0xE1, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x80, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x80,
  0x7E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0x78, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0x83,
  0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x04,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0x07, 0x80,
  0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x3F, 0x07,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0x81, 0xFC, 0x07, 0x80,
  0x7E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x0F,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0x03, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00,
  0x0C, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xFF, 0x9E, 0x07, 0xFF, 0x3C, 0x0F, 0xFC,
  0x78, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xC7,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x3F,
  0x07, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x07,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C,
  0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x78, 0x01, 0xF0,
  0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xF3,
  0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0x70, 0x1F, 0xC1, 0xDC, 0x0E, 0xE0,
  0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0F, 0x78, 0x77, 0x83, 0xDE, 0x39,
  0xE0, 0xE3, 0x8E, 0x70, 0x38, 0xE7, 0x1C, 0x0E, 0x39, 0xC7, 0x07, 0x8E,
  0xE3, 0xC1, 0xE3, 0xB8, 0xF0, 0x70, 0xFC, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x03,
  0xE0, 0x07, 0x83, 0xF0, 0x03, 0x81, 0xF8, 0x01, 0xC0, 0xFC, 0x01, 0xE0,
  0x7F, 0x00, 0xF0, 0x3F, 0x80, 0x78, 0x3D, 0xC0, 0x38, 0x1E, 0xE0, 0x1C,
  0x0F, 0x78, 0x1E, 0x07, 0x3C, 0x0F, 0x03, 0x8E, 0x07, 0x83, 0xC7, 0x83,
  0x81, 0xE3, 0xC1, 0xC0, 0xF1, 0xE1, 0xE0, 0x70, 0x70, 0xF0, 0x38, 0x3C,
  0x78, 0x3C, 0x1E, 0x38, 0x1E, 0x07, 0x1C, 0x0F, 0x03, 0x9E, 0x07, 0x01,
  0xEF, 0x03, 0x80, 0xF7, 0x83, 0xC0, 0x3B, 0x81, 0xE0, 0x1F, 0xC0, 0xF0,
  0x0F, 0xE0, 0x70, 0x07, 0xF0, 0x38, 0x01, 0xF8, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0x07, 0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x8F,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0,
  0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00,
  0x1E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07,
  0xCF, 0x00, 0x0F, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x7E, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x3F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x1E, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0,
  0x78, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3E,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00,
  0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xF0, 0x07, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x1F,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF8, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x03, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xE0, 0x7E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x78, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78, 0x00,
  0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x38, 0x3C, 0x3F, 0x0F, 0x07,
  0x07, 0xE1, 0xE0, 0xE1, 0xDC, 0x38, 0x1C, 0x3B, 0x8F, 0x03, 0x87, 0x71,
  0xE0, 0x71, 0xCE, 0x38, 0x0E, 0x39, 0xCF, 0x01, 0xCE, 0x39, 0xE0, 0x39,
  0xC7, 0x38, 0x0F, 0x70, 0xE7, 0x01, 0xEE, 0x1D, 0xC0, 0x3F, 0x83, 0xB8,
  0x07, 0xF0, 0x77, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x80,
  0x07, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x80, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3E,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x39, 0xE0, 0x03,
  0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x78,
  0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0xC3, 0x80,
  0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x0E, 0x07, 0x00, 0x7F, 0x80,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07,
  0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x07, 0xF1, 0xF0,
  0xF7, 0x8F, 0xFF, 0x3F, 0xBF, 0xF1, 0xF8, 0xFC, 0x07, 0xC0, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0xC0, 0x79, 0xFF,
  0x83, 0xBF, 0xFC, 0x3D, 0xC1, 0xF1, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF3, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x3F, 0x00, 0xF1, 0xFC, 0x1F, 0x8F,
  0x7F, 0xF8, 0x7B, 0xFF, 0x03, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x7E, 0x0F, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0xFE, 0x3C, 0x03, 0xFF, 0x3C, 0x07, 0xFF, 0xBC, 0x0F, 0x81, 0xF8,
  0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x07, 0xE0, 0x7C, 0x1D, 0xC0,
  0x7F, 0xFB, 0xC0, 0x3F, 0xF3, 0xC0, 0x0F, 0xC3, 0xC0, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x7B, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x06, 0x1F, 0x00, 0x78, 0xFC,
  0x0F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x1C, 0x0F, 0xFC, 0xF0, 0x7F, 0xFB, 0xC3, 0xF0, 0xEF, 0x0F,
  0x01, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0,
  0x0F, 0x87, 0x80, 0x7E, 0x1F, 0x07, 0x78, 0x7F, 0xF9, 0xC0, 0xFF, 0xCF,
  0x00, 0xFC, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x0F, 0xC0, 0x79, 0xFF, 0x83, 0x9F, 0xFC, 0x3D, 0xC1, 0xF1,
  0xF8, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x78,
  0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xF9, 0xE0, 0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0,
  0x78, 0x07, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1F,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x3C, 0x1E, 0x07, 0x3F, 0x3F, 0x83, 0xBF, 0x9F, 0xE1,
  0xF1, 0xD8, 0xF0, 0xF0, 0xF8, 0x78, 0xF8, 0x78, 0x3C, 0x78, 0x3C, 0x1E,
  0x3C, 0x1E, 0x0E, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x07, 0x8F, 0x07, 0x83,
  0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x70,
  0x38, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0E, 0x1C, 0x0E,
  0x07, 0x0E, 0x07, 0x03, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0xC1,
  0xE0, 0xF0, 0x0E, 0x0F, 0xC0, 0x71, 0xFF, 0x83, 0x9F, 0xFC, 0x3D, 0xC1,
  0xF1, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F,
  0x83, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xFC, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC3, 0xF0, 0x07, 0x9F, 0xF8, 0x0E, 0x7F,
  0xF0, 0x3D, 0xC1, 0xF0, 0x7E, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xFC,
  0x1F, 0x83, 0xDF, 0xFE, 0x07, 0xBF, 0xF0, 0x0F, 0x1F, 0xC0, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFE, 0x3C, 0x0F, 0xFC, 0xF0, 0x7F, 0xFB, 0xC3, 0xE0, 0xFF, 0x1F,
  0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0x87, 0x80, 0x7E, 0x1F, 0x07, 0x70, 0x7F, 0xFB, 0xC0, 0xFF, 0xCF,
  0x00, 0xFC, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x07, 0xF1, 0xE3, 0xFF, 0x1E, 0x7F, 0xF1,
  0xEF, 0x00, 0x1E, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x01,
  0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x0F, 0x3C, 0x00, 0x70, 0xF0, 0x0F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x02, 0x1F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xF1, 0xF0, 0x77, 0x0F, 0xFF, 0x38,
  0x3F, 0xF1, 0xC0, 0xFE, 0x1E, 0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x03, 0xC0, 0xE3,
  0xC1, 0xF0, 0x78, 0xF0, 0x7C, 0x1C, 0x3C, 0x3B, 0x0F, 0x0F, 0x0C, 0xC3,
  0xC3, 0xC7, 0x38, 0xE0, 0xF1, 0xCE, 0x78, 0x3C, 0xE3, 0x9E, 0x0F, 0x38,
  0xE7, 0x03, 0xDC, 0x3B, 0xC0, 0xF7, 0x0E, 0xF0, 0x3F, 0x83, 0xB8, 0x0E,
  0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x00, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xF8, 0x19, 0xFF, 0xFF, 0xF3, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 9, 28, 26, 9, -28 },
  { 33, 16, 13, 26, 8, -31 },
  { 59, 25, 28, 26, 1, -28 },
  { 147, 24, 34, 26, 1, -31 },
  { 249, 29, 28, 26, -1, -28 },
  { 351, 23, 28, 26, 0, -28 },
  { 432, 6, 13, 26, 13, -31 },
  { 442, 17, 40, 26, 6, -31 },
  { 527, 16, 40, 26, 3, -31 },
  { 607, 15, 15, 26, 8, -31 },
  { 636, 21, 21, 26, 2, -25 },
  { 692, 12, 14, 26, 2, -6 },
  { 713, 12, 3, 26, 7, -12 },
  { 718, 6, 6, 26, 8, -6 },
  { 723, 27, 31, 26, 0, -31 },
  { 828, 21, 28, 26, 3, -28 },
  { 902, 21, 28, 26, 1, -28 },
  { 976, 23, 28, 26, 1, -28 },
  { 1057, 22, 28, 26, 2, -28 },
  { 1134, 22, 28, 26, 1, -28 },
  { 1211, 23, 28, 26, 2, -28 },
  { 1292, 21, 28, 26, 3, -28 },
  { 1366, 20, 28, 26, 6, -28 },
  { 1436, 22, 28, 26, 2, -28 },
  { 1513, 22, 28, 26, 2, -28 },
  { 1590, 10, 23, 26, 8, -23 },
  { 1619, 14, 31, 26, 4, -23 },
  { 1674, 21, 22, 26, 2, -25 },
  { 1732, 21, 14, 26, 2, -21 },
  { 1769, 21, 22, 26, 2, -25 },
  { 1827, 21, 28, 26, 4, -28 },
  { 1901, 26, 37, 26, 0, -31 },
  { 2022, 26, 28, 26, -2, -28 },
  { 2113, 24, 28, 26, 1, -28 },
  { 2197, 23, 28, 26, 2, -28 },
  { 2278, 24, 28, 26, 1, -28 },
  { 2362, 25, 28, 26, 1, -28 },
  { 2450, 24, 28, 26, 2, -28 },
  { 2534, 23, 28, 26, 2, -28 },
  { 2615, 25, 28, 26, 1, -28 },
  { 2703, 23, 28, 26, 2, -28 },
  { 2784, 21, 28, 26, 3, -28 },
  { 2858, 26, 28, 26, 1, -28 },
  { 2949, 19, 28, 26, 3, -28 },
  { 3016, 26, 28, 26, 0, -28 },
  { 3107, 25, 28, 26, 1, -28 },
  { 3195, 23, 28, 26, 2, -28 },
  { 3276, 24, 28, 26, 1, -28 },
  { 3360, 23, 37, 26, 2, -28 },
  { 3467, 25, 28, 26, 1, -28 },
  { 3555, 24, 28, 26, 1, -28 },
  { 3639, 23, 28, 26, 4, -28 },
  { 3720, 24, 28, 26, 2, -28 },
  { 3804, 26, 28, 26, 3, -28 },
  { 3895, 27, 28, 26, 2, -28 },
  { 3990, 28, 28, 26, -1, -28 },
  { 4088, 24, 28, 26, 4, -28 },
  { 4172, 28, 28, 26, -1, -28 },
  { 4270, 19, 40, 26, 5, -31 },
  { 4365, 15, 31, 26, 6, -31 },
  { 4424, 19, 40, 26, 2, -31 },
  { 4519, 21, 19, 26, 2, -28 },
  { 4569, 26, 2, 26, -3, 3 },
  { 4576, 8, 5, 26, 12, -30 },
  { 4581, 21, 23, 26, 2, -23 },
  { 4642, 21, 31, 26, 2, -31 },
  { 4724, 22, 23, 26, 2, -23 },
  { 4788, 24, 31, 26, 2, -31 },
  { 4881, 21, 23, 26, 2, -23 },
  { 4942, 22, 31, 26, 5, -31 },
  { 5028, 22, 32, 26, 2, -23 },
  { 5116, 21, 31, 26, 2, -31 },
  { 5198, 21, 31, 26, 1, -31 },
  { 5280, 22, 40, 26, -1, -31 },
  { 5390, 22, 31, 26, 3, -31 },
  { 5476, 21, 31, 26, 1, -31 },
  { 5558, 25, 23, 26, 0, -23 },
  { 5630, 21, 23, 26, 2, -23 },
  { 5691, 21, 23, 26, 2, -23 },
  { 5752, 23, 32, 26, 0, -23 },
  { 5844, 22, 32, 26, 2, -23 },
  { 5932, 20, 23, 26, 4, -23 },
  { 5990, 21, 23, 26, 2, -23 },
  { 6051, 17, 29, 26, 6, -29 },
  { 6113, 21, 23, 26, 3, -23 },
  { 6174, 23, 23, 26, 4, -23 },
  { 6241, 26, 23, 26, 2, -23 },
  { 6316, 26, 23, 26, 0, -23 },
  { 6391, 27, 32, 26, 0, -23 },
  { 6499, 23, 23, 26, 1, -23 },
  { 6566, 22, 40, 26, 4, -31 },
  { 6676, 4, 40, 26, 11, -31 },
  { 6696, 21, 40, 26, 0, -31 },
  { 6801, 23, 5, 26, 2, -17 },
};

const GFXfont LiberationMono_Italic43pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic43pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic43pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _LIBERATIONMONO_ITALIC43PT7B_H_
