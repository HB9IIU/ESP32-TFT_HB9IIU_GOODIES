#ifndef _LIBERATIONMONO_ITALIC27PT7B_H_
#define _LIBERATIONMONO_ITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x00, 0x00,
  0x18, 0x63, 0x80, 0x71, 0xDC, 0x76, 0x19, 0x8E, 0xE3, 0xB8, 0xCC, 0x33,
  0x0C, 0x00, 0x83, 0x01, 0x82, 0x01, 0x06, 0x01, 0x04, 0x03, 0x0C, 0x3F,
  0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x04, 0x10, 0x0C, 0x30, 0x08, 0x30, 0x7F,
  0xFE, 0xFF, 0xFE, 0x10, 0x60, 0x30, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x61,
  0x80, 0x00, 0x20, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0E, 0x6F, 0x1C,
  0x47, 0x18, 0x43, 0x18, 0xC0, 0x1C, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xBC, 0x01, 0x8E, 0x01, 0x8E, 0x01, 0x86, 0xE1, 0x8E, 0x61, 0x0C, 0x73,
  0x3C, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0x00, 0x02, 0x00, 0x0F, 0x01, 0x98,
  0xC1, 0x8C, 0x61, 0x8C, 0x31, 0x86, 0x19, 0x83, 0x0C, 0xC1, 0x8C, 0xC0,
  0xC6, 0xC0, 0x3C, 0xC0, 0x00, 0xDF, 0x00, 0xD8, 0xC0, 0xCC, 0x60, 0xCC,
  0x30, 0x46, 0x18, 0x63, 0x08, 0x61, 0x8C, 0x60, 0xC4, 0x60, 0x3C, 0x00,
  0x00, 0xF0, 0x07, 0xF0, 0x1C, 0x70, 0x30, 0x60, 0x61, 0x80, 0xC7, 0x01,
  0xB8, 0x03, 0xC0, 0x1F, 0x04, 0x76, 0x19, 0x8C, 0x33, 0x0C, 0xCC, 0x19,
  0x98, 0x1E, 0x30, 0x38, 0x70, 0xF8, 0x7F, 0xBC, 0x7C, 0x38, 0x77, 0x66,
  0xEC, 0xCC, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x04, 0x03, 0x00, 0xC1,
  0x36, 0xFF, 0x87, 0x03, 0xC1, 0xD8, 0x66, 0x11, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x1E, 0x1C, 0x38,
  0x38, 0x30, 0x60, 0x60, 0xC0, 0x7F, 0xFF, 0x77, 0xFE, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x37, 0x01,
  0xB0, 0x0D, 0x80, 0x7C, 0xE3, 0xC7, 0x1E, 0x39, 0xF0, 0x0F, 0x80, 0x6C,
  0x07, 0x60, 0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF0, 0x00, 0x00, 0x60,
  0x0F, 0x01, 0xF8, 0x7D, 0xC3, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xF1, 0xE1, 0xC6, 0x03, 0x38,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x03, 0xF0, 0x3F, 0xF1, 0xE1, 0xC6, 0x03, 0x38, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x1E, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1B, 0x80,
  0xEE, 0x03, 0x9C, 0x1C, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x01, 0xB8, 0x0C, 0xC0, 0x63, 0x03, 0x0C, 0x18, 0x70,
  0xC1, 0xC7, 0x06, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x3E, 0x0F, 0xFC, 0x38, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x1B, 0x80, 0xEE, 0x07, 0x1C, 0x38, 0x7F, 0xC0, 0x7E, 0x00,
  0x03, 0xE0, 0x7F, 0xC7, 0x0E, 0x30, 0x33, 0x00, 0x38, 0x01, 0x9F, 0x0D,
  0xFC, 0xF8, 0x77, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x3B, 0x81,
  0x8E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xE1, 0xC6, 0x03, 0x38, 0x0C, 0xE0, 0x33, 0x81, 0xC7, 0x0E, 0x0F,
  0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0xBC,
  0x1C, 0x7F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0x1E, 0x60, 0x77,
  0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x3B, 0x87, 0xCF, 0xEC, 0x3E,
  0x60, 0x07, 0x00, 0x33, 0x03, 0x1C, 0x38, 0xFF, 0x83, 0xF0, 0x00, 0x1C,
  0x73, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x73, 0xCE, 0x00, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x08, 0x00, 0x00, 0x18,
  0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x03, 0x00, 0x18, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x07, 0xE0, 0xFF,
  0xCE, 0x0E, 0xE0, 0x36, 0x01, 0xF0, 0x0C, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xC0, 0x60,
  0xC0, 0x30, 0xC7, 0x28, 0x64, 0x76, 0x66, 0x33, 0x36, 0x19, 0x32, 0x0C,
  0x9B, 0x0C, 0xCD, 0x86, 0x64, 0x83, 0x26, 0xC3, 0x13, 0x61, 0x99, 0xB1,
  0xC8, 0xC9, 0xC8, 0x67, 0x38, 0x30, 0x00, 0x18, 0x00, 0x06, 0x01, 0x03,
  0x83, 0x80, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xD8, 0x01, 0xD8, 0x01, 0x9C, 0x03, 0x1C, 0x03, 0x0C, 0x06, 0x0C,
  0x0E, 0x0C, 0x0C, 0x0E, 0x1F, 0xFE, 0x1F, 0xFE, 0x38, 0x0E, 0x30, 0x06,
  0x70, 0x06, 0xE0, 0x07, 0xC0, 0x07, 0x1F, 0xF0, 0x7F, 0xF1, 0x81, 0xC6,
  0x03, 0x38, 0x0C, 0xE0, 0x33, 0x81, 0xCC, 0x0E, 0x3F, 0xE1, 0xFF, 0xC7,
  0x03, 0x9C, 0x07, 0x60, 0x1D, 0x80, 0x7E, 0x01, 0xB8, 0x1E, 0xFF, 0xF3,
  0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x70, 0x19, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x33, 0x00, 0xCE, 0x07, 0x3C, 0x78, 0x7F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0xE1, 0x83, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03,
  0x30, 0x0D, 0xC0, 0x37, 0x01, 0xDC, 0x06, 0x60, 0x39, 0x80, 0xEE, 0x07,
  0x38, 0x78, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0xFF,
  0xF1, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x70, 0x19, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE1, 0xFB, 0x0F, 0xEC, 0x03, 0x30, 0x0C, 0xC0,
  0x33, 0x01, 0xCE, 0x07, 0x3C, 0x3C, 0x7F, 0xE0, 0xFC, 0x00, 0x1C, 0x06,
  0x30, 0x1C, 0x60, 0x38, 0xC0, 0x63, 0x80, 0xC7, 0x01, 0x8E, 0x07, 0x18,
  0x0E, 0x3F, 0xFC, 0xFF, 0xF1, 0xC0, 0x63, 0x81, 0xC6, 0x03, 0x8C, 0x07,
  0x38, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x60, 0x63, 0x87, 0x1C, 0x70, 0x7F, 0x01, 0xF0, 0x00,
  0x1C, 0x07, 0x18, 0x0E, 0x18, 0x1C, 0x18, 0x78, 0x38, 0xE0, 0x39, 0xC0,
  0x33, 0x80, 0x37, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x79, 0xC0, 0x71, 0xC0,
  0x60, 0xE0, 0x60, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xC0, 0x1C,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xEF, 0xFE, 0x0E, 0x07, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0xE1, 0x61,
  0xB1, 0xB0, 0xD9, 0xB8, 0x6C, 0xD8, 0x66, 0xCC, 0x33, 0x66, 0x18, 0xE3,
  0x0C, 0x73, 0x86, 0x31, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0,
  0x38, 0x60, 0x18, 0x70, 0x0C, 0x00, 0x1C, 0x06, 0x3C, 0x0C, 0x78, 0x38,
  0xF0, 0x63, 0xE0, 0xC6, 0xE1, 0x8C, 0xC3, 0x19, 0x8E, 0x33, 0x1C, 0xE7,
  0x31, 0x86, 0x63, 0x0C, 0xC6, 0x1B, 0x8C, 0x3F, 0x38, 0x3C, 0x60, 0x78,
  0xC0, 0xF1, 0x80, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0xE3,
  0x80, 0xC6, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x60, 0x0C, 0xC0, 0x3B, 0x80,
  0x77, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x18, 0x1C, 0x38, 0x70, 0x3F, 0xC0,
  0x3E, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x60, 0x78, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xCC, 0x03, 0x18, 0x0E, 0x30, 0x38, 0xFF, 0xE1, 0xFF, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xDC,
  0x03, 0xB8, 0x06, 0x60, 0x0C, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x03,
  0x9C, 0x07, 0x18, 0x1C, 0x38, 0x70, 0x3F, 0xC0, 0x3E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x60, 0x78, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0x18, 0x1E,
  0x3F, 0xF0, 0xFF, 0x81, 0xC7, 0x03, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x31, 0x80, 0x70, 0x03, 0xF0, 0x1F, 0xF8, 0x70,
  0x71, 0xC0, 0x73, 0x80, 0xE7, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xD8, 0x03, 0x30, 0x0E, 0x70,
  0x38, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x01,
  0x8C, 0x03, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x63, 0x00, 0xC6,
  0x03, 0x9C, 0x07, 0x38, 0x1C, 0x38, 0x70, 0x7F, 0xE0, 0x3F, 0x00, 0xE0,
  0x07, 0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x70, 0x18, 0x70,
  0x30, 0x30, 0x70, 0x30, 0x60, 0x30, 0xE0, 0x38, 0xC0, 0x39, 0xC0, 0x39,
  0x80, 0x1B, 0x80, 0x1B, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31,
  0x86, 0x18, 0xC7, 0x1C, 0x63, 0x8C, 0x33, 0x66, 0x19, 0xB7, 0x0D, 0x9B,
  0x06, 0xCD, 0x83, 0xC6, 0xC1, 0xE3, 0xC1, 0xA1, 0xE0, 0xF0, 0xF0, 0x70,
  0x70, 0x00, 0x0E, 0x01, 0xC1, 0x80, 0xE0, 0x70, 0x70, 0x0C, 0x18, 0x03,
  0x8C, 0x00, 0x67, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x0C, 0xC0, 0x06, 0x38, 0x03, 0x86, 0x01, 0xC1, 0xC0,
  0xE0, 0x70, 0x70, 0x0E, 0x18, 0x03, 0x80, 0xC0, 0x0D, 0xC0, 0x39, 0x80,
  0xE3, 0x83, 0x83, 0x0E, 0x07, 0x18, 0x0E, 0x60, 0x0D, 0xC0, 0x1F, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xFE, 0x0F, 0xE0, 0xC0,
  0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x07, 0xF0,
  0x7F, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0xFF, 0x0F,
  0xE0, 0x00, 0xE0, 0x0F, 0x00, 0xD8, 0x06, 0xC0, 0x62, 0x06, 0x18, 0x30,
  0xC3, 0x06, 0x18, 0x31, 0x80, 0xD8, 0x06, 0xC0, 0x30, 0xFF, 0xFF, 0x00,
  0xE3, 0x8C, 0x07, 0xE0, 0xFF, 0x87, 0x0E, 0x70, 0x70, 0x03, 0x80, 0x1C,
  0x3F, 0xC7, 0xFE, 0x78, 0x37, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x16, 0x7F,
  0x3D, 0xF1, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x67, 0xC1, 0xBF, 0x8F, 0x8E, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0xCC, 0x07,
  0x70, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xE3, 0x8F, 0xFE,
  0x33, 0xE0, 0x03, 0xF0, 0x3F, 0xE1, 0xC3, 0xCE, 0x07, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x18, 0x0E, 0x70,
  0x70, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0xF9, 0x83, 0xFB, 0x0E, 0x1E, 0x38, 0x3C, 0x60, 0x31,
  0xC0, 0x63, 0x80, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x70, 0x38, 0x60,
  0x70, 0xE1, 0xE1, 0xFF, 0xC1, 0xF3, 0x80, 0x07, 0xC0, 0xFF, 0x8E, 0x1C,
  0xE0, 0x66, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0xCE, 0x1E, 0x3F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xF0,
  0xF0, 0x03, 0x80, 0x0C, 0x03, 0xFF, 0xCF, 0xFF, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0xC7,
  0xCE, 0x0F, 0x30, 0x19, 0xC0, 0x67, 0x01, 0x98, 0x0E, 0x60, 0x39, 0x80,
  0xE6, 0x07, 0x18, 0x1C, 0x70, 0xB1, 0xFD, 0xC3, 0xE7, 0x00, 0x18, 0x00,
  0x63, 0x83, 0x8E, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0xF8, 0x6F, 0xE7, 0xC7, 0x38, 0x19, 0xC0,
  0xCC, 0x06, 0x60, 0x37, 0x03, 0xB8, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0xB8, 0x1D, 0xC0, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0xFF, 0x03,
  0xF8, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x63, 0x87, 0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x1F, 0x80, 0x7F,
  0x01, 0xDC, 0x06, 0x38, 0x18, 0xE0, 0xE1, 0xC3, 0x87, 0x0C, 0x0E, 0x30,
  0x38, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x07, 0xFF, 0xFF, 0xFE,
  0x1B, 0x8E, 0x37, 0xFE, 0x3D, 0xE7, 0x38, 0xC7, 0x30, 0xC6, 0x31, 0xC6,
  0x31, 0x86, 0x71, 0x86, 0x61, 0x8E, 0x61, 0x8C, 0x63, 0x8C, 0x63, 0x8C,
  0xE3, 0x0C, 0xE3, 0x1C, 0xC3, 0x1C, 0x19, 0xF0, 0xDF, 0xCF, 0x8E, 0x70,
  0x33, 0x81, 0x98, 0x0C, 0xC0, 0x6E, 0x07, 0x70, 0x3B, 0x01, 0x98, 0x0C,
  0xC0, 0x66, 0x03, 0x70, 0x3B, 0x81, 0xC0, 0x03, 0xE0, 0x3F, 0xE1, 0xC3,
  0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x76, 0x01, 0xD8, 0x06, 0x60, 0x1B, 0x80,
  0xE6, 0x03, 0x98, 0x1C, 0x70, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x0C, 0xF8,
  0x1B, 0xF8, 0x7C, 0x70, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x8C,
  0x06, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0xC7, 0x0F, 0xFE,
  0x19, 0xF0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0xC3, 0xCE, 0x0F, 0x30, 0x1D, 0xC0,
  0x66, 0x01, 0x98, 0x0E, 0x60, 0x39, 0x80, 0xEE, 0x07, 0x18, 0x1C, 0x70,
  0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x18, 0xF8, 0xDF, 0xC6, 0xC0, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0x06, 0x30, 0x33, 0x80,
  0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0x80, 0x0D, 0xC0, 0x66,
  0x07, 0x3F, 0xF0, 0xFE, 0x00, 0x18, 0x06, 0x01, 0x80, 0xE0, 0xFF, 0xFF,
  0xF3, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x00, 0xE0, 0x3F, 0xC7, 0xF0, 0x30, 0x19, 0x80, 0xDC, 0x0E, 0xE0, 0x76,
  0x03, 0x30, 0x19, 0x80, 0xDC, 0x0E, 0xE0, 0x76, 0x03, 0x30, 0x19, 0x81,
  0xCE, 0x16, 0x7F, 0xF1, 0xF3, 0x80, 0xE0, 0x0C, 0xC0, 0x39, 0x80, 0x63,
  0x81, 0xC7, 0x03, 0x0E, 0x0E, 0x0C, 0x38, 0x18, 0x60, 0x31, 0xC0, 0x73,
  0x00, 0xEE, 0x00, 0xD8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x60,
  0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x63, 0x8E, 0x63, 0x8C, 0xE6,
  0x8C, 0xE6, 0x9C, 0xEC, 0x98, 0xEC, 0xD8, 0xF8, 0xF8, 0xD8, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x1C, 0x07, 0x0C, 0x0E, 0x0E, 0x1C, 0x06,
  0x38, 0x07, 0x70, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06,
  0xE0, 0x0C, 0x60, 0x18, 0x70, 0x38, 0x30, 0x70, 0x38, 0xE0, 0x18, 0x38,
  0x03, 0x0C, 0x03, 0x86, 0x01, 0x83, 0x01, 0xC1, 0xC0, 0xC0, 0x60, 0xE0,
  0x30, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x07, 0x30, 0x01, 0x98, 0x00, 0xD8,
  0x00, 0x68, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x7F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x80, 0x3C,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xF8, 0x61,
  0xFE, 0x03, 0xE0,
};

const GFXglyph LiberationMono_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 18, 16, 5, -18 },
  { 15, 10, 8, 16, 5, -20 },
  { 25, 16, 18, 16, 0, -18 },
  { 61, 16, 22, 16, 0, -20 },
  { 105, 17, 18, 16, 0, -18 },
  { 144, 15, 18, 16, 0, -18 },
  { 178, 4, 8, 16, 8, -20 },
  { 182, 10, 26, 16, 4, -20 },
  { 215, 10, 26, 16, 2, -20 },
  { 248, 10, 10, 16, 5, -20 },
  { 261, 13, 14, 16, 2, -16 },
  { 284, 8, 9, 16, 1, -4 },
  { 293, 8, 2, 16, 4, -8 },
  { 295, 4, 4, 16, 5, -4 },
  { 297, 17, 20, 16, 0, -20 },
  { 340, 13, 18, 16, 2, -18 },
  { 370, 13, 18, 16, 1, -18 },
  { 400, 14, 18, 16, 1, -18 },
  { 432, 14, 18, 16, 1, -18 },
  { 464, 14, 18, 16, 1, -18 },
  { 496, 14, 18, 16, 1, -18 },
  { 528, 13, 18, 16, 2, -18 },
  { 558, 12, 18, 16, 4, -18 },
  { 585, 14, 18, 16, 1, -18 },
  { 617, 13, 18, 16, 2, -18 },
  { 647, 6, 15, 16, 5, -15 },
  { 659, 9, 20, 16, 2, -15 },
  { 682, 13, 14, 16, 2, -16 },
  { 705, 13, 8, 16, 2, -13 },
  { 718, 13, 14, 16, 2, -16 },
  { 741, 13, 18, 16, 2, -18 },
  { 771, 17, 24, 16, 0, -20 },
  { 822, 16, 18, 16, -1, -18 },
  { 858, 14, 18, 16, 1, -18 },
  { 890, 14, 18, 16, 2, -18 },
  { 922, 14, 18, 16, 1, -18 },
  { 954, 15, 18, 16, 1, -18 },
  { 988, 15, 18, 16, 1, -18 },
  { 1022, 14, 18, 16, 2, -18 },
  { 1054, 15, 18, 16, 1, -18 },
  { 1088, 15, 18, 16, 1, -18 },
  { 1122, 13, 18, 16, 2, -18 },
  { 1152, 16, 18, 16, 1, -18 },
  { 1188, 12, 18, 16, 2, -18 },
  { 1215, 17, 18, 16, 0, -18 },
  { 1254, 15, 18, 16, 1, -18 },
  { 1288, 15, 18, 16, 1, -18 },
  { 1322, 15, 18, 16, 1, -18 },
  { 1356, 15, 24, 16, 1, -18 },
  { 1401, 15, 18, 16, 1, -18 },
  { 1435, 15, 18, 16, 1, -18 },
  { 1469, 14, 18, 16, 3, -18 },
  { 1501, 15, 18, 16, 1, -18 },
  { 1535, 16, 18, 16, 2, -18 },
  { 1571, 17, 18, 16, 1, -18 },
  { 1610, 18, 18, 16, -1, -18 },
  { 1651, 15, 18, 16, 3, -18 },
  { 1685, 17, 18, 16, 0, -18 },
  { 1724, 12, 26, 16, 3, -20 },
  { 1763, 9, 20, 16, 4, -20 },
  { 1786, 12, 26, 16, 1, -20 },
  { 1825, 13, 12, 16, 1, -18 },
  { 1845, 17, 1, 16, -2, 2 },
  { 1848, 5, 3, 16, 8, -19 },
  { 1850, 13, 15, 16, 1, -15 },
  { 1875, 14, 20, 16, 1, -20 },
  { 1910, 14, 15, 16, 1, -15 },
  { 1937, 15, 20, 16, 1, -20 },
  { 1975, 13, 15, 16, 2, -15 },
  { 2000, 14, 20, 16, 3, -20 },
  { 2035, 14, 21, 16, 1, -15 },
  { 2072, 13, 20, 16, 1, -20 },
  { 2105, 14, 20, 16, 0, -20 },
  { 2140, 14, 26, 16, -1, -20 },
  { 2186, 14, 20, 16, 2, -20 },
  { 2221, 14, 20, 16, 0, -20 },
  { 2256, 16, 15, 16, 0, -15 },
  { 2286, 13, 15, 16, 1, -15 },
  { 2311, 14, 15, 16, 1, -15 },
  { 2338, 15, 21, 16, 0, -15 },
  { 2378, 14, 21, 16, 1, -15 },
  { 2415, 13, 15, 16, 2, -15 },
  { 2440, 13, 15, 16, 1, -15 },
  { 2465, 10, 19, 16, 4, -19 },
  { 2489, 13, 15, 16, 2, -15 },
  { 2514, 15, 15, 16, 2, -15 },
  { 2543, 16, 15, 16, 1, -15 },
  { 2573, 16, 15, 16, 0, -15 },
  { 2603, 17, 21, 16, 0, -15 },
  { 2648, 14, 15, 16, 1, -15 },
  { 2675, 13, 26, 16, 3, -20 },
  { 2718, 2, 26, 16, 7, -20 },
  { 2725, 13, 26, 16, 0, -20 },
  { 2768, 13, 4, 16, 2, -11 },
};

const GFXfont LiberationMono_Italic27pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic27pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic27pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _LIBERATIONMONO_ITALIC27PT7B_H_
