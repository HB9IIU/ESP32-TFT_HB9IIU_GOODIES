#ifndef _LIBERATIONMONO_ITALIC41PT7B_H_
#define _LIBERATIONMONO_ITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x78, 0x3C, 0x00, 0x7C, 0x3E, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x18,
  0x00, 0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x06, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00,
  0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xF1, 0x8F, 0x87, 0x87, 0x0F, 0x0E, 0x0E, 0x1E, 0x3C, 0x1C, 0x18, 0x78,
  0x30, 0x00, 0xF0, 0x60, 0x00, 0xF1, 0xC0, 0x01, 0xF3, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xE3,
  0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x06, 0x07, 0x98, 0x0C, 0x0E,
  0x70, 0x38, 0x1C, 0xF0, 0x70, 0x79, 0xF0, 0xE1, 0xE1, 0xF1, 0x8F, 0xC3,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x7F, 0x80, 0x38,
  0x1C, 0x70, 0x0E, 0x07, 0x07, 0x03, 0x80, 0xC0, 0xE0, 0xE0, 0x38, 0x1C,
  0x38, 0x07, 0x07, 0x07, 0x00, 0xE0, 0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0x03,
  0x83, 0x9C, 0x00, 0x70, 0xE7, 0x00, 0x0E, 0x3D, 0xC0, 0x00, 0xFF, 0x70,
  0x00, 0x0F, 0x9C, 0x7C, 0x00, 0x07, 0x3F, 0xC0, 0x00, 0xEE, 0x3C, 0x00,
  0x3B, 0x83, 0x80, 0x0E, 0x70, 0x70, 0x03, 0x8E, 0x0E, 0x00, 0xE3, 0x81,
  0xC0, 0x38, 0x70, 0x38, 0x0E, 0x0E, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0x60,
  0x38, 0x38, 0x1C, 0x07, 0x8E, 0x07, 0x00, 0x7F, 0x81, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x1E,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x01,
  0xC1, 0xE0, 0x07, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x18, 0x3F, 0xC0, 0x71, 0xE7, 0x03, 0x8E, 0x1E, 0x0E, 0x78, 0x38, 0x71,
  0xC0, 0xF1, 0xCF, 0x01, 0xCE, 0x38, 0x07, 0xB8, 0xE0, 0x0F, 0xC3, 0xC0,
  0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x07, 0xFD, 0x7F, 0xFD, 0xFC, 0xFF, 0xE3,
  0xF0, 0xFC, 0x07, 0x80, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9C, 0x73, 0xCF,
  0x38, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x18, 0x6F, 0xB7, 0xDF, 0xFF, 0x8F,
  0xF8, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x01, 0xE7, 0x07, 0x8F, 0x0E, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70,
  0x0C, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x7D, 0xEF, 0xBE, 0xFB, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x83,
  0xE0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x3C,
  0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xF0, 0xF8, 0xF7, 0x87, 0x87,
  0xBC, 0x7C, 0x3D, 0xC3, 0xE1, 0xCE, 0x1F, 0x1E, 0x70, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x3C, 0x01, 0xE1,
  0xE0, 0x1E, 0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x78, 0x0F, 0xC7, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x3C, 0x1E,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x39, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xE0, 0x0F,
  0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x8F, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x03, 0x80, 0x78, 0x38, 0x03, 0xC3, 0x80, 0x1E, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x71,
  0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0x7C, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x0F,
  0x80, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x87, 0xE0, 0x79, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x07, 0xC7, 0xC0, 0x3E,
  0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x87, 0xC1,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x81,
  0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xC0, 0x7C, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x00, 0xE3, 0x80,
  0x07, 0x3C, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1F, 0x81, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0,
  0xF8, 0x0F, 0x0F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1F,
  0x00, 0xF8, 0x7C, 0x1F, 0xC3, 0xFF, 0xDE, 0x0F, 0xFC, 0xE0, 0x1F, 0x87,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x0F, 0x87, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x7F, 0xFF, 0x1F, 0x81, 0xF7, 0xC0, 0x1E, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x07, 0x80, 0x0E,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x06, 0x07, 0x9D, 0x87, 0x0F, 0xEC, 0xC3, 0x0E, 0x36, 0x63,
  0x8E, 0x0E, 0x31, 0x8E, 0x07, 0x19, 0xC7, 0x03, 0x9C, 0xE7, 0x03, 0x8E,
  0x63, 0x81, 0xC6, 0x73, 0x80, 0xE3, 0x39, 0xC0, 0xE1, 0x98, 0xC0, 0x71,
  0xCC, 0xE0, 0x30, 0xC6, 0x70, 0x38, 0x67, 0x38, 0x1C, 0x73, 0x9C, 0x1C,
  0x31, 0xCE, 0x0E, 0x38, 0xE7, 0x0F, 0x18, 0x73, 0x8D, 0x98, 0x38, 0xFC,
  0xF8, 0x1C, 0x38, 0x78, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x01, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x3C,
  0x00, 0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x1C, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xE0, 0x1F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x38, 0x01, 0xE1, 0xE0, 0x1F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x81, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x80, 0x0F, 0x1E, 0x00, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x04, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x04, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x3C, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x78,
  0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xC1, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x01, 0xF0,
  0x3C, 0x0F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF8, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0C, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x1F, 0xF9, 0xE0, 0x7F, 0xC7, 0x81, 0xFF, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x81, 0xF8, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78,
  0x00, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0x00,
  0x1E, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x0E, 0x1F, 0x00, 0x07, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0xF0,
  0x03, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xB8, 0x3D, 0xC1, 0xDC, 0x1C,
  0xE1, 0xDE, 0x0E, 0x70, 0xEF, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x73, 0x83,
  0xCF, 0x71, 0xC1, 0xE3, 0xB1, 0xE0, 0xE1, 0xF8, 0xF0, 0x70, 0xF8, 0x70,
  0x38, 0x7C, 0x38, 0x1C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0xC0, 0x0E, 0x0F, 0x80, 0x1C, 0x1F, 0x80, 0x38, 0x3F,
  0x00, 0xF0, 0xFE, 0x01, 0xE1, 0xFC, 0x03, 0x83, 0xBC, 0x07, 0x07, 0x78,
  0x0E, 0x0E, 0x70, 0x3C, 0x1C, 0xE0, 0x78, 0x79, 0xE0, 0xE0, 0xF1, 0xC1,
  0xC1, 0xC3, 0x83, 0x83, 0x87, 0x0F, 0x07, 0x0F, 0x1E, 0x1E, 0x0E, 0x38,
  0x3C, 0x1C, 0x70, 0x70, 0x3C, 0xE0, 0xE0, 0x7B, 0xC1, 0xC0, 0x77, 0x87,
  0x80, 0xEF, 0x0F, 0x01, 0xFC, 0x1C, 0x03, 0xF8, 0x38, 0x03, 0xF0, 0x70,
  0x07, 0xE1, 0xE0, 0x0F, 0xC3, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1F,
  0x87, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C, 0x03, 0xF0, 0xF0,
  0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x1F,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xDE,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0x87, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C, 0x03, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x3E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xE3, 0xC0,
  0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0x03, 0xE0, 0x78, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x78, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x3C, 0x1E, 0x1C,
  0x1F, 0x07, 0x07, 0x07, 0xC1, 0xC1, 0xC3, 0xF0, 0xF0, 0x70, 0xFC, 0x38,
  0x1C, 0x37, 0x0E, 0x07, 0x1D, 0xC7, 0x81, 0xC6, 0x71, 0xC0, 0x73, 0x9C,
  0x70, 0x3C, 0xE7, 0x3C, 0x0F, 0x71, 0xCE, 0x03, 0xDC, 0x33, 0x80, 0xFE,
  0x0D, 0xE0, 0x3B, 0x83, 0x70, 0x0E, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x79,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xF0, 0x1E, 0x3E, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00,
  0x78, 0x70, 0x07, 0xC7, 0x80, 0x7E, 0x1E, 0x0E, 0xF0, 0xFF, 0xE7, 0xF7,
  0xFE, 0x3F, 0x0F, 0xC0, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x0F, 0xC0, 0x39, 0xFF, 0x83, 0xDF, 0xFC, 0x1F, 0xC1,
  0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xF0,
  0x1E, 0x1F, 0xC1, 0xF0, 0xFF, 0xFF, 0x07, 0x3F, 0xF0, 0x38, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0xF0, 0x03, 0xC3, 0xC0, 0x3E, 0x1F,
  0x03, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x78,
  0x07, 0xFE, 0xF0, 0x1F, 0xFD, 0xE0, 0x7C, 0x1F, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0,
  0x01, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x38, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x1F,
  0x81, 0xF0, 0x7E, 0x03, 0xFF, 0xDC, 0x03, 0xFF, 0x38, 0x03, 0xF8, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1E, 0x1F,
  0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x01, 0x87, 0x80, 0x3C, 0x7C, 0x0F,
  0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xF3,
  0xC1, 0xFF, 0xDE, 0x1F, 0x07, 0xF1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x38,
  0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0xC3, 0xC0, 0x7E, 0x1F, 0x0F, 0xF0, 0xFF, 0xF7, 0x03,
  0xFE, 0x38, 0x0F, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x0F,
  0x07, 0x80, 0x78, 0x3E, 0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x1F,
  0x80, 0xE7, 0xFE, 0x1E, 0xFF, 0xE1, 0xFC, 0x1F, 0x1F, 0x80, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38,
  0xF0, 0x03, 0x8E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x01, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0xF8, 0x70, 0x0F, 0x87, 0x80, 0xF8, 0x3C, 0x0F, 0x01, 0xE0,
  0xF0, 0x0E, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x7C,
  0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x70, 0x3C, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x70, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0E, 0x3C, 0x3C, 0x0E, 0xFC, 0x7E, 0x0F, 0xFE, 0xFF, 0x0F, 0x9F,
  0x8F, 0x1F, 0x0F, 0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0E, 0x0E, 0x1C, 0x1E,
  0x0E, 0x1C, 0x1E, 0x0E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x38, 0x1C,
  0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x38, 0x3C, 0x78, 0x38,
  0x3C, 0x70, 0x38, 0x38, 0x70, 0x78, 0x38, 0x70, 0x78, 0x38, 0xF0, 0x70,
  0x38, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x78, 0x0E, 0x1F, 0x81, 0xE7, 0xFE,
  0x1E, 0xFF, 0xE1, 0xFC, 0x1F, 0x1F, 0x80, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03, 0x8E,
  0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1F,
  0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x07, 0x78, 0x00,
  0x77, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x80, 0x78, 0x7C,
  0x1F, 0x83, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0x87, 0xE0,
  0x1E, 0x7F, 0xE0, 0x7B, 0xFF, 0x81, 0xFC, 0x1F, 0x07, 0xC0, 0x3C, 0x1F,
  0x00, 0xF0, 0x78, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x7C, 0x07, 0xC3, 0xF8,
  0x3E, 0x0F, 0xFF, 0xF0, 0x39, 0xFF, 0x80, 0xE1, 0xF8, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x78, 0x1F, 0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0x07, 0xE1, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0xC0, 0x7E, 0x1F, 0x07,
  0xF0, 0xFF, 0xF7, 0x03, 0xFF, 0x78, 0x0F, 0xE3, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0xE3,
  0x87, 0xFC, 0x71, 0xFF, 0x8E, 0x78, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1F,
  0x0E, 0x00, 0xF1, 0xE0, 0x07, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0x78,
  0x0F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x01, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x04, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0xF1,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x1E,
  0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x03,
  0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8E, 0x00,
  0x78, 0xE0, 0x0F, 0x8F, 0x01, 0xF8, 0xF8, 0x3F, 0x8F, 0xFF, 0x70, 0x7F,
  0xE7, 0x03, 0xF8, 0x70, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0F,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0xF0, 0x07, 0x83,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x03, 0x9E, 0x00,
  0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0,
  0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0xF8, 0x38, 0xF0, 0xDC, 0x78, 0xF1,
  0xDC, 0x70, 0xF1, 0x9C, 0x70, 0xF3, 0x9C, 0xF0, 0xF3, 0x1C, 0xE0, 0xE7,
  0x1C, 0xE0, 0xE6, 0x1D, 0xE0, 0xEE, 0x0D, 0xC0, 0xEC, 0x0D, 0xC0, 0xFC,
  0x0D, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xF3, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xC7, 0x00, 0x03, 0xC7, 0x80, 0x07,
  0x83, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x38, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x78,
  0x00, 0xE0, 0x38, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0,
  0xDF, 0xFF, 0xFE, 0xC0, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 27, 25, 8, -27 },
  { 32, 15, 13, 25, 8, -30 },
  { 57, 24, 27, 25, 1, -27 },
  { 138, 23, 33, 25, 1, -30 },
  { 233, 27, 27, 25, -1, -27 },
  { 325, 22, 27, 25, 0, -27 },
  { 400, 6, 13, 25, 12, -30 },
  { 410, 16, 39, 25, 6, -30 },
  { 488, 15, 39, 25, 3, -30 },
  { 562, 15, 15, 25, 7, -30 },
  { 591, 20, 21, 25, 2, -24 },
  { 644, 11, 13, 25, 2, -6 },
  { 662, 12, 3, 25, 6, -12 },
  { 667, 6, 6, 25, 8, -6 },
  { 672, 26, 30, 25, 0, -30 },
  { 770, 21, 27, 25, 2, -27 },
  { 841, 20, 27, 25, 1, -27 },
  { 909, 22, 27, 25, 1, -27 },
  { 984, 21, 27, 25, 2, -27 },
  { 1055, 21, 27, 25, 1, -27 },
  { 1126, 22, 27, 25, 2, -27 },
  { 1201, 20, 27, 25, 3, -27 },
  { 1269, 19, 27, 25, 6, -27 },
  { 1334, 21, 27, 25, 2, -27 },
  { 1405, 21, 27, 25, 2, -27 },
  { 1476, 9, 22, 25, 8, -22 },
  { 1501, 13, 29, 25, 4, -22 },
  { 1549, 20, 21, 25, 2, -24 },
  { 1602, 20, 13, 25, 2, -20 },
  { 1635, 20, 21, 25, 2, -24 },
  { 1688, 19, 27, 25, 4, -27 },
  { 1753, 25, 35, 25, 0, -30 },
  { 1863, 24, 27, 25, -2, -27 },
  { 1944, 22, 27, 25, 1, -27 },
  { 2019, 22, 27, 25, 2, -27 },
  { 2094, 23, 27, 25, 1, -27 },
  { 2172, 24, 27, 25, 1, -27 },
  { 2253, 23, 27, 25, 2, -27 },
  { 2331, 22, 27, 25, 2, -27 },
  { 2406, 23, 27, 25, 1, -27 },
  { 2484, 22, 27, 25, 2, -27 },
  { 2559, 20, 27, 25, 3, -27 },
  { 2627, 25, 27, 25, 1, -27 },
  { 2712, 18, 27, 25, 3, -27 },
  { 2773, 25, 27, 25, 0, -27 },
  { 2858, 23, 27, 25, 1, -27 },
  { 2936, 22, 27, 25, 2, -27 },
  { 3011, 23, 27, 25, 1, -27 },
  { 3089, 22, 36, 25, 2, -27 },
  { 3188, 23, 27, 25, 1, -27 },
  { 3266, 23, 27, 25, 1, -27 },
  { 3344, 22, 27, 25, 4, -27 },
  { 3419, 23, 27, 25, 2, -27 },
  { 3497, 25, 27, 25, 3, -27 },
  { 3582, 26, 27, 25, 2, -27 },
  { 3670, 27, 27, 25, -1, -27 },
  { 3762, 23, 27, 25, 4, -27 },
  { 3840, 26, 27, 25, -1, -27 },
  { 3928, 19, 39, 25, 4, -30 },
  { 4021, 14, 30, 25, 6, -30 },
  { 4074, 18, 39, 25, 2, -30 },
  { 4162, 20, 18, 25, 2, -27 },
  { 4207, 25, 2, 25, -3, 2 },
  { 4214, 7, 5, 25, 12, -29 },
  { 4219, 21, 22, 25, 1, -22 },
  { 4277, 21, 30, 25, 1, -30 },
  { 4356, 21, 22, 25, 2, -22 },
  { 4414, 23, 30, 25, 2, -30 },
  { 4501, 20, 22, 25, 2, -22 },
  { 4556, 22, 30, 25, 4, -30 },
  { 4639, 21, 30, 25, 2, -22 },
  { 4718, 20, 30, 25, 2, -30 },
  { 4793, 20, 30, 25, 1, -30 },
  { 4868, 21, 39, 25, -1, -30 },
  { 4971, 21, 30, 25, 3, -30 },
  { 5050, 20, 30, 25, 1, -30 },
  { 5125, 24, 22, 25, 0, -22 },
  { 5191, 20, 22, 25, 2, -22 },
  { 5246, 20, 22, 25, 2, -22 },
  { 5301, 22, 31, 25, 0, -22 },
  { 5387, 21, 31, 25, 2, -22 },
  { 5469, 19, 22, 25, 4, -22 },
  { 5522, 20, 22, 25, 2, -22 },
  { 5577, 17, 28, 25, 5, -28 },
  { 5637, 20, 22, 25, 3, -22 },
  { 5692, 22, 22, 25, 3, -22 },
  { 5753, 24, 22, 25, 2, -22 },
  { 5819, 24, 22, 25, 0, -22 },
  { 5885, 25, 31, 25, 0, -22 },
  { 5982, 22, 22, 25, 1, -22 },
  { 6043, 21, 39, 25, 4, -30 },
  { 6146, 3, 39, 25, 11, -30 },
  { 6161, 20, 39, 25, 0, -30 },
  { 6259, 21, 5, 25, 2, -16 },
};

const GFXfont LiberationMono_Italic41pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic41pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic41pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _LIBERATIONMONO_ITALIC41PT7B_H_
