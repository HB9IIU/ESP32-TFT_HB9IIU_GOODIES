#ifndef _LIBERATIONMONO_ITALIC30PT7B_H_
#define _LIBERATIONMONO_ITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x06, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x00, 0x71, 0xCE, 0x3B, 0x87, 0x70,
  0xEE, 0x19, 0xC3, 0x30, 0xE6, 0x1C, 0xC3, 0x00, 0x00, 0x40, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x40, 0x81, 0xFF, 0xFC,
  0xFF, 0xFF, 0x02, 0x04, 0x01, 0x83, 0x00, 0x40, 0x80, 0x30, 0x60, 0x7F,
  0xFF, 0x3F, 0xFF, 0xC1, 0x83, 0x00, 0x40, 0x80, 0x30, 0x60, 0x0C, 0x18,
  0x02, 0x0C, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00, 0xFF, 0x01,
  0xFF, 0xE1, 0xE6, 0x70, 0xC3, 0x1C, 0xE1, 0x0E, 0x71, 0x80, 0x38, 0xC0,
  0x0E, 0x60, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1B, 0xE0, 0x0C, 0x70, 0x06,
  0x18, 0x03, 0x0E, 0xC1, 0x86, 0x60, 0x87, 0x38, 0xC3, 0x9E, 0x67, 0x87,
  0xFF, 0x80, 0xFF, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x63, 0xF8,
  0x18, 0xE3, 0x06, 0x18, 0x61, 0x87, 0x0C, 0x60, 0xC3, 0x98, 0x18, 0x67,
  0x03, 0x9C, 0xC0, 0x3F, 0x30, 0x07, 0xCC, 0x00, 0x03, 0x3C, 0x00, 0xDF,
  0xC0, 0x33, 0x1C, 0x0C, 0xE3, 0x83, 0x98, 0x60, 0x63, 0x0C, 0x18, 0x61,
  0x86, 0x0C, 0x71, 0x81, 0xFC, 0x60, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xFE,
  0x03, 0x8E, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x3C, 0x07, 0xF0,
  0x07, 0xC0, 0x0F, 0x03, 0x3B, 0x83, 0x71, 0x86, 0x61, 0xC6, 0xE0, 0xCC,
  0xE0, 0xFC, 0xC0, 0x78, 0xE0, 0x78, 0xF0, 0xFC, 0x7F, 0xDF, 0x3F, 0x0F,
  0x77, 0x76, 0xEE, 0xEC, 0xC0, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x00, 0x03,
  0x00, 0xC0, 0x18, 0x23, 0x17, 0x6E, 0x7F, 0x03, 0x80, 0xF8, 0x33, 0x0E,
  0x70, 0x84, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x0F, 0x0F, 0x1E, 0x1C, 0x1C, 0x38, 0x30, 0x70,
  0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF8, 0x78, 0x70, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xDC, 0x03,
  0xB0, 0x07, 0x63, 0x8F, 0xC7, 0x1F, 0x8E, 0x37, 0x3C, 0x6C, 0x01, 0xD8,
  0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x70, 0xE1, 0xC1, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x3F, 0x07, 0xDC, 0x1C, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x0F, 0x0E, 0x07, 0x1C, 0x07, 0x18, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xFF, 0xFC, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x0F, 0x0C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C,
  0x70, 0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0x60, 0x0D, 0xC0, 0x33, 0x80, 0xE7, 0x03, 0x8E, 0x0E,
  0x18, 0x38, 0x30, 0x60, 0xE1, 0x81, 0xC6, 0x03, 0x9F, 0xFF, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x19, 0xF0, 0x3F, 0xFC, 0x3C, 0x1C, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x78, 0x7F, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x71, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x39, 0xF0, 0x7F, 0xF8, 0xF8, 0x73, 0xC0, 0x77, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0x60, 0x38, 0xE1, 0xE0,
  0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x0F, 0xF8, 0x0F, 0xF8, 0x1C,
  0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0,
  0x1C, 0x70, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x78,
  0x71, 0xC0, 0x63, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E,
  0xE0, 0x39, 0xE1, 0xB1, 0xFE, 0xE1, 0xF9, 0xC0, 0x03, 0x00, 0x0E, 0x60,
  0x18, 0xE0, 0x71, 0xE3, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x1C, 0xF3, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE, 0x38, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x70, 0x78, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0x80, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xE3,
  0x83, 0xDC, 0x07, 0xE0, 0x1F, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x3C, 0x38, 0x1C, 0x07, 0x06, 0x00, 0xC3, 0x00, 0x31, 0x87, 0x3C, 0x63,
  0xE9, 0x31, 0x8E, 0xCC, 0xC3, 0x32, 0x70, 0xCD, 0x98, 0x33, 0x6E, 0x18,
  0xDB, 0x06, 0x6C, 0xC1, 0x1B, 0x30, 0xC6, 0xCC, 0x73, 0x33, 0x3D, 0x8C,
  0xFB, 0xE3, 0x1C, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x81, 0xE0,
  0xE0, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x0C,
  0x01, 0xC3, 0x00, 0xE0, 0xE0, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0xC0, 0x18, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x03, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x07, 0x38, 0x0E, 0x38, 0x1C, 0x3F, 0xF8, 0x3F, 0xF8, 0x30,
  0x1E, 0x70, 0x0E, 0x70, 0x06, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0xE0,
  0x1E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x1E,
  0x1E, 0x1C, 0x0E, 0x38, 0x07, 0x70, 0x04, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x08, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x0F,
  0xF0, 0x1F, 0xFC, 0x1C, 0x1E, 0x1C, 0x0F, 0x1C, 0x07, 0x18, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x38, 0xE0, 0xF0, 0xFF,
  0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1E, 0x1E, 0x1C,
  0x0E, 0x38, 0x06, 0x70, 0x04, 0x70, 0x00, 0x70, 0x00, 0xE1, 0xFE, 0xE1,
  0xFC, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x18, 0xE0, 0x38, 0x70, 0x78, 0x3F, 0xF0, 0x1F, 0x80, 0x0C, 0x03, 0x8E,
  0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x06, 0x1C, 0x07, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0xE1, 0xE3, 0x81, 0xFF, 0x01, 0xF8, 0x00, 0x0C, 0x03,
  0xC7, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x70, 0x1C, 0x38, 0x06, 0x1C, 0x03,
  0x8E, 0x00, 0xE7, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xF7,
  0x80, 0x78, 0xE0, 0x1C, 0x3C, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0xE0, 0x3C,
  0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C,
  0x1F, 0x1F, 0x8F, 0xC6, 0xE3, 0x61, 0xB9, 0xD8, 0x66, 0x66, 0x19, 0xB3,
  0x8E, 0x6C, 0xE3, 0x9E, 0x30, 0xC7, 0x8C, 0x30, 0xC3, 0x0C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE3, 0x80,
  0x38, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0xC0, 0xC3, 0xE0, 0x61, 0xB0, 0x30,
  0xD8, 0x38, 0xEE, 0x1C, 0x77, 0x0C, 0x39, 0x86, 0x18, 0xC3, 0x0C, 0x73,
  0x8E, 0x39, 0xC7, 0x0C, 0xE3, 0x87, 0x61, 0x83, 0xB0, 0xC0, 0xD8, 0xE0,
  0x7C, 0x70, 0x3E, 0x38, 0x1E, 0x18, 0x07, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0x0E, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x0E, 0xE0, 0x0E,
  0x70, 0x0C, 0x70, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x3F, 0xE0, 0x0F, 0x80,
  0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0x03, 0xC3, 0x80, 0xF1, 0xC0, 0x38, 0xC0,
  0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x0F, 0x0F, 0xFE, 0x0F,
  0xFC, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0x0E, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x0E, 0xE0, 0x0E, 0x70,
  0x0C, 0x70, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x3F, 0xE0, 0x0F, 0xC0, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFF, 0x87, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x1E, 0x1F, 0xFE, 0x0F, 0xF8, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x1E, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x01, 0xFC, 0x07, 0xFE, 0x0E, 0x0F,
  0x1C, 0x07, 0x18, 0x03, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x80,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0xC0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x38, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xC0, 0x38, 0xE0, 0x70,
  0xE0, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x60, 0x01, 0xDC, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x70,
  0x38, 0x18, 0x0E, 0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x18, 0xE0, 0x07,
  0x38, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xCE, 0x18, 0x73, 0x8F, 0x1C, 0xE3, 0xC6, 0x31,
  0xB1, 0x8C, 0x6C, 0xE3, 0x33, 0x30, 0xCC, 0xCC, 0x37, 0x37, 0x0D, 0x8D,
  0x83, 0x63, 0x60, 0xF0, 0xF8, 0x3C, 0x3C, 0x0E, 0x0F, 0x03, 0x83, 0xC0,
  0x07, 0x00, 0x70, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x01, 0x87,
  0x00, 0x1C, 0x60, 0x00, 0xCE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0x98, 0x00, 0x31, 0xC0, 0x07,
  0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0x70, 0x70, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0x83, 0x83,
  0x81, 0xC3, 0x80, 0x73, 0x80, 0x39, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x36, 0x00,
  0xDC, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x06, 0x0C, 0x38, 0x38, 0xC0, 0x66,
  0x01, 0x98, 0x06, 0xC0, 0x1C, 0xFF, 0xFF, 0xC0, 0xF0, 0xC1, 0x83, 0x03,
  0xF0, 0x1F, 0xF8, 0x70, 0x71, 0xC0, 0x60, 0x00, 0xC0, 0x03, 0x81, 0xFF,
  0x1F, 0xFE, 0x78, 0x1C, 0xE0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C,
  0x37, 0x1F, 0xCF, 0x9F, 0x0F, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x3E, 0x0E, 0xFE, 0x1B, 0x0E, 0x38, 0x1C,
  0xF0, 0x19, 0xC0, 0x33, 0x80, 0xE6, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70,
  0x0C, 0xE0, 0x39, 0xC0, 0xE3, 0xC3, 0xCE, 0xFF, 0x1C, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0xE1, 0xC3, 0xCE, 0x07, 0x70, 0x0D, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x3B, 0xC1, 0xC7,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x07, 0xCE, 0x1F, 0xEE, 0x3C, 0x3C, 0x38, 0x1C, 0x70,
  0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xC0,
  0x38, 0xC0, 0x78, 0xE0, 0x70, 0xE1, 0xB0, 0xFF, 0x70, 0x3E, 0x70, 0x03,
  0xE0, 0x3F, 0xE1, 0xC3, 0xCE, 0x07, 0x70, 0x0D, 0xC0, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x33, 0xC1, 0xC7,
  0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0xE7, 0x0F, 0xF7, 0x1E, 0x1E, 0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70,
  0x3C, 0x70, 0xD8, 0x3F, 0x98, 0x1F, 0x38, 0x00, 0x38, 0x00, 0x30, 0xE0,
  0x70, 0xF0, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x3E, 0x0E, 0xFE, 0x1B, 0x0E,
  0x38, 0x1C, 0xF0, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xCC, 0x03, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x00, 0xCE, 0x03, 0x9C, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x81, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x0E, 0x18, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x38, 0xE0, 0x39, 0xC0,
  0x33, 0x80, 0x37, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x71, 0xC0, 0x71, 0xC0,
  0x60, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x38, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFF, 0xEF,
  0xFF, 0xC0, 0x19, 0xC7, 0x8D, 0xF7, 0xC7, 0x3C, 0x67, 0x0E, 0x33, 0x8E,
  0x19, 0xC7, 0x1C, 0xC3, 0x8E, 0x61, 0x87, 0x70, 0xC3, 0x38, 0xE1, 0x9C,
  0x70, 0xCC, 0x38, 0xE6, 0x18, 0x77, 0x0C, 0x33, 0x86, 0x19, 0xC7, 0x0C,
  0x1C, 0xF8, 0x33, 0xFC, 0x6C, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0x98, 0x07, 0x30, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xCC, 0x03, 0x38, 0x0E, 0x70, 0x1C, 0x07, 0xF0, 0x3F, 0xE3, 0xC3, 0xCE,
  0x07, 0x70, 0x0D, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xB8, 0x0E, 0xE0, 0x73, 0xC3, 0xC7, 0xFC, 0x07, 0xC0, 0x0E, 0x7C,
  0x0E, 0xFE, 0x0D, 0x87, 0x0E, 0x07, 0x1E, 0x03, 0x1C, 0x03, 0x1C, 0x07,
  0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x1C,
  0x3C, 0x3C, 0x77, 0xF8, 0x73, 0xE0, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xCE, 0x3F, 0xDC, 0xF0, 0xF1,
  0xC0, 0xE7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x19, 0xC0,
  0x73, 0x00, 0xE6, 0x03, 0xCE, 0x07, 0x1C, 0x36, 0x3F, 0xDC, 0x1F, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0xFC, 0xE7, 0xF3, 0xB0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x30,
  0x00, 0xE0, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0xC0, 0x33, 0x81, 0xCF, 0xFE, 0x0F, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0x7F,
  0xC3, 0xF8, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x31, 0x80, 0x67, 0x01, 0xCE,
  0x03, 0x9C, 0x07, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x07, 0x1C, 0x16, 0x3F, 0xCC, 0x3F, 0x38, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0,
  0x70, 0xC0, 0x71, 0xC0, 0x33, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x19, 0x80,
  0x0E, 0x61, 0xC3, 0x98, 0x70, 0xC6, 0x3C, 0x71, 0x8D, 0x18, 0x66, 0x66,
  0x19, 0x9B, 0x86, 0xC6, 0xC1, 0xB1, 0xB0, 0x78, 0x7C, 0x1E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x1C, 0x03, 0x83, 0x81, 0xC0, 0x60, 0x60, 0x1C,
  0x38, 0x03, 0x1C, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x07,
  0x01, 0xC3, 0x80, 0x38, 0x18, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E,
  0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x06,
  0x18, 0x00, 0xC7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x1F,
  0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01,
  0xFF, 0x0E, 0x0F, 0xF8, 0x07, 0xC0,
};

const GFXglyph LiberationMono_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 7, 20, 18, 6, -20 },
  { 19, 11, 9, 18, 6, -22 },
  { 32, 18, 20, 18, 0, -20 },
  { 77, 17, 24, 18, 1, -22 },
  { 128, 19, 20, 18, 0, -20 },
  { 176, 16, 20, 18, 0, -20 },
  { 216, 4, 9, 18, 9, -22 },
  { 221, 11, 28, 18, 5, -22 },
  { 260, 11, 28, 18, 2, -22 },
  { 299, 11, 11, 18, 5, -22 },
  { 315, 14, 14, 18, 2, -17 },
  { 340, 8, 10, 18, 1, -4 },
  { 350, 8, 2, 18, 5, -9 },
  { 352, 4, 4, 18, 6, -4 },
  { 354, 19, 22, 18, 0, -22 },
  { 407, 15, 20, 18, 2, -20 },
  { 445, 14, 20, 18, 1, -20 },
  { 480, 16, 20, 18, 1, -20 },
  { 520, 16, 20, 18, 1, -20 },
  { 560, 15, 20, 18, 1, -20 },
  { 598, 16, 20, 18, 1, -20 },
  { 638, 15, 20, 18, 2, -20 },
  { 676, 14, 20, 18, 4, -20 },
  { 711, 16, 20, 18, 1, -20 },
  { 751, 15, 20, 18, 2, -20 },
  { 789, 6, 16, 18, 6, -16 },
  { 801, 9, 22, 18, 3, -16 },
  { 826, 14, 15, 18, 2, -17 },
  { 853, 14, 9, 18, 2, -14 },
  { 869, 14, 15, 18, 2, -17 },
  { 896, 14, 20, 18, 3, -20 },
  { 931, 18, 26, 18, 0, -22 },
  { 990, 18, 20, 18, -2, -20 },
  { 1035, 16, 20, 18, 1, -20 },
  { 1075, 16, 20, 18, 2, -20 },
  { 1115, 16, 20, 18, 1, -20 },
  { 1155, 17, 20, 18, 1, -20 },
  { 1198, 17, 20, 18, 1, -20 },
  { 1241, 16, 20, 18, 2, -20 },
  { 1281, 17, 20, 18, 1, -20 },
  { 1324, 16, 20, 18, 1, -20 },
  { 1364, 15, 20, 18, 2, -20 },
  { 1402, 18, 20, 18, 1, -20 },
  { 1447, 13, 20, 18, 2, -20 },
  { 1480, 18, 20, 18, 0, -20 },
  { 1525, 17, 20, 18, 1, -20 },
  { 1568, 16, 20, 18, 1, -20 },
  { 1608, 17, 20, 18, 1, -20 },
  { 1651, 16, 26, 18, 1, -20 },
  { 1703, 17, 20, 18, 1, -20 },
  { 1746, 16, 20, 18, 1, -20 },
  { 1786, 16, 20, 18, 3, -20 },
  { 1826, 16, 20, 18, 2, -20 },
  { 1866, 18, 20, 18, 2, -20 },
  { 1911, 18, 20, 18, 2, -20 },
  { 1956, 20, 20, 18, -1, -20 },
  { 2006, 17, 20, 18, 3, -20 },
  { 2049, 19, 20, 18, 0, -20 },
  { 2097, 14, 28, 18, 3, -22 },
  { 2146, 11, 22, 18, 4, -22 },
  { 2177, 14, 28, 18, 1, -22 },
  { 2226, 14, 13, 18, 2, -20 },
  { 2249, 18, 1, 18, -2, 2 },
  { 2252, 6, 4, 18, 8, -22 },
  { 2255, 15, 16, 18, 1, -16 },
  { 2285, 15, 22, 18, 1, -22 },
  { 2327, 14, 16, 18, 2, -16 },
  { 2355, 16, 22, 18, 2, -22 },
  { 2399, 14, 16, 18, 2, -16 },
  { 2427, 16, 22, 18, 3, -22 },
  { 2471, 16, 22, 18, 1, -16 },
  { 2515, 15, 22, 18, 1, -22 },
  { 2557, 14, 22, 18, 1, -22 },
  { 2596, 16, 28, 18, -1, -22 },
  { 2652, 16, 22, 18, 2, -22 },
  { 2696, 15, 22, 18, 0, -22 },
  { 2738, 17, 16, 18, 0, -16 },
  { 2772, 15, 16, 18, 1, -16 },
  { 2802, 14, 16, 18, 2, -16 },
  { 2830, 16, 22, 18, 0, -16 },
  { 2874, 15, 22, 18, 2, -16 },
  { 2916, 14, 16, 18, 3, -16 },
  { 2944, 14, 16, 18, 2, -16 },
  { 2972, 12, 20, 18, 4, -20 },
  { 3002, 15, 16, 18, 2, -16 },
  { 3032, 16, 16, 18, 3, -16 },
  { 3064, 18, 16, 18, 1, -16 },
  { 3100, 18, 16, 18, 0, -16 },
  { 3136, 19, 22, 18, 0, -16 },
  { 3189, 16, 16, 18, 1, -16 },
  { 3221, 15, 28, 18, 3, -22 },
  { 3274, 2, 28, 18, 8, -22 },
  { 3281, 15, 28, 18, 0, -22 },
  { 3334, 15, 4, 18, 2, -12 },
};

const GFXfont LiberationMono_Italic30pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic30pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic30pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _LIBERATIONMONO_ITALIC30PT7B_H_
