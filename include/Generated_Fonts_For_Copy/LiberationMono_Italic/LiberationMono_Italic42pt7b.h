#ifndef _LIBERATIONMONO_ITALIC42PT7B_H_
#define _LIBERATIONMONO_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0x7C, 0x1E, 0xF8, 0x7D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C,
  0x0F, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x03, 0x8E, 0x07,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0,
  0x30, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xE0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x06, 0x01,
  0x80, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0C, 0x07,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xC7, 0x3E, 0x0F, 0x06,
  0x1F, 0x0F, 0x06, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x00, 0x1E, 0x0E,
  0x00, 0x0F, 0x0C, 0x00, 0x0F, 0xCC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1B, 0xF8, 0x00, 0x18, 0xFC, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x60, 0x30,
  0x3C, 0xF0, 0x30, 0x3C, 0xF0, 0x70, 0x78, 0xF8, 0x70, 0xF8, 0x7C, 0x73,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x3F,
  0xC0, 0x0E, 0x07, 0x1E, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x0E, 0x1C, 0x01, 0xC0, 0xE3, 0x80, 0x1C,
  0x1C, 0x70, 0x01, 0xC1, 0xC7, 0x00, 0x1C, 0x38, 0xE0, 0x01, 0xC3, 0x9C,
  0x00, 0x0F, 0xF3, 0x80, 0x00, 0x7C, 0x70, 0x00, 0x00, 0x0E, 0x3F, 0x00,
  0x01, 0xCF, 0xF8, 0x00, 0x39, 0xE3, 0x80, 0x03, 0x9C, 0x3C, 0x00, 0x73,
  0x81, 0xC0, 0x0E, 0x38, 0x1C, 0x01, 0xC3, 0x83, 0x80, 0x38, 0x78, 0x38,
  0x07, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x87, 0x01, 0xC0,
  0x38, 0xF0, 0x38, 0x03, 0xFE, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xC3, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03,
  0x87, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x80, 0xFE,
  0x03, 0x87, 0xDC, 0x07, 0x1E, 0x3C, 0x1E, 0x38, 0x78, 0x38, 0xF0, 0x78,
  0xF1, 0xC0, 0xF1, 0xC7, 0x80, 0xF7, 0x0F, 0x00, 0xFE, 0x1C, 0x01, 0xF8,
  0x3C, 0x01, 0xF0, 0x78, 0x07, 0xE0, 0xF8, 0x3F, 0xF2, 0xFF, 0xFB, 0xFC,
  0xFF, 0xE3, 0xF0, 0x7E, 0x01, 0xE0, 0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x04, 0x38, 0x5F, 0x67, 0xBF, 0xFF, 0x1F, 0xF8, 0x0F, 0x80, 0x1B,
  0x00, 0x67, 0x01, 0x86, 0x06, 0x0E, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x7D, 0xF7, 0xFE, 0xFB, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE,
  0x1F, 0x0F, 0x78, 0x7C, 0x39, 0xE1, 0xF1, 0xE7, 0x8F, 0x87, 0x9E, 0x3E,
  0x1E, 0x70, 0x00, 0x79, 0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0x70, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x3E,
  0x1F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xB8, 0x07,
  0xFB, 0xC0, 0x3F, 0x1E, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x83, 0xE0,
  0x3C, 0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF8, 0x3E, 0x07, 0x80, 0x7C, 0x3C,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3E, 0x00, 0xF0, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C,
  0x00, 0x38, 0xF0, 0x01, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x78, 0x03,
  0x81, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1E, 0x07, 0x00, 0x70, 0x38, 0x03,
  0xC1, 0xC0, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE7,
  0xF0, 0x07, 0x7F, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xC0, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x01,
  0xF0, 0xFC, 0x0F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC3, 0xE0, 0x78,
  0x0F, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x1F, 0x80, 0xF3, 0xFF, 0x07, 0xBF, 0xFC, 0x3B, 0x83,
  0xF1, 0xF0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0xF0, 0x7C, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x3C,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3E, 0x00, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0,
  0x7E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x7F, 0x87, 0xFF, 0xDC, 0x0F, 0xFC,
  0xF0, 0x0F, 0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1,
  0xC0, 0x0F, 0x07, 0x00, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xF0, 0x3E, 0x3C, 0x01, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xC1,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0x06, 0x07, 0x8D, 0xC3, 0x87, 0xF7, 0x70,
  0xC3, 0xCD, 0x9C, 0x71, 0xC1, 0xE7, 0x18, 0x60, 0x79, 0xCE, 0x38, 0x1C,
  0x63, 0x9C, 0x07, 0x18, 0xC7, 0x03, 0x86, 0x71, 0x80, 0xE3, 0x9C, 0xE0,
  0x38, 0xE7, 0x38, 0x1C, 0x31, 0x8C, 0x07, 0x0C, 0x67, 0x01, 0x87, 0x39,
  0xC0, 0xE1, 0x8E, 0x70, 0x38, 0xE3, 0x9C, 0x1C, 0x30, 0xE7, 0x0F, 0x1C,
  0x39, 0xC6, 0xCE, 0x0E, 0x3F, 0x3F, 0x03, 0x87, 0x87, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x04, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C, 0x03,
  0xF0, 0x78, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xF0, 0x0F, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0xFC, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x03,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x7C, 0x03,
  0xC1, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0C, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0x0F, 0x80, 0x07, 0x8F, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x3C, 0x03, 0xE0, 0x78, 0x1F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07,
  0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x07, 0x8F, 0x00, 0x08,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xFF, 0x1E, 0x07, 0xFE, 0x3C, 0x0F, 0xFC, 0xF8,
  0x00, 0x79, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x3E, 0x00, 0xF0, 0x3E, 0x07,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x81, 0xE0, 0xFC, 0x3C, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xE3, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xF0, 0x1B, 0x81, 0xDC, 0x0F, 0xE0, 0x77, 0x07, 0x78, 0x3D, 0xC1,
  0xDC, 0x0F, 0x70, 0xE7, 0x03, 0x9C, 0x39, 0xC0, 0xE7, 0x9C, 0xF0, 0x39,
  0xE7, 0x3C, 0x1E, 0x3B, 0x8E, 0x07, 0x8E, 0xE3, 0x81, 0xC3, 0xF0, 0xE0,
  0x70, 0xFC, 0x78, 0x1C, 0x3E, 0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC1, 0xC1,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0xE0, 0x0F,
  0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x0F, 0xF0, 0x1E,
  0x0F, 0xF0, 0x1E, 0x0F, 0x70, 0x1E, 0x0E, 0x70, 0x1C, 0x0E, 0x78, 0x1C,
  0x0E, 0x78, 0x1C, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1C, 0x3C, 0x3C,
  0x1C, 0x3C, 0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x78,
  0x38, 0x1E, 0x78, 0x38, 0x0E, 0x70, 0x38, 0x0F, 0x70, 0x78, 0x0F, 0x70,
  0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xF8, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1F, 0x01, 0xF0,
  0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x7E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x7C, 0x1E, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x3E, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0x8F,
  0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0x80, 0x3F, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E,
  0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x38, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x03, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x1F, 0x03, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0xF8, 0x7E, 0x03, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xF3,
  0xC0, 0x00, 0x79, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0E, 0x1E, 0x0F, 0x03, 0x87, 0x03, 0xC1, 0xE1,
  0xC1, 0xF0, 0x70, 0x70, 0x7C, 0x1C, 0x1C, 0x3B, 0x0F, 0x07, 0x0E, 0xC3,
  0x81, 0xC7, 0x30, 0xE0, 0x71, 0xCE, 0x78, 0x1C, 0xE3, 0x9C, 0x07, 0x38,
  0xE7, 0x03, 0xDC, 0x3B, 0xC0, 0xF7, 0x0E, 0xE0, 0x3D, 0xC3, 0xB8, 0x0F,
  0xE0, 0xEE, 0x03, 0xB8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x1C, 0x3C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00,
  0xE7, 0x00, 0x07, 0x70, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xF0, 0x0E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xE3, 0x80, 0x3E, 0x1E, 0x03, 0x70, 0xF0, 0x77, 0xC7, 0xFF,
  0x1F, 0x9F, 0xF0, 0xFC, 0x7E, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE3, 0xF0, 0x0E, 0x7F, 0xE0, 0x77, 0xFF, 0x87, 0xF0, 0x7C,
  0x3F, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0x70, 0x01, 0xE7,
  0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03,
  0xC7, 0xE0, 0x3E, 0x3F, 0x83, 0xE1, 0xFF, 0xFE, 0x0E, 0x7F, 0xE0, 0x70,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0x83,
  0xE0, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF0, 0xFC, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x7E, 0x1E, 0x03, 0xFF, 0x38, 0x0F, 0xFF, 0xF0, 0x3E, 0x0F, 0xE0, 0xF8,
  0x0F, 0xC1, 0xE0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0xC0, 0xF0, 0x1F, 0x81, 0xF0, 0x7F, 0x03, 0xFF, 0xDE, 0x03,
  0xFF, 0x3C, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x0C, 0x1E, 0x00, 0xF0, 0xFC, 0x1F, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x3C, 0x0F, 0xFC, 0xE0,
  0x7F, 0xF3, 0x83, 0xE0, 0xFE, 0x1F, 0x01, 0xF8, 0x78, 0x03, 0xE3, 0xC0,
  0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0x80, 0xFC, 0x1F, 0x07,
  0xF0, 0x7F, 0xFB, 0xC0, 0xFF, 0xCF, 0x00, 0xFC, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF8,
  0x3E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF8, 0x0F, 0x3F, 0xE0, 0x77, 0xFF,
  0x87, 0xF8, 0x7C, 0x3F, 0x01, 0xE1, 0xF0, 0x07, 0x8F, 0x00, 0x38, 0x78,
  0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x70, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x20, 0x3F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x0F, 0x00,
  0xF0, 0x38, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x1F, 0x00,
  0x78, 0xF8, 0x01, 0xC7, 0xC0, 0x07, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1F, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x3C, 0x3E, 0x0E, 0xFE, 0x7F, 0x0E, 0xFE, 0xFF, 0x0F,
  0x9F, 0xCF, 0x1F, 0x0F, 0x87, 0x1E, 0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x1E,
  0x0E, 0x0F, 0x1C, 0x1E, 0x0F, 0x1C, 0x1E, 0x0E, 0x3C, 0x1E, 0x0E, 0x3C,
  0x1C, 0x0E, 0x3C, 0x1C, 0x1E, 0x38, 0x1C, 0x1E, 0x38, 0x3C, 0x1E, 0x78,
  0x3C, 0x1C, 0x78, 0x38, 0x1C, 0x78, 0x38, 0x3C, 0x70, 0x38, 0x3C, 0x70,
  0x78, 0x3C, 0xF0, 0x78, 0x38, 0xF0, 0x70, 0x38, 0xF0, 0x70, 0x38, 0x0E,
  0x0F, 0xC0, 0x71, 0xFF, 0x07, 0xBF, 0xFC, 0x3F, 0xC3, 0xE1, 0xF8, 0x0F,
  0x0F, 0x80, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x83, 0xE1, 0xF0,
  0x0F, 0x0F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x1E,
  0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0x87, 0xF0, 0x07, 0x3F, 0xF0, 0x1E, 0xFF, 0xF0, 0x3F, 0x83,
  0xE0, 0x7E, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xFC, 0x07, 0xC1, 0xFC, 0x1F, 0x03, 0xDF,
  0xFC, 0x07, 0xBF, 0xF0, 0x0E, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x3C,
  0x0F, 0xFC, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0xFE, 0x1F, 0x01, 0xF8, 0x78,
  0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x07, 0x80,
  0xFC, 0x1F, 0x07, 0xF0, 0x7F, 0xFB, 0xC0, 0xFF, 0xCF, 0x00, 0xFC, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x0F, 0xF1, 0xE3, 0xFE, 0x1E, 0x7F, 0xE1, 0xEF, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xF8, 0x1F, 0x0F, 0x00, 0x70,
  0xE0, 0x07, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE7, 0x00, 0x1C, 0xF0, 0x03, 0xC7, 0x80,
  0x78, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x02, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x1E,
  0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03,
  0xE1, 0xF0, 0x7F, 0x0F, 0xFF, 0x78, 0x3F, 0xF3, 0xC0, 0xFE, 0x1E, 0x00,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF8,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07,
  0x81, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x7B,
  0xC0, 0x01, 0xEE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC1,
  0xF0, 0x79, 0xE0, 0xF8, 0x38, 0xF0, 0xFC, 0x3C, 0x78, 0x7E, 0x1E, 0x3C,
  0x77, 0x0E, 0x1E, 0x3B, 0x8F, 0x0F, 0x39, 0xC7, 0x07, 0x9C, 0x63, 0x83,
  0xCC, 0x33, 0xC1, 0xEE, 0x1D, 0xC0, 0xE6, 0x0E, 0xE0, 0x77, 0x07, 0xF0,
  0x3B, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x03,
  0xC7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0x9C, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x1C,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x37, 0xFF, 0xFF, 0xD8, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 28, 25, 8, -28 },
  { 36, 15, 13, 25, 8, -30 },
  { 61, 24, 28, 25, 1, -28 },
  { 145, 24, 34, 25, 1, -31 },
  { 247, 28, 28, 25, -1, -28 },
  { 345, 23, 28, 25, 0, -28 },
  { 426, 7, 13, 25, 12, -30 },
  { 438, 16, 39, 25, 6, -30 },
  { 516, 16, 39, 25, 3, -30 },
  { 594, 15, 14, 25, 8, -30 },
  { 621, 21, 21, 25, 2, -24 },
  { 677, 11, 14, 25, 2, -6 },
  { 697, 12, 3, 25, 7, -12 },
  { 702, 6, 6, 25, 8, -6 },
  { 707, 27, 30, 25, 0, -30 },
  { 809, 22, 28, 25, 2, -28 },
  { 886, 21, 28, 25, 1, -28 },
  { 960, 23, 28, 25, 1, -28 },
  { 1041, 22, 28, 25, 2, -28 },
  { 1118, 22, 28, 25, 1, -28 },
  { 1195, 22, 28, 25, 2, -28 },
  { 1272, 21, 28, 25, 3, -28 },
  { 1346, 19, 28, 25, 6, -28 },
  { 1413, 22, 28, 25, 2, -28 },
  { 1490, 22, 28, 25, 2, -28 },
  { 1567, 9, 23, 25, 8, -23 },
  { 1593, 13, 31, 25, 4, -23 },
  { 1644, 21, 21, 25, 2, -24 },
  { 1700, 21, 14, 25, 2, -21 },
  { 1737, 21, 21, 25, 2, -24 },
  { 1793, 20, 28, 25, 4, -28 },
  { 1863, 26, 35, 25, 0, -30 },
  { 1977, 25, 28, 25, -2, -28 },
  { 2065, 23, 28, 25, 1, -28 },
  { 2146, 23, 28, 25, 2, -28 },
  { 2227, 23, 28, 25, 1, -28 },
  { 2308, 24, 28, 25, 1, -28 },
  { 2392, 23, 28, 25, 2, -28 },
  { 2473, 23, 28, 25, 2, -28 },
  { 2554, 24, 28, 25, 1, -28 },
  { 2638, 22, 28, 25, 2, -28 },
  { 2715, 20, 28, 25, 3, -28 },
  { 2785, 26, 28, 25, 1, -28 },
  { 2876, 18, 28, 25, 3, -28 },
  { 2939, 26, 28, 25, 0, -28 },
  { 3030, 24, 28, 25, 1, -28 },
  { 3114, 22, 28, 25, 2, -28 },
  { 3191, 24, 28, 25, 1, -28 },
  { 3275, 22, 37, 25, 2, -28 },
  { 3377, 24, 28, 25, 1, -28 },
  { 3461, 23, 28, 25, 1, -28 },
  { 3542, 23, 28, 25, 4, -28 },
  { 3623, 23, 28, 25, 2, -28 },
  { 3704, 25, 28, 25, 3, -28 },
  { 3792, 26, 28, 25, 2, -28 },
  { 3883, 28, 28, 25, -1, -28 },
  { 3981, 24, 28, 25, 4, -28 },
  { 4065, 27, 28, 25, -1, -28 },
  { 4160, 18, 39, 25, 5, -30 },
  { 4248, 15, 30, 25, 6, -30 },
  { 4305, 19, 39, 25, 2, -30 },
  { 4398, 20, 19, 25, 2, -28 },
  { 4446, 26, 2, 25, -3, 3 },
  { 4453, 8, 5, 25, 12, -30 },
  { 4458, 21, 23, 25, 1, -23 },
  { 4519, 21, 30, 25, 2, -30 },
  { 4598, 21, 23, 25, 2, -23 },
  { 4659, 23, 30, 25, 2, -30 },
  { 4746, 21, 23, 25, 2, -23 },
  { 4807, 22, 30, 25, 4, -30 },
  { 4890, 22, 32, 25, 2, -23 },
  { 4978, 21, 30, 25, 2, -30 },
  { 5057, 21, 30, 25, 1, -30 },
  { 5136, 22, 39, 25, -1, -30 },
  { 5244, 22, 30, 25, 3, -30 },
  { 5327, 20, 30, 25, 1, -30 },
  { 5402, 24, 23, 25, 0, -23 },
  { 5471, 21, 23, 25, 2, -23 },
  { 5532, 21, 23, 25, 2, -23 },
  { 5593, 23, 32, 25, 0, -23 },
  { 5685, 22, 32, 25, 2, -23 },
  { 5773, 20, 23, 25, 4, -23 },
  { 5831, 20, 23, 25, 2, -23 },
  { 5889, 17, 29, 25, 5, -29 },
  { 5951, 21, 23, 25, 3, -23 },
  { 6012, 22, 23, 25, 4, -23 },
  { 6076, 25, 23, 25, 2, -23 },
  { 6148, 25, 23, 25, 0, -23 },
  { 6220, 26, 32, 25, 0, -23 },
  { 6324, 22, 23, 25, 1, -23 },
  { 6388, 22, 39, 25, 4, -30 },
  { 6496, 3, 39, 25, 11, -30 },
  { 6511, 21, 39, 25, 0, -30 },
  { 6614, 22, 5, 25, 2, -16 },
};

const GFXfont LiberationMono_Italic42pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic42pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic42pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _LIBERATIONMONO_ITALIC42PT7B_H_
