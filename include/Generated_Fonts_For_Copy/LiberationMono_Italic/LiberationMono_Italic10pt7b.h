#ifndef _LIBERATIONMONO_ITALIC10PT7B_H_
#define _LIBERATIONMONO_ITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xAA, 0xA0, 0x14, 0xA7, 0xD2, 0xF9, 0x49, 0x00, 0x10,
  0xE5, 0x54, 0x38, 0x6A, 0x9E, 0x20, 0x66, 0xA7, 0x04, 0x3D, 0x59, 0x80,
  0x39, 0x4C, 0xCA, 0xCF, 0xA0, 0xE0, 0x2A, 0x49, 0x24, 0x80, 0x24, 0x92,
  0x4A, 0x80, 0x5B, 0x80, 0x44, 0xF4, 0x40, 0x2A, 0x00, 0xC0, 0x80, 0x04,
  0x21, 0x04, 0x21, 0x08, 0x00, 0x74, 0x63, 0x59, 0x4B, 0x80, 0x13, 0x84,
  0x21, 0x0B, 0xE0, 0x39, 0x10, 0x84, 0x21, 0x0F, 0x80, 0x39, 0x10, 0x8C,
  0x0A, 0x27, 0x00, 0x08, 0xCA, 0x9F, 0x88, 0x40, 0x3D, 0x07, 0x82, 0x0A,
  0x27, 0x00, 0x7A, 0x3D, 0x29, 0x4B, 0x80, 0xF8, 0x84, 0x44, 0x21, 0x00,
  0x39, 0x14, 0x8C, 0x4A, 0x27, 0x00, 0x74, 0x63, 0x2F, 0x0B, 0x80, 0x40,
  0x80, 0x20, 0x04, 0xA0, 0x1E, 0x8E, 0x10, 0xF0, 0xF0, 0x87, 0x17, 0x80,
  0x74, 0x42, 0x64, 0x01, 0x00, 0x18, 0x95, 0x6B, 0xD7, 0x5F, 0xA0, 0x70,
  0x08, 0x51, 0x49, 0x3D, 0x14, 0x40, 0x79, 0x14, 0x9C, 0x49, 0x2F, 0x80,
  0x76, 0x61, 0x08, 0x4B, 0x80, 0x79, 0x34, 0x51, 0x4A, 0x2F, 0x00, 0x7D,
  0x04, 0x1E, 0x41, 0x0F, 0x80, 0x3D, 0x04, 0x1E, 0x41, 0x08, 0x00, 0x76,
  0x61, 0x69, 0x4B, 0xC0, 0x45, 0x14, 0x5E, 0x49, 0x28, 0x80, 0x3C, 0x41,
  0x04, 0x20, 0x87, 0x80, 0x30, 0x84, 0x21, 0x53, 0x80, 0x45, 0x25, 0x1C,
  0x51, 0x28, 0x80, 0x44, 0x88, 0x88, 0xF0, 0x65, 0xB7, 0x5D, 0x8A, 0x28,
  0x80, 0x65, 0x96, 0x56, 0x5A, 0x69, 0x80, 0x39, 0x14, 0x51, 0x89, 0x27,
  0x00, 0x79, 0x14, 0x5E, 0x41, 0x08, 0x00, 0x39, 0x14, 0x51, 0x89, 0x27,
  0x08, 0x18, 0x7D, 0x14, 0x5E, 0x51, 0x28, 0x80, 0x39, 0x14, 0x0E, 0x0A,
  0x27, 0x00, 0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x63, 0x29, 0x4B, 0x80,
  0x8A, 0x29, 0x24, 0x61, 0x84, 0x00, 0x86, 0x2A, 0xBA, 0xF2, 0xCB, 0x00,
  0x44, 0xA3, 0x04, 0x31, 0x28, 0x80, 0x89, 0x45, 0x18, 0x41, 0x04, 0x00,
  0x7C, 0x21, 0x04, 0x21, 0x0F, 0x80, 0x39, 0x10, 0x84, 0x22, 0x10, 0xE0,
  0x44, 0x42, 0x22, 0x10, 0x38, 0x44, 0x21, 0x08, 0x44, 0xE0, 0x25, 0x99,
  0xFC, 0x90, 0x78, 0x5F, 0x3E, 0x80, 0x22, 0x1E, 0x94, 0xA6, 0xC0, 0x79,
  0x88, 0xF0, 0x08, 0x5B, 0x29, 0x4B, 0xC0, 0x79, 0xF8, 0xF0, 0x39, 0x3E,
  0x84, 0x22, 0x00, 0x35, 0x24, 0x92, 0x78, 0x47, 0x00, 0x22, 0x1E, 0x94,
  0xA6, 0x20, 0x10, 0x0C, 0x21, 0x13, 0xE0, 0x08, 0x0C, 0x21, 0x08, 0x44,
  0xE0, 0x42, 0x25, 0x4E, 0x52, 0x40, 0x30, 0x84, 0x21, 0x13, 0xE0, 0x7D,
  0x59, 0x6A, 0xA8, 0x7A, 0x52, 0x98, 0x80, 0x79, 0x99, 0xE0, 0x7A, 0x52,
  0x9B, 0x42, 0x00, 0x6C, 0xA5, 0x2F, 0x08, 0x80, 0x7A, 0x21, 0x08, 0x00,
  0x78, 0x71, 0xE0, 0x4F, 0x44, 0x87, 0x8C, 0xA5, 0x2F, 0x00, 0x8C, 0xAC,
  0xC4, 0x00, 0x46, 0x5B, 0x76, 0xD8, 0x48, 0xC3, 0x14, 0x88, 0x45, 0x25,
  0x8C, 0x20, 0x8C, 0x00, 0x78, 0x23, 0x10, 0xF8, 0x19, 0x08, 0xC8, 0x21,
  0x08, 0x60, 0xFF, 0x80, 0x30, 0x84, 0x20, 0x98, 0x84, 0xC0, 0xC9, 0x80,
};

const GFXglyph LiberationMono_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 5, 7, 6, 0, -7 },
  { 29, 1, 3, 6, 3, -7 },
  { 30, 3, 9, 6, 2, -7 },
  { 34, 3, 9, 6, 1, -7 },
  { 38, 3, 4, 6, 2, -7 },
  { 40, 4, 5, 6, 1, -6 },
  { 43, 3, 3, 6, 0, -1 },
  { 45, 2, 1, 6, 2, -3 },
  { 46, 1, 1, 6, 2, -1 },
  { 47, 6, 7, 6, 0, -7 },
  { 53, 5, 7, 6, 1, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 6, 7, 6, 0, -7 },
  { 69, 6, 7, 6, 0, -7 },
  { 75, 5, 7, 6, 0, -7 },
  { 80, 6, 7, 6, 0, -7 },
  { 86, 5, 7, 6, 1, -7 },
  { 91, 5, 7, 6, 1, -7 },
  { 96, 6, 7, 6, 0, -7 },
  { 102, 5, 7, 6, 1, -7 },
  { 107, 2, 5, 6, 2, -5 },
  { 109, 3, 7, 6, 1, -5 },
  { 112, 4, 5, 6, 1, -6 },
  { 115, 4, 3, 6, 1, -5 },
  { 117, 4, 5, 6, 1, -6 },
  { 120, 5, 7, 6, 1, -7 },
  { 125, 6, 9, 6, 0, -7 },
  { 132, 6, 7, 6, -1, -7 },
  { 138, 6, 7, 6, 0, -7 },
  { 144, 5, 7, 6, 1, -7 },
  { 149, 6, 7, 6, 0, -7 },
  { 155, 6, 7, 6, 0, -7 },
  { 161, 6, 7, 6, 0, -7 },
  { 167, 5, 7, 6, 1, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 6, 7, 6, 0, -7 },
  { 184, 5, 7, 6, 1, -7 },
  { 189, 6, 7, 6, 0, -7 },
  { 195, 4, 7, 6, 1, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 6, 7, 6, 0, -7 },
  { 211, 6, 7, 6, 0, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 6, 9, 6, 0, -7 },
  { 230, 6, 7, 6, 0, -7 },
  { 236, 6, 7, 6, 0, -7 },
  { 242, 5, 7, 6, 1, -7 },
  { 247, 5, 7, 6, 1, -7 },
  { 252, 6, 7, 6, 1, -7 },
  { 258, 6, 7, 6, 1, -7 },
  { 264, 6, 7, 6, 0, -7 },
  { 270, 6, 7, 6, 1, -7 },
  { 276, 6, 7, 6, 0, -7 },
  { 282, 5, 9, 6, 1, -7 },
  { 288, 4, 7, 6, 1, -7 },
  { 292, 5, 9, 6, 0, -7 },
  { 298, 4, 4, 6, 1, -7 },
  { 300, 6, 1, 6, -1, 1 },
  { 301, 2, 2, 6, 3, -8 },
  { 302, 5, 5, 6, 0, -5 },
  { 306, 5, 7, 6, 0, -7 },
  { 311, 4, 5, 6, 1, -5 },
  { 314, 5, 7, 6, 1, -7 },
  { 319, 4, 5, 6, 1, -5 },
  { 322, 5, 7, 6, 1, -7 },
  { 327, 6, 7, 6, 0, -5 },
  { 333, 5, 7, 6, 0, -7 },
  { 338, 5, 7, 6, 0, -7 },
  { 343, 5, 9, 6, 0, -7 },
  { 349, 5, 7, 6, 1, -7 },
  { 354, 5, 7, 6, 0, -7 },
  { 359, 6, 5, 6, 0, -5 },
  { 363, 5, 5, 6, 0, -5 },
  { 367, 4, 5, 6, 1, -5 },
  { 370, 5, 7, 6, 0, -5 },
  { 375, 5, 7, 6, 1, -5 },
  { 380, 5, 5, 6, 1, -5 },
  { 384, 4, 5, 6, 1, -5 },
  { 387, 4, 6, 6, 1, -6 },
  { 390, 5, 5, 6, 1, -5 },
  { 394, 5, 5, 6, 1, -5 },
  { 398, 6, 5, 6, 0, -5 },
  { 402, 6, 5, 6, 0, -5 },
  { 406, 6, 7, 6, 0, -5 },
  { 412, 6, 5, 6, 0, -5 },
  { 416, 5, 9, 6, 1, -7 },
  { 422, 1, 9, 6, 3, -7 },
  { 424, 5, 9, 6, 0, -7 },
  { 430, 5, 2, 6, 1, -5 },
};

const GFXfont LiberationMono_Italic10pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic10pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic10pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _LIBERATIONMONO_ITALIC10PT7B_H_
