#ifndef _LIBERATIONMONO_ITALIC60PT7B_H_
#define _LIBERATIONMONO_ITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF3,
  0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3E,
  0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x1E, 0x7F, 0x80, 0x3F, 0x83,
  0xC3, 0xF8, 0x0F, 0xC0, 0x70, 0x3F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0x78, 0x0E, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x7F, 0xC0,
  0x00, 0x03, 0x83, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x1E, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0E,
  0x00, 0xF8, 0x18, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x03, 0xE3, 0xE0,
  0x0F, 0x00, 0xF8, 0x7E, 0x01, 0xE0, 0x1F, 0x0F, 0xC0, 0x3C, 0x07, 0xE0,
  0xFC, 0x07, 0x01, 0xF8, 0x1F, 0xC1, 0xE0, 0x7E, 0x01, 0xFE, 0x3C, 0x7F,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3C, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0x03,
  0xC0, 0x3C, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x78, 0x00, 0xF8,
  0x07, 0x81, 0xE0, 0x01, 0xF0, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x1F,
  0x00, 0x07, 0xC0, 0x78, 0x7C, 0x00, 0x07, 0x81, 0xF1, 0xF0, 0x00, 0x0F,
  0x87, 0xC3, 0xC0, 0x00, 0x1F, 0xFF, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x3C,
  0x00, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x7F, 0xE0, 0x00, 0x01, 0xE3, 0xFF, 0xE0, 0x00, 0x07, 0x87, 0xC3, 0xE0,
  0x00, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x7C, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x3C,
  0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x1E, 0x7F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x0C, 0x01, 0xFF, 0x80, 0x0F, 0x07, 0xFF, 0x80, 0x1F, 0x0F, 0xC7,
  0xC0, 0x1E, 0x1F, 0x87, 0xC0, 0x1E, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x03,
  0xE0, 0x3C, 0x3E, 0x03, 0xE0, 0x7C, 0x7C, 0x01, 0xF0, 0x78, 0x7C, 0x01,
  0xF8, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0xF8, 0x00, 0xFD, 0xE0, 0xF8, 0x00,
  0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x03,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0x03, 0xFC, 0x00, 0x3C, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x81, 0xE0, 0x6F, 0x8F, 0x1F,
  0x7F, 0x73, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xF8, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0x9F, 0xCF,
  0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x3F, 0x83, 0xF7, 0xC0, 0xFE, 0x0F,
  0xDF, 0x03, 0xF0, 0x3E, 0xFC, 0x1F, 0xC0, 0xFB, 0xF0, 0x7F, 0x03, 0xEF,
  0x81, 0xFC, 0x1F, 0xBE, 0x07, 0xF0, 0x7E, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x7C, 0x00, 0x7F, 0xF3, 0xE0, 0x07, 0xFE, 0x3F, 0x00,
  0x3F, 0xC1, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x78, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC1, 0xFE, 0x00, 0x07, 0xCF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xC0, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0x00,
  0xF8, 0xFF, 0xFE, 0x03, 0xEF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x7F,
  0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFF, 0x83, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0x7C, 0x07, 0xFF,
  0xFC, 0xF8, 0x07, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0x87, 0xC0, 0x03, 0xFC,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x3E, 0x00, 0xF0,
  0x1C, 0x07, 0xF8, 0xF7, 0x81, 0xE0, 0x7F, 0xE7, 0x3C, 0x1E, 0x07, 0xC7,
  0x79, 0xE0, 0xF0, 0x78, 0x1B, 0x8F, 0x07, 0x07, 0x80, 0xFC, 0x78, 0x78,
  0x78, 0x07, 0xE3, 0xC3, 0x83, 0xC0, 0x3E, 0x1C, 0x3C, 0x3C, 0x01, 0xF0,
  0xE1, 0xE1, 0xE0, 0x0F, 0x0F, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0xF0, 0xF0,
  0x07, 0x83, 0xC7, 0x8F, 0x00, 0x3C, 0x1C, 0x3C, 0x78, 0x01, 0xE0, 0xE1,
  0xC7, 0x80, 0x1E, 0x0F, 0x1E, 0x3C, 0x00, 0xF0, 0x78, 0xF1, 0xE0, 0x07,
  0x03, 0x87, 0x8F, 0x00, 0x78, 0x3C, 0x38, 0x78, 0x03, 0xC1, 0xC1, 0xC7,
  0x80, 0x3C, 0x1E, 0x1E, 0x3C, 0x03, 0xE0, 0xE0, 0xF1, 0xE0, 0x1F, 0x0F,
  0x07, 0x8F, 0x01, 0xF0, 0x70, 0x3C, 0x3C, 0x1F, 0x87, 0x81, 0xE1, 0xE3,
  0xDC, 0x78, 0x0F, 0x0F, 0xFC, 0xFF, 0x80, 0x78, 0x3F, 0xC7, 0xF8, 0x01,
  0xE0, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x03, 0xF8,
  0x7C, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x18,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x40,
  0x7C, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xFC,
  0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7C, 0x00, 0x3F, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x18, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x7E,
  0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0x7E,
  0x01, 0xFF, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xE0, 0x3F,
  0x80, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0xFE, 0x00,
  0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0xFB, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xBC,
  0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C, 0x07, 0xCF, 0x01,
  0xF7, 0xC0, 0x7C, 0xF0, 0x1E, 0x7C, 0x07, 0xCF, 0x83, 0xE7, 0x80, 0x78,
  0xF8, 0x3C, 0xF8, 0x07, 0x8F, 0x87, 0x8F, 0x80, 0xF8, 0xF8, 0x78, 0xF8,
  0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF8, 0x79, 0xF0, 0xF0, 0x0F, 0x87, 0x9E,
  0x1F, 0x00, 0xF0, 0x79, 0xE1, 0xF0, 0x1F, 0x07, 0xFC, 0x1F, 0x01, 0xF0,
  0x7F, 0xC1, 0xF0, 0x1F, 0x03, 0xF8, 0x1E, 0x01, 0xF0, 0x3F, 0x01, 0xE0,
  0x1E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00,
  0xF8, 0x07, 0xF8, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0x80,
  0x03, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x7C, 0x03, 0xDF,
  0x00, 0x1F, 0x00, 0xF7, 0xC0, 0x07, 0xC0, 0x7C, 0xF8, 0x01, 0xF0, 0x1F,
  0x3E, 0x00, 0x7C, 0x07, 0xCF, 0x80, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x80,
  0x7C, 0x7C, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80,
  0x3E, 0x3E, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x03, 0xE3, 0xE0, 0x3E,
  0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x1F, 0x7C, 0x07, 0xC0, 0x07, 0xDF, 0x01,
  0xF0, 0x01, 0xF7, 0xC0, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x0F, 0xF8,
  0x07, 0xC0, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x1F,
  0xE0, 0x3E, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xC0, 0x7C, 0x07, 0xC0,
  0xFF, 0x03, 0xE0, 0x1F, 0x07, 0xBC, 0x0F, 0x80, 0x7C, 0x1E, 0xF0, 0x3E,
  0x01, 0xF0, 0xF3, 0xE1, 0xF0, 0x07, 0xC3, 0xCF, 0x87, 0xC0, 0x1F, 0x1F,
  0x1E, 0x1E, 0x00, 0x7C, 0x78, 0x78, 0xF8, 0x01, 0xF1, 0xE1, 0xE3, 0xE0,
  0x07, 0x8F, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x1E, 0x7C, 0x00, 0x79, 0xE0,
  0x79, 0xF0, 0x03, 0xE7, 0x81, 0xE7, 0x80, 0x0F, 0xBE, 0x07, 0x9E, 0x00,
  0x3E, 0xF0, 0x1E, 0xF8, 0x00, 0xFB, 0xC0, 0x7B, 0xC0, 0x03, 0xFE, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0x81, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0xFE, 0x01, 0xEF, 0xC3, 0xFC, 0x1F, 0x3F,
  0x07, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xC3, 0xFE, 0x1F, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x1F,
  0x8F, 0xFF, 0x00, 0x3E, 0x3F, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0xFB,
  0xC0, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0x7E, 0x0F, 0xF0, 0x01, 0xF8, 0x1F, 0x70, 0x07, 0xF0, 0x3E,
  0xF0, 0x3F, 0xC0, 0x7D, 0xFF, 0xFF, 0x01, 0xF9, 0xFF, 0xFC, 0x03, 0xE1,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xFB,
  0xE0, 0x0F, 0xF0, 0x7D, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x03,
  0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03,
  0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xDF, 0x00,
  0x3F, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0xC3, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x20, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x7F, 0xFF, 0x3F,
  0x00, 0xFF, 0xFF, 0x3E, 0x01, 0xFE, 0x0F, 0xBE, 0x03, 0xF8, 0x03, 0xBE,
  0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0xF7, 0xE0, 0x1F, 0xFF, 0xE7, 0xC0,
  0x0F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x7C, 0x7F, 0xF8, 0x03, 0xE3, 0xFF,
  0xF8, 0x0F, 0x9F, 0xFF, 0xE0, 0x3E, 0xF8, 0x3F, 0xC0, 0xFF, 0x80, 0x3F,
  0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x60, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x7F, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7D, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFB, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0xFF, 0x0F, 0xF8,
  0x0F, 0x3F, 0xE3, 0xFF, 0x01, 0xEF, 0xFC, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x3E,
  0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x7C,
  0x1F, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0xF8,
  0x3E, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x80,
  0xF8, 0x3E, 0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0x83, 0xFF, 0xC0,
  0x3E, 0x3F, 0xFF, 0x80, 0xF9, 0xFF, 0xFE, 0x03, 0xEF, 0x83, 0xFC, 0x0F,
  0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0xFC,
  0x00, 0x3E, 0x3F, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0xC0, 0x0F, 0xBC, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x7E, 0x01,
  0xF7, 0x00, 0x7F, 0x00, 0xFB, 0xC0, 0x7F, 0x00, 0x7D, 0xFF, 0xFF, 0x00,
  0x3E, 0x7F, 0xFF, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x03, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF,
  0xF3, 0xE0, 0x3F, 0xC1, 0xF7, 0xC0, 0xFE, 0x00, 0xFF, 0x81, 0xF8, 0x00,
  0xFF, 0x07, 0xE0, 0x01, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x7D, 0xF0, 0x0F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF,
  0xC7, 0xC0, 0x0F, 0xFF, 0x1F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xF8, 0x1F, 0xFF,
  0x0F, 0x83, 0xFF, 0xE0, 0xF8, 0x7F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE0, 0xF9,
  0xF8, 0x02, 0x0F, 0x9E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xF8, 0x3F, 0x00, 0x3B, 0xE0, 0xFF, 0x03, 0xDF, 0x01, 0xFF, 0xFE, 0x7C,
  0x07, 0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0x87, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0x7C, 0x7C, 0x07, 0xF8, 0x1F,
  0x0F, 0x80, 0xFF, 0x03, 0xE1, 0xF0, 0x3D, 0xE0, 0xFC, 0x3E, 0x07, 0xBC,
  0x1F, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF8, 0x3C, 0xF0, 0xF8, 0x1F, 0x0F,
  0x1E, 0x1F, 0x03, 0xE1, 0xE3, 0xC3, 0xE0, 0x7C, 0x78, 0x78, 0xF8, 0x0F,
  0x8F, 0x07, 0x9F, 0x01, 0xF3, 0xC0, 0xF3, 0xE0, 0x3E, 0x78, 0x1E, 0xF8,
  0x07, 0xDE, 0x03, 0xDF, 0x00, 0xFB, 0xC0, 0x7B, 0xE0, 0x1F, 0xF0, 0x0F,
  0x78, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x05, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0xFF, 0xFF, 0xC8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00,
};

const GFXglyph LiberationMono_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 13, 40, 36, 12, -40 },
  { 66, 22, 19, 36, 11, -43 },
  { 119, 35, 40, 36, 1, -40 },
  { 294, 35, 49, 36, 1, -44 },
  { 509, 39, 42, 36, -1, -41 },
  { 714, 32, 42, 36, 0, -41 },
  { 882, 9, 19, 36, 18, -43 },
  { 904, 22, 55, 36, 9, -43 },
  { 1056, 23, 55, 36, 4, -43 },
  { 1215, 21, 21, 36, 11, -43 },
  { 1271, 30, 30, 36, 3, -35 },
  { 1384, 17, 19, 36, 2, -9 },
  { 1425, 18, 5, 36, 9, -18 },
  { 1437, 9, 9, 36, 11, -9 },
  { 1448, 38, 44, 36, 0, -43 },
  { 1657, 30, 42, 36, 4, -41 },
  { 1815, 29, 40, 36, 2, -40 },
  { 1960, 33, 41, 36, 1, -41 },
  { 2130, 31, 42, 36, 3, -41 },
  { 2293, 31, 40, 36, 2, -40 },
  { 2448, 32, 41, 36, 2, -40 },
  { 2612, 30, 42, 36, 4, -41 },
  { 2770, 28, 40, 36, 8, -40 },
  { 2910, 31, 42, 36, 3, -41 },
  { 3073, 31, 42, 36, 3, -41 },
  { 3236, 14, 32, 36, 11, -32 },
  { 3292, 20, 42, 36, 5, -32 },
  { 3397, 30, 30, 36, 3, -35 },
  { 3510, 30, 19, 36, 3, -29 },
  { 3582, 30, 30, 36, 3, -35 },
  { 3695, 29, 41, 36, 5, -41 },
  { 3844, 37, 50, 36, 0, -43 },
  { 4076, 36, 40, 36, -3, -40 },
  { 4256, 32, 40, 36, 2, -40 },
  { 4416, 32, 42, 36, 3, -41 },
  { 4584, 32, 40, 36, 2, -40 },
  { 4744, 34, 40, 36, 2, -40 },
  { 4914, 33, 40, 36, 3, -40 },
  { 5079, 32, 42, 36, 3, -41 },
  { 5247, 34, 40, 36, 2, -40 },
  { 5417, 32, 40, 36, 3, -40 },
  { 5577, 29, 41, 36, 4, -40 },
  { 5726, 36, 40, 36, 2, -40 },
  { 5906, 26, 40, 36, 4, -40 },
  { 6036, 36, 40, 36, 1, -40 },
  { 6216, 34, 40, 36, 2, -40 },
  { 6386, 32, 42, 36, 3, -41 },
  { 6554, 33, 40, 36, 2, -40 },
  { 6719, 32, 53, 36, 3, -41 },
  { 6931, 34, 40, 36, 2, -40 },
  { 7101, 34, 42, 36, 1, -41 },
  { 7280, 32, 40, 36, 6, -40 },
  { 7440, 33, 41, 36, 3, -40 },
  { 7610, 35, 40, 36, 5, -40 },
  { 7785, 38, 40, 36, 3, -40 },
  { 7975, 40, 40, 36, -2, -40 },
  { 8175, 34, 40, 36, 6, -40 },
  { 8345, 38, 40, 36, -1, -40 },
  { 8535, 27, 55, 36, 6, -43 },
  { 8721, 20, 44, 36, 9, -43 },
  { 8831, 27, 55, 36, 2, -43 },
  { 9017, 29, 27, 36, 3, -40 },
  { 9115, 36, 3, 36, -4, 4 },
  { 9129, 11, 8, 36, 17, -43 },
  { 9140, 30, 34, 36, 2, -33 },
  { 9268, 31, 44, 36, 2, -43 },
  { 9439, 30, 34, 36, 3, -33 },
  { 9567, 33, 44, 36, 3, -43 },
  { 9749, 30, 34, 36, 3, -33 },
  { 9877, 31, 43, 36, 6, -43 },
  { 10044, 32, 45, 36, 2, -33 },
  { 10224, 30, 43, 36, 2, -43 },
  { 10386, 30, 43, 36, 1, -43 },
  { 10548, 32, 55, 36, -2, -43 },
  { 10768, 31, 43, 36, 4, -43 },
  { 10935, 29, 43, 36, 1, -43 },
  { 11091, 35, 33, 36, 0, -33 },
  { 11236, 30, 33, 36, 2, -33 },
  { 11360, 30, 34, 36, 3, -33 },
  { 11488, 33, 45, 36, 0, -33 },
  { 11674, 31, 45, 36, 3, -33 },
  { 11849, 28, 33, 36, 6, -33 },
  { 11965, 29, 34, 36, 3, -33 },
  { 12089, 24, 41, 36, 8, -40 },
  { 12212, 30, 33, 36, 4, -32 },
  { 12336, 32, 32, 36, 5, -32 },
  { 12464, 35, 32, 36, 3, -32 },
  { 12604, 36, 32, 36, 0, -32 },
  { 12748, 38, 44, 36, -1, -32 },
  { 12957, 32, 32, 36, 1, -32 },
  { 13085, 30, 55, 36, 6, -43 },
  { 13292, 4, 55, 36, 16, -43 },
  { 13320, 31, 55, 36, -1, -43 },
  { 13534, 31, 7, 36, 3, -23 },
};

const GFXfont LiberationMono_Italic60pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic60pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic60pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _LIBERATIONMONO_ITALIC60PT7B_H_
