#ifndef _LIBERATIONMONO_ITALIC48PT7B_H_
#define _LIBERATIONMONO_ITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78,
  0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07,
  0x0E, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x03,
  0x80, 0x03, 0x80, 0x30, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x70, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x73, 0xF8, 0x3E, 0x0E, 0x1F, 0x07, 0x81,
  0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x3C, 0x0E, 0x07, 0x07, 0x81, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3F, 0xB8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0x7F, 0x80, 0x00, 0xE3, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0xF1, 0xC0,
  0x70, 0x1E, 0x78, 0x0E, 0x03, 0xCF, 0x01, 0xC0, 0xF9, 0xF0, 0x38, 0x1E,
  0x1F, 0x07, 0x0F, 0x83, 0xF9, 0xC7, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x01,
  0xFF, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x0E, 0x07, 0x81, 0xE0, 0x0E, 0x07, 0x81, 0xC0, 0x1E,
  0x07, 0x83, 0x80, 0x1E, 0x07, 0x87, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x1C,
  0x0F, 0x1E, 0x00, 0x1E, 0x0F, 0x3C, 0x00, 0x1E, 0x1E, 0x78, 0x00, 0x1F,
  0xFC, 0xF0, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x00,
  0x03, 0x87, 0xE0, 0x00, 0x07, 0x1F, 0xF0, 0x00, 0x0F, 0x3F, 0xF8, 0x00,
  0x1E, 0x78, 0x78, 0x00, 0x3C, 0xF0, 0x38, 0x00, 0x78, 0xF0, 0x38, 0x00,
  0x70, 0xE0, 0x38, 0x00, 0xE1, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x78, 0x03,
  0x81, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x70, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x01, 0xE1, 0xE0, 0x3C, 0x00, 0xFF, 0xC0, 0x38, 0x00, 0xFF, 0x80, 0x70,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x0F, 0x80,
  0x0F, 0x07, 0xC0, 0x03, 0xCF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x30, 0x1F, 0xE0, 0x0F, 0x0F, 0xBC, 0x03, 0x87, 0xCF,
  0x01, 0xE3, 0xE1, 0xE0, 0x70, 0xF0, 0x78, 0x3C, 0x78, 0x0F, 0x0E, 0x1E,
  0x03, 0xC7, 0x8F, 0x00, 0x79, 0xC3, 0xC0, 0x1F, 0xF0, 0xF0, 0x03, 0xF8,
  0x3C, 0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x0F,
  0xFE, 0x5F, 0xFF, 0xCF, 0xF3, 0xFF, 0xC1, 0xFC, 0x3F, 0xC0, 0x1E, 0x3E,
  0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x04, 0x1C, 0x17,
  0x8E, 0x3F, 0xF7, 0x7E, 0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0xE0, 0x03, 0xF8,
  0x01, 0xDC, 0x01, 0xCF, 0x01, 0xE3, 0x81, 0xE1, 0xE0, 0xE0, 0xE0, 0x20,
  0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF, 0xBF,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x78, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1E, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x7C, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0xF0, 0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xF0, 0x07, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x07, 0xE0, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F,
  0x07, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x0F, 0x80,
  0x07, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0x80, 0x0F, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x1F,
  0xC0, 0x3C, 0x7F, 0xF0, 0x3D, 0xFF, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07,
  0xC3, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x3F, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0xFE,
  0x1F, 0x83, 0xDE, 0x1F, 0xFF, 0xBC, 0x07, 0xFE, 0x3C, 0x01, 0xF8, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xFC, 0x1F, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFC,
  0x0F, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x38, 0x1C, 0x0F, 0x81, 0xC1, 0xC1, 0xFE, 0xEE, 0x0E,
  0x1E, 0x37, 0x70, 0xE1, 0xC1, 0xF3, 0x87, 0x1C, 0x0F, 0x9C, 0x70, 0xE0,
  0x7C, 0xE3, 0x8E, 0x03, 0xC7, 0x1C, 0x70, 0x1E, 0x39, 0xC7, 0x00, 0xE1,
  0xCE, 0x38, 0x07, 0x0E, 0x73, 0x80, 0x78, 0x67, 0x1C, 0x03, 0x87, 0x38,
  0xE0, 0x1C, 0x39, 0xCF, 0x01, 0xE1, 0x8E, 0x70, 0x0E, 0x1C, 0x73, 0x80,
  0xF0, 0xE7, 0x1C, 0x07, 0x06, 0x38, 0xE0, 0x78, 0x71, 0xC7, 0x03, 0xC3,
  0x0E, 0x38, 0x3E, 0x30, 0x71, 0xE7, 0x73, 0x83, 0x87, 0xF3, 0xF0, 0x1E,
  0x1E, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x02, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x1F, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x7F, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07,
  0xC0, 0x0F, 0xC1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x03, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x61,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x7E,
  0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x07, 0xF8, 0x0F, 0x80, 0x3F,
  0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x3E,
  0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x06,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xFC, 0xF8, 0x0F,
  0xFE, 0x7C, 0x07, 0xFF, 0x3E, 0x03, 0xFF, 0x9E, 0x00, 0x07, 0xCF, 0x00,
  0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0xE0, 0x7F, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x01, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00,
  0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0x7C,
  0x07, 0xE0, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x1E, 0x0F,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xBE, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x01, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0x70, 0x07, 0xF0, 0x77, 0x00, 0xEE, 0x0F, 0x70, 0x0F,
  0xE0, 0xF7, 0x81, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x0E,
  0x78, 0x79, 0xC1, 0xE3, 0x87, 0x3C, 0x1E, 0x38, 0xF3, 0xC1, 0xE3, 0xCE,
  0x3C, 0x1E, 0x3D, 0xE3, 0xC1, 0xC3, 0xDC, 0x38, 0x1C, 0x3F, 0xC7, 0x83,
  0xC1, 0xF8, 0x78, 0x3C, 0x1F, 0x87, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E,
  0x07, 0x83, 0x81, 0xE0, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x1E, 0x03,
  0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x80,
  0x1E, 0x07, 0xF8, 0x03, 0xC0, 0x7B, 0xC0, 0x3C, 0x07, 0xBC, 0x03, 0xC0,
  0x7B, 0xC0, 0x3C, 0x0F, 0x1C, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x0F, 0x1E,
  0x07, 0x80, 0xF1, 0xE0, 0x78, 0x0F, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x78,
  0x1E, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0xF0, 0x1E, 0x07, 0x8F, 0x01, 0xE0,
  0x78, 0xF0, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x78, 0xF0, 0x3C, 0x03, 0xDE,
  0x03, 0xC0, 0x3D, 0xE0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x3D, 0xE0, 0x78,
  0x01, 0xFE, 0x07, 0x80, 0x1F, 0xC0, 0x78, 0x01, 0xFC, 0x07, 0x80, 0x1F,
  0xC0, 0x78, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0xFE, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0xE0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9E,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3C,
  0x00, 0xFE, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE0, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x1F,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xE0, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE1, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x07,
  0xC0, 0xF8, 0x78, 0x1F, 0x03, 0xC1, 0xE0, 0x7E, 0x0F, 0x07, 0x83, 0xF8,
  0x78, 0x1E, 0x0F, 0xE1, 0xE0, 0x78, 0x73, 0x87, 0x81, 0xE1, 0xCE, 0x1C,
  0x07, 0x8F, 0x38, 0xF0, 0x1E, 0x38, 0xE3, 0xC0, 0x79, 0xE3, 0x8E, 0x01,
  0xE7, 0x0E, 0x78, 0x07, 0xBC, 0x39, 0xE0, 0x1E, 0xE0, 0xE7, 0x00, 0x73,
  0x83, 0xBC, 0x01, 0xDC, 0x0E, 0xF0, 0x07, 0x70, 0x3B, 0x80, 0x1F, 0x80,
  0xEE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x01,
  0xE0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C,
  0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0x1F, 0x80, 0x1E, 0x3E,
  0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x3F, 0x1F, 0x01, 0xDE, 0x3F, 0x0F, 0x3C, 0x7F, 0xFC,
  0x7F, 0x7F, 0xF0, 0xFE, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x83,
  0xF0, 0x07, 0x9F, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0x70, 0x3E, 0x0F, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x7E, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0x83, 0xF0, 0xF3, 0xFF, 0xC0, 0xF1, 0xFF,
  0x80, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x07,
  0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x83, 0xC0, 0x3F, 0xF9, 0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xC1,
  0xFE, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x07, 0xE0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xFC, 0x0F, 0x80, 0x6F, 0x03,
  0xF0, 0x7F, 0xC0, 0x7F, 0xFD, 0xF0, 0x0F, 0xFC, 0x78, 0x01, 0xFC, 0x1E,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07,
  0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x0F, 0x80,
  0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0xE3,
  0xC0, 0xFF, 0xFB, 0xE0, 0xFC, 0x1D, 0xE0, 0x78, 0x07, 0xF0, 0x7C, 0x01,
  0xF8, 0x7C, 0x00, 0xFC, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x1F, 0xC1, 0xF8, 0x3D, 0xE0, 0x7F, 0xFD, 0xF0, 0x1F, 0xF8, 0xF0,
  0x03, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xF0, 0x07, 0x9F, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F,
  0x78, 0x3E, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x60, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x07,
  0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xCF, 0x80, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0x07, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0xF8,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x1F, 0x07,
  0xC0, 0x73, 0xF8, 0xFE, 0x0F, 0x7F, 0x9F, 0xE0, 0xFC, 0x7B, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x7C,
  0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1,
  0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C,
  0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x81,
  0xE0, 0x78, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F,
  0x0F, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xF0, 0x0F, 0x1F, 0xFC, 0x0F, 0x3F,
  0xFE, 0x0F, 0x78, 0x3E, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x7C, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xE1, 0xFC, 0x00, 0xF9, 0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x0F,
  0x70, 0x3E, 0x03, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC1,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x1F,
  0x01, 0xFE, 0x0F, 0xC0, 0xFB, 0xFF, 0xE0, 0x3C, 0x7F, 0xE0, 0x0F, 0x0F,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0x03, 0xFF, 0x8F, 0x07, 0xFF, 0xDF, 0x0F, 0xC1, 0xFE, 0x1F, 0x00,
  0x7E, 0x1E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xF0, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x06, 0xF0, 0xFC, 0x1F, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xF1,
  0xE0, 0x0F, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x01,
  0xFE, 0x1E, 0x1F, 0xFC, 0x3C, 0x7F, 0xF8, 0x79, 0xFF, 0xE0, 0xF7, 0xC0,
  0x01, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03,
  0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE3, 0x00, 0x03, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x3E, 0x3F, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x06, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C,
  0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x0E, 0xF0, 0x7F, 0xFC, 0xF0, 0x3F,
  0xF1, 0xE0, 0x1F, 0xC1, 0xE0, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xE7,
  0x80, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07,
  0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x7C,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x03, 0xE0, 0x78, 0x78,
  0x1F, 0x03, 0xC3, 0xC1, 0xF8, 0x3C, 0x1E, 0x0F, 0xC1, 0xE0, 0xF0, 0xEE,
  0x0F, 0x07, 0x87, 0x70, 0xF0, 0x3C, 0x73, 0x87, 0x81, 0xE3, 0x9E, 0x3C,
  0x0F, 0x38, 0x73, 0xC0, 0x71, 0xC3, 0x9E, 0x03, 0x9C, 0x1C, 0xE0, 0x3C,
  0xE0, 0xEF, 0x01, 0xEE, 0x07, 0x78, 0x0F, 0x70, 0x3B, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x07,
  0xE0, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8,
};

const GFXglyph LiberationMono_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 10, 32, 29, 10, -32 },
  { 41, 18, 15, 29, 9, -35 },
  { 75, 28, 32, 29, 1, -32 },
  { 187, 27, 39, 29, 1, -35 },
  { 319, 32, 32, 29, -1, -32 },
  { 447, 26, 32, 29, 0, -32 },
  { 551, 7, 15, 29, 14, -35 },
  { 565, 18, 45, 29, 7, -35 },
  { 667, 18, 45, 29, 3, -35 },
  { 769, 17, 17, 29, 9, -35 },
  { 806, 23, 23, 29, 3, -28 },
  { 873, 13, 16, 29, 2, -7 },
  { 899, 14, 4, 29, 7, -14 },
  { 906, 7, 7, 29, 9, -7 },
  { 913, 30, 35, 29, 0, -35 },
  { 1045, 24, 32, 29, 3, -32 },
  { 1141, 24, 32, 29, 1, -32 },
  { 1237, 26, 32, 29, 1, -32 },
  { 1341, 25, 32, 29, 2, -32 },
  { 1441, 25, 32, 29, 1, -32 },
  { 1541, 26, 32, 29, 2, -32 },
  { 1645, 24, 32, 29, 3, -32 },
  { 1741, 22, 32, 29, 7, -32 },
  { 1829, 25, 32, 29, 2, -32 },
  { 1929, 24, 32, 29, 3, -32 },
  { 2025, 11, 26, 29, 9, -26 },
  { 2061, 16, 35, 29, 4, -26 },
  { 2131, 23, 24, 29, 3, -28 },
  { 2200, 23, 16, 29, 3, -24 },
  { 2246, 23, 24, 29, 3, -28 },
  { 2315, 23, 32, 29, 4, -32 },
  { 2407, 29, 41, 29, 0, -35 },
  { 2556, 28, 32, 29, -2, -32 },
  { 2668, 26, 32, 29, 1, -32 },
  { 2772, 25, 32, 29, 3, -32 },
  { 2872, 27, 32, 29, 1, -32 },
  { 2980, 28, 32, 29, 1, -32 },
  { 3092, 27, 32, 29, 2, -32 },
  { 3200, 25, 32, 29, 3, -32 },
  { 3300, 28, 32, 29, 1, -32 },
  { 3412, 26, 32, 29, 2, -32 },
  { 3516, 24, 32, 29, 3, -32 },
  { 3612, 30, 32, 29, 1, -32 },
  { 3732, 21, 32, 29, 3, -32 },
  { 3816, 28, 32, 29, 1, -32 },
  { 3928, 28, 32, 29, 1, -32 },
  { 4040, 26, 32, 29, 2, -32 },
  { 4144, 27, 32, 29, 1, -32 },
  { 4252, 26, 42, 29, 2, -32 },
  { 4389, 27, 32, 29, 1, -32 },
  { 4497, 27, 32, 29, 1, -32 },
  { 4605, 26, 32, 29, 5, -32 },
  { 4709, 26, 32, 29, 3, -32 },
  { 4813, 28, 32, 29, 4, -32 },
  { 4925, 30, 32, 29, 2, -32 },
  { 5045, 33, 32, 29, -2, -32 },
  { 5177, 27, 32, 29, 5, -32 },
  { 5285, 31, 32, 29, -1, -32 },
  { 5409, 22, 45, 29, 5, -35 },
  { 5533, 17, 35, 29, 7, -35 },
  { 5608, 21, 45, 29, 2, -35 },
  { 5727, 22, 21, 29, 3, -32 },
  { 5785, 30, 2, 29, -4, 3 },
  { 5793, 9, 6, 29, 13, -34 },
  { 5800, 23, 26, 29, 2, -26 },
  { 5875, 24, 35, 29, 2, -35 },
  { 5980, 23, 26, 29, 3, -26 },
  { 6055, 26, 35, 29, 3, -35 },
  { 6169, 23, 26, 29, 3, -26 },
  { 6244, 25, 35, 29, 5, -35 },
  { 6354, 25, 36, 29, 2, -26 },
  { 6467, 24, 35, 29, 2, -35 },
  { 6572, 24, 35, 29, 1, -35 },
  { 6677, 25, 45, 29, -1, -35 },
  { 6818, 25, 35, 29, 3, -35 },
  { 6928, 23, 35, 29, 1, -35 },
  { 7029, 28, 26, 29, 0, -26 },
  { 7120, 24, 26, 29, 2, -26 },
  { 7198, 23, 26, 29, 3, -26 },
  { 7273, 26, 36, 29, 0, -26 },
  { 7390, 24, 36, 29, 3, -26 },
  { 7498, 23, 26, 29, 4, -26 },
  { 7573, 23, 26, 29, 3, -26 },
  { 7648, 19, 33, 29, 6, -33 },
  { 7727, 24, 26, 29, 3, -26 },
  { 7805, 26, 26, 29, 4, -26 },
  { 7890, 29, 26, 29, 2, -26 },
  { 7985, 28, 26, 29, 0, -26 },
  { 8076, 30, 36, 29, 0, -26 },
  { 8211, 26, 26, 29, 1, -26 },
  { 8296, 24, 45, 29, 5, -35 },
  { 8431, 4, 45, 29, 12, -35 },
  { 8454, 25, 45, 29, -1, -35 },
  { 8595, 24, 6, 29, 3, -19 },
};

const GFXfont LiberationMono_Italic48pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic48pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic48pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _LIBERATIONMONO_ITALIC48PT7B_H_
