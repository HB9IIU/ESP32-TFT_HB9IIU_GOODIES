#ifndef _LIBERATIONMONO_ITALIC65PT7B_H_
#define _LIBERATIONMONO_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x1E, 0x3F, 0xE0, 0x1F,
  0xE0, 0x78, 0x3F, 0x80, 0x7E, 0x03, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x0E, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0x3E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x3F, 0xF0,
  0x00, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x7E, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x1F, 0x81, 0xC0, 0x0F, 0x00, 0x7E, 0x3F, 0x00, 0x3C,
  0x01, 0xF0, 0xFC, 0x01, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0x80, 0x3F, 0x0F,
  0xE0, 0x1E, 0x01, 0xF8, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x7F, 0x81, 0xE0,
  0x7F, 0x00, 0xFF, 0x8F, 0x8F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0xF8,
  0x00, 0x01, 0xF8, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0x07, 0x80, 0x00,
  0x01, 0xFF, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xC3, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0xFC, 0x3F,
  0x00, 0x00, 0x3C, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0xC0,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x7F, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x30, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x7F, 0xF0, 0x00,
  0xF8, 0x3F, 0xBF, 0x00, 0x3E, 0x0F, 0xE3, 0xE0, 0x07, 0xC1, 0xF8, 0x7E,
  0x01, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x07, 0x83, 0xE0,
  0x1F, 0x81, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x87,
  0xE0, 0x03, 0xF3, 0xE0, 0xFC, 0x00, 0x7F, 0x7C, 0x1F, 0x00, 0x07, 0xFF,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xFC, 0x03, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFC,
  0x7F, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xF8, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x83, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x08, 0x0F, 0x01, 0x3E, 0x1E,
  0x1F, 0x7F, 0x39, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x00,
  0x0F, 0x9F, 0x00, 0x3E, 0x1E, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x04, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0x81, 0xFE, 0x07, 0xCF, 0xC0, 0xFF, 0x03, 0xE7, 0xE0, 0x7F,
  0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xF9, 0xF8, 0x3F, 0xC0, 0xFC, 0xF8, 0x1F,
  0xE0, 0x7E, 0xFC, 0x0F, 0xF0, 0x3E, 0x7E, 0x07, 0xF0, 0x3F, 0x3F, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFD, 0xF0, 0x01, 0xFF, 0xF7, 0xE0,
  0x03, 0xFF, 0xCF, 0xC0, 0x07, 0xFE, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x07, 0xFC, 0x00, 0x07, 0xCF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x38, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F,
  0x0F, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xE0, 0x7E,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0x80, 0x00,
  0xFF, 0x1F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFE, 0x0F, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0xFE, 0x7C, 0x03, 0xFF, 0xFC,
  0x7C, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x1F, 0xF1, 0xCF, 0x01, 0xE0, 0x3F, 0xF3, 0xCF, 0x03, 0xE0,
  0xF8, 0x73, 0xCF, 0x03, 0xC0, 0xF0, 0x3F, 0x8F, 0x07, 0xC1, 0xE0, 0x3F,
  0x8F, 0x07, 0x83, 0xC0, 0x3F, 0x0F, 0x0F, 0x87, 0x80, 0x3F, 0x0F, 0x0F,
  0x07, 0x80, 0x3F, 0x0F, 0x0F, 0x0F, 0x00, 0x3E, 0x0E, 0x1E, 0x0F, 0x00,
  0x3E, 0x1E, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x1E, 0x1E, 0x00, 0x7C, 0x1E,
  0x3E, 0x3E, 0x00, 0x7C, 0x1E, 0x3C, 0x3C, 0x00, 0x78, 0x1C, 0x3C, 0x3C,
  0x00, 0xF8, 0x3C, 0x3C, 0x7C, 0x00, 0xF8, 0x3C, 0x78, 0x78, 0x00, 0xF0,
  0x38, 0x78, 0x78, 0x01, 0xF0, 0x78, 0x78, 0xF8, 0x01, 0xE0, 0x78, 0x78,
  0xF8, 0x01, 0xE0, 0x70, 0x78, 0xF8, 0x03, 0xE0, 0xF0, 0x78, 0xF0, 0x03,
  0xC0, 0xF0, 0x78, 0xF0, 0x07, 0xC0, 0xE0, 0xF8, 0xF0, 0x0F, 0xC1, 0xE0,
  0xF0, 0xF0, 0x0F, 0x81, 0xC0, 0xF0, 0xF0, 0x1F, 0x83, 0x80, 0xF0, 0xF8,
  0x3B, 0x87, 0x80, 0xF8, 0x78, 0x73, 0x8F, 0x00, 0xF8, 0x7F, 0xE3, 0xFE,
  0x00, 0x78, 0x3F, 0xC3, 0xFC, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xF8,
  0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xE0, 0xFC,
  0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x04, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x30, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xF3, 0xF8, 0x03,
  0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0xFF, 0x8F, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0xFF,
  0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x00,
  0x1F, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xDF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x07, 0xDF,
  0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x07, 0x9F, 0x00, 0xFC, 0xF8, 0x1F, 0x3E, 0x01, 0xF1,
  0xF0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x07, 0xC7, 0xE3, 0xE1,
  0xF0, 0x0F, 0x87, 0xC7, 0xC7, 0xC0, 0x3F, 0x0F, 0x9F, 0x0F, 0x80, 0x7C,
  0x1F, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0x01, 0xF0, 0x7D, 0xE0,
  0x7C, 0x03, 0xE0, 0x7F, 0xC1, 0xF8, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x1F,
  0x01, 0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x7C, 0x03, 0xFE,
  0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x01, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0x80,
  0x03, 0xE0, 0x1F, 0x7E, 0x00, 0x1F, 0x00, 0xF9, 0xF0, 0x01, 0xF8, 0x07,
  0xCF, 0x80, 0x0F, 0xC0, 0x3E, 0x7E, 0x00, 0x7C, 0x03, 0xF3, 0xF0, 0x03,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x1F, 0x83, 0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0x1F, 0x0F,
  0xC0, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x07, 0xEF, 0xC0,
  0x3E, 0x00, 0x3F, 0x7E, 0x01, 0xF0, 0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x07,
  0xDF, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x3E,
  0x00, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0xFF,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x03,
  0xE0, 0x3F, 0x01, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F,
  0xC0, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0x7B, 0xC0, 0xFC, 0x03, 0xF0, 0x7D,
  0xE0, 0x7C, 0x01, 0xF8, 0x3C, 0xF0, 0x3E, 0x00, 0xFC, 0x3E, 0x7C, 0x3F,
  0x00, 0x7C, 0x1E, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x8F, 0x87, 0xC0, 0x0F, 0x87, 0x87, 0xC7, 0xC0, 0x07, 0xC7, 0xC3,
  0xE3, 0xE0, 0x03, 0xE3, 0xC1, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0xF9, 0xF0,
  0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x1E, 0x7C, 0x00, 0x3E,
  0xF0, 0x0F, 0x7C, 0x00, 0x1F, 0x78, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x03,
  0xDF, 0x00, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00,
  0x3F, 0xF0, 0xFE, 0x00, 0x7B, 0xF0, 0x7F, 0x83, 0xF3, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC3, 0xFF, 0xE0,
  0x07, 0xE7, 0xFF, 0xF8, 0x03, 0xE7, 0xFF, 0xFE, 0x03, 0xF7, 0xC0, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x03, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x3F,
  0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xF8, 0x01, 0xFC, 0x0F,
  0xDF, 0x03, 0xFC, 0x07, 0xEF, 0xFF, 0xFC, 0x03, 0xE3, 0xFF, 0xFC, 0x03,
  0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F,
  0x1F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x3F, 0xFF,
  0xCF, 0xC0, 0x0F, 0xFF, 0xFD, 0xF8, 0x03, 0xFC, 0x0F, 0xBF, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x03,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFB, 0xE0, 0x07, 0xFF, 0xFE, 0x7C,
  0x00, 0x7F, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x07, 0xE0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0x00, 0x3F, 0xFF, 0xE3, 0xE0,
  0x0F, 0xF0, 0x3E, 0xFC, 0x03, 0xF8, 0x01, 0xDF, 0x80, 0x7E, 0x00, 0x3F,
  0xE0, 0x1F, 0x80, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xEF,
  0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0x7E, 0x00, 0xFF, 0xFF,
  0xCF, 0xC0, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xF8, 0x03, 0xF1, 0xFF, 0xFC,
  0x03, 0xE7, 0xFF, 0xFE, 0x07, 0xEF, 0x81, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0x07, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xF3, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0xE0, 0xFF, 0x80, 0xF9, 0xFF, 0x8F,
  0xFE, 0x07, 0xDF, 0xFC, 0xFF, 0xF0, 0x3F, 0xC3, 0xE7, 0x1F, 0x81, 0xEC,
  0x1F, 0x60, 0x7C, 0x0F, 0xC0, 0xFF, 0x03, 0xE0, 0xFE, 0x07, 0xF0, 0x1F,
  0x07, 0xE0, 0x3F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87,
  0xE0, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x00,
  0xFC, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0xFF,
  0xF8, 0x03, 0xE1, 0xFF, 0xFC, 0x03, 0xE7, 0xFF, 0xFE, 0x07, 0xEF, 0x81,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0x01, 0xF1, 0xFF, 0xFE, 0x00, 0x3E,
  0x7F, 0xFF, 0xE0, 0x0F, 0xDF, 0x03, 0xFC, 0x01, 0xFB, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0xFD, 0xF0, 0x3F, 0xC0, 0x1F, 0xBF, 0xFF, 0xF0, 0x03, 0xF3, 0xFF,
  0xFC, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0xC0,
  0x3F, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0xF7, 0xE0, 0x3F, 0xC0, 0xFB, 0xF0,
  0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0x80, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xFC,
  0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xDF, 0x80, 0xFF,
  0x03, 0xEF, 0x80, 0x7F, 0xFF, 0xE7, 0xC0, 0x1F, 0xFF, 0xC7, 0xE0, 0x07,
  0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x0F, 0x80, 0xFF, 0xF8, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF,
  0xE0, 0x7E, 0x3F, 0xFF, 0xC0, 0xFC, 0xFE, 0x00, 0x81, 0xFB, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x1C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x03, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07,
  0xF0, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xDF, 0x80, 0xFF, 0xFF, 0xCF, 0xC0,
  0x3F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0x83, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x03,
  0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0xC0, 0x3E,
  0x07, 0xC0, 0x7F, 0x80, 0x7C, 0x0F, 0x80, 0xFF, 0x81, 0xF8, 0x1F, 0x03,
  0xDF, 0x03, 0xE0, 0x3E, 0x07, 0x9E, 0x0F, 0xC0, 0x7C, 0x1E, 0x3C, 0x1F,
  0x80, 0xF8, 0x3C, 0x78, 0x3E, 0x01, 0xF0, 0xF8, 0xF0, 0xFC, 0x07, 0xE1,
  0xE1, 0xE1, 0xF0, 0x0F, 0xC7, 0xC3, 0xC3, 0xE0, 0x1F, 0x8F, 0x07, 0x8F,
  0xC0, 0x3F, 0x3C, 0x0F, 0x9F, 0x00, 0x7E, 0x78, 0x1F, 0x3E, 0x00, 0xF9,
  0xE0, 0x3E, 0xFC, 0x01, 0xF3, 0xC0, 0x3D, 0xF0, 0x03, 0xEF, 0x00, 0x7B,
  0xE0, 0x07, 0xDE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x5F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80,
  0x7F, 0xFF, 0xFA, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
};

const GFXglyph LiberationMono_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 15, 43, 39, 13, -43 },
  { 82, 24, 20, 39, 12, -47 },
  { 142, 38, 43, 39, 1, -43 },
  { 347, 38, 52, 39, 1, -47 },
  { 594, 43, 45, 39, -1, -44 },
  { 836, 35, 45, 39, 0, -44 },
  { 1033, 10, 20, 39, 19, -47 },
  { 1058, 24, 60, 39, 10, -47 },
  { 1238, 24, 60, 39, 5, -47 },
  { 1418, 23, 23, 39, 12, -47 },
  { 1485, 31, 33, 39, 4, -38 },
  { 1613, 18, 21, 39, 3, -9 },
  { 1661, 19, 5, 39, 10, -20 },
  { 1673, 10, 9, 39, 12, -9 },
  { 1685, 41, 48, 39, 0, -47 },
  { 1931, 33, 45, 39, 4, -44 },
  { 2117, 31, 43, 39, 2, -43 },
  { 2284, 36, 44, 39, 1, -44 },
  { 2482, 34, 45, 39, 3, -44 },
  { 2674, 33, 43, 39, 2, -43 },
  { 2852, 34, 44, 39, 3, -43 },
  { 3039, 32, 45, 39, 5, -44 },
  { 3219, 30, 43, 39, 9, -43 },
  { 3381, 34, 45, 39, 3, -44 },
  { 3573, 32, 45, 39, 4, -44 },
  { 3753, 15, 34, 39, 12, -34 },
  { 3817, 21, 46, 39, 6, -34 },
  { 3938, 31, 33, 39, 4, -38 },
  { 4066, 31, 21, 39, 4, -32 },
  { 4148, 31, 33, 39, 4, -38 },
  { 4276, 31, 44, 39, 6, -44 },
  { 4447, 40, 56, 39, 0, -47 },
  { 4727, 39, 43, 39, -3, -43 },
  { 4937, 35, 43, 39, 2, -43 },
  { 5126, 34, 45, 39, 4, -44 },
  { 5318, 35, 43, 39, 2, -43 },
  { 5507, 37, 43, 39, 2, -43 },
  { 5706, 36, 43, 39, 3, -43 },
  { 5900, 34, 45, 39, 4, -44 },
  { 6092, 37, 43, 39, 2, -43 },
  { 6291, 35, 43, 39, 3, -43 },
  { 6480, 32, 44, 39, 4, -43 },
  { 6656, 39, 43, 39, 2, -43 },
  { 6866, 29, 43, 39, 4, -43 },
  { 7022, 39, 43, 39, 1, -43 },
  { 7232, 37, 43, 39, 2, -43 },
  { 7431, 34, 45, 39, 3, -44 },
  { 7623, 36, 43, 39, 2, -43 },
  { 7817, 34, 57, 39, 3, -44 },
  { 8060, 37, 43, 39, 2, -43 },
  { 8259, 37, 45, 39, 1, -44 },
  { 8468, 36, 43, 39, 6, -43 },
  { 8662, 36, 44, 39, 3, -43 },
  { 8860, 39, 43, 39, 5, -43 },
  { 9070, 41, 43, 39, 3, -43 },
  { 9291, 44, 43, 39, -2, -43 },
  { 9528, 37, 43, 39, 6, -43 },
  { 9727, 41, 43, 39, -1, -43 },
  { 9948, 29, 60, 39, 7, -47 },
  { 10166, 23, 48, 39, 9, -47 },
  { 10304, 29, 60, 39, 3, -47 },
  { 10522, 30, 29, 39, 4, -43 },
  { 10631, 40, 3, 39, -5, 4 },
  { 10646, 12, 8, 39, 18, -46 },
  { 10658, 32, 36, 39, 2, -35 },
  { 10802, 33, 48, 39, 2, -47 },
  { 11000, 32, 36, 39, 4, -35 },
  { 11144, 35, 48, 39, 4, -47 },
  { 11354, 31, 36, 39, 4, -35 },
  { 11494, 34, 47, 39, 7, -47 },
  { 11694, 35, 48, 39, 2, -35 },
  { 11904, 32, 47, 39, 3, -47 },
  { 12092, 32, 47, 39, 1, -47 },
  { 12280, 34, 60, 39, -2, -47 },
  { 12535, 34, 47, 39, 4, -47 },
  { 12735, 32, 47, 39, 1, -47 },
  { 12923, 37, 35, 39, 0, -35 },
  { 13085, 32, 35, 39, 3, -35 },
  { 13225, 31, 36, 39, 4, -35 },
  { 13365, 35, 48, 39, 0, -35 },
  { 13575, 33, 48, 39, 4, -35 },
  { 13773, 31, 35, 39, 6, -35 },
  { 13909, 32, 36, 39, 3, -35 },
  { 14053, 26, 44, 39, 8, -43 },
  { 14196, 33, 35, 39, 4, -34 },
  { 14341, 34, 34, 39, 6, -34 },
  { 14486, 39, 34, 39, 3, -34 },
  { 14652, 39, 34, 39, 0, -34 },
  { 14818, 41, 47, 39, -1, -34 },
  { 15059, 35, 34, 39, 1, -34 },
  { 15208, 32, 60, 39, 7, -47 },
  { 15448, 5, 60, 39, 17, -47 },
  { 15486, 33, 60, 39, -1, -47 },
  { 15734, 33, 8, 39, 4, -26 },
};

const GFXfont LiberationMono_Italic65pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic65pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic65pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _LIBERATIONMONO_ITALIC65PT7B_H_
