#ifndef _LIBERATIONMONO_ITALIC61PT7B_H_
#define _LIBERATIONMONO_ITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01,
  0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC1,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x1E, 0x3F, 0xC0, 0x3F, 0x83,
  0xC1, 0xF8, 0x07, 0xC0, 0x78, 0x1F, 0x81, 0xF8, 0x0F, 0x03, 0xF0, 0x3E,
  0x01, 0xC0, 0x7E, 0x07, 0xC0, 0x78, 0x07, 0xC1, 0xF8, 0x0F, 0x00, 0xC0,
  0x3F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x7E, 0x07, 0x00,
  0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x3F, 0xC0,
  0x00, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0xFC, 0x18, 0x01, 0xE0, 0x1F, 0x1F, 0x00, 0x38, 0x03, 0xE3, 0xF0,
  0x0F, 0x00, 0x7C, 0x7E, 0x01, 0xE0, 0x1F, 0x8F, 0xC0, 0x3C, 0x07, 0xE0,
  0xFC, 0x07, 0x80, 0xFC, 0x1F, 0xC0, 0xE0, 0x7F, 0x01, 0xFE, 0x1C, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0x80, 0x00, 0x07,
  0xFF, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x80,
  0x00, 0x00, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xE1, 0xFF, 0xF0, 0x00, 0x03,
  0xC3, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0x80,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0xF8, 0x00,
  0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x1F, 0x00,
  0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x7C, 0x00, 0x0F, 0xFF,
  0x80, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x78, 0x7F,
  0x00, 0x00, 0x3E, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x1F, 0xF8,
  0x00, 0xF8, 0x3F, 0xFE, 0x00, 0x78, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x0F,
  0x80, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80,
  0xFC, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0x87, 0xC0,
  0x07, 0xE7, 0x83, 0xE0, 0x03, 0xF7, 0xC1, 0xF0, 0x00, 0xFF, 0xC0, 0xF8,
  0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x02,
  0x03, 0x80, 0x9F, 0x0E, 0x1E, 0x7F, 0x3B, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x79, 0xC0,
  0x03, 0xC7, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF8, 0x0E,
  0x03, 0xC0, 0x10, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFE, 0xFE,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C,
  0xFC, 0x1F, 0xC0, 0xF9, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x07, 0xE7,
  0xC0, 0xFE, 0x0F, 0xDF, 0x83, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x3E, 0x7C,
  0x0F, 0xE0, 0x7C, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x7E, 0x00, 0x7F, 0xF3, 0xE0, 0x07, 0xFE, 0x1F, 0x00, 0x3F, 0xC0,
  0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x83,
  0xFC, 0x00, 0x07, 0xCF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7C,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x00,
  0x3F, 0x1F, 0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0xF9, 0xFF, 0xFF, 0x01,
  0xF7, 0xC0, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xE1,
  0xFC, 0x01, 0xEF, 0x87, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFD, 0xF0, 0x1F,
  0xFF, 0xC7, 0xC0, 0x3F, 0xFE, 0x1F, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x1E, 0x03,
  0xFC, 0x73, 0x81, 0xE0, 0x7F, 0xE7, 0x9C, 0x0F, 0x07, 0xC7, 0xB8, 0xE0,
  0xF0, 0x7C, 0x1F, 0xC7, 0x07, 0x87, 0xC0, 0x7E, 0x38, 0x78, 0x3C, 0x03,
  0xE1, 0xC3, 0xC3, 0xC0, 0x1F, 0x1E, 0x1C, 0x3C, 0x00, 0xF0, 0xF1, 0xE1,
  0xE0, 0x0F, 0x87, 0x8F, 0x1E, 0x00, 0x7C, 0x3C, 0x70, 0xF0, 0x03, 0xC1,
  0xC7, 0x8F, 0x80, 0x1E, 0x1E, 0x3C, 0x78, 0x01, 0xE0, 0xF1, 0xC3, 0xC0,
  0x0F, 0x07, 0x9E, 0x3E, 0x00, 0x70, 0x38, 0xF1, 0xE0, 0x07, 0x83, 0xC7,
  0x8F, 0x00, 0x3C, 0x1E, 0x3C, 0x78, 0x03, 0xC0, 0xE1, 0xE3, 0xC0, 0x1E,
  0x0F, 0x0E, 0x1E, 0x01, 0xF0, 0x70, 0xF1, 0xE0, 0x0F, 0x07, 0x87, 0x8F,
  0x00, 0xF8, 0x38, 0x3C, 0x3C, 0x0D, 0xC3, 0xC1, 0xE1, 0xE0, 0xFE, 0x3C,
  0x0F, 0x0F, 0x0E, 0xF3, 0xC0, 0x78, 0x7F, 0xE7, 0xFC, 0x03, 0xC1, 0xFE,
  0x1F, 0xC0, 0x0F, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x80, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xFC, 0x0F,
  0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x07, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x01, 0xF8,
  0x00, 0x01, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0xC3, 0xF0, 0x07,
  0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F,
  0x80, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00,
  0x7E, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFE, 0x03, 0xEF, 0x00, 0x7B, 0xE0, 0x3C, 0xF0, 0x0F, 0xBE, 0x07, 0xCF,
  0x80, 0xF3, 0xC0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xCF, 0x81, 0xE7, 0xC0,
  0x7C, 0xF8, 0x3E, 0x7C, 0x07, 0x8F, 0x87, 0xC7, 0xC0, 0xF8, 0x78, 0x78,
  0x78, 0x0F, 0x87, 0xCF, 0x8F, 0x80, 0xF8, 0x7C, 0xF0, 0xF8, 0x0F, 0x87,
  0xDF, 0x0F, 0x80, 0xF8, 0x7D, 0xE0, 0xF8, 0x0F, 0x03, 0xFE, 0x0F, 0x01,
  0xF0, 0x3F, 0xC1, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x81,
  0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xE0, 0x3F, 0x01, 0xE0, 0x3E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x1F, 0xE0,
  0x00, 0x7C, 0x07, 0xF8, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0xFF,
  0xC0, 0x03, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x03,
  0xFF, 0x00, 0x0F, 0x80, 0xFB, 0xE0, 0x07, 0xE0, 0x7C, 0xF8, 0x01, 0xF0,
  0x1F, 0x3E, 0x00, 0x7C, 0x07, 0xCF, 0xC0, 0x1F, 0x01, 0xF1, 0xF0, 0x07,
  0xC0, 0x7C, 0x7C, 0x03, 0xF0, 0x3F, 0x1F, 0x00, 0xF8, 0x0F, 0x87, 0xE0,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0xF8, 0x7C, 0x07,
  0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x03, 0xF3, 0xE0,
  0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xCF,
  0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x0F,
  0xFC, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0xF8, 0x00,
  0x1F, 0xE0, 0x3E, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x07, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0x01,
  0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x01, 0xF0, 0x3D, 0xE0, 0x7C,
  0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x1F, 0x03, 0xDE, 0x0F, 0x80, 0x7C, 0x1E,
  0x78, 0x3E, 0x01, 0xF0, 0x79, 0xE0, 0xF8, 0x07, 0xC3, 0xC7, 0x87, 0xC0,
  0x1F, 0x0F, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x78, 0x7C, 0x01, 0xF1, 0xE1,
  0xE3, 0xE0, 0x07, 0xCF, 0x87, 0x8F, 0x80, 0x1E, 0x3C, 0x1E, 0x3E, 0x00,
  0x79, 0xF0, 0x78, 0xF0, 0x01, 0xE7, 0x81, 0xE7, 0xC0, 0x0F, 0x9E, 0x07,
  0x9F, 0x00, 0x3E, 0xF0, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x1D,
  0xF0, 0xFE, 0x00, 0xFF, 0xC1, 0xFC, 0x1F, 0xBF, 0x87, 0xFF, 0xFC, 0x7F,
  0xCF, 0xFF, 0xC1, 0xFF, 0x1F, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x00, 0x3F,
  0x0F, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0x00, 0xF9, 0xFF, 0xFF, 0x01, 0xF7,
  0xC0, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFC, 0x1F, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xE0, 0x07, 0xE0, 0x7D,
  0xF0, 0x3F, 0x80, 0xF9, 0xFF, 0xFE, 0x01, 0xF3, 0xFF, 0xF8, 0x07, 0xE3,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x3F,
  0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0xF7, 0xE0, 0x0F, 0xF0, 0x3D, 0xF8, 0x07,
  0xF0, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xFC,
  0x01, 0xF8, 0x01, 0xDF, 0x00, 0x7F, 0x81, 0xEF, 0xC0, 0x0F, 0xFF, 0xFB,
  0xF0, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0C, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x0F, 0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF, 0xF3, 0xE0,
  0x1F, 0xE0, 0x7B, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8,
  0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0x7C, 0x03, 0xFC, 0x0F, 0xBE, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x3F,
  0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0x0F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x81, 0xFE, 0x00, 0x1F, 0x0F, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0x00,
  0xF9, 0xFF, 0xFF, 0x01, 0xF7, 0xC0, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x60, 0x0F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x0F, 0x87, 0xF0, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xE0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x78, 0xFF, 0x07, 0xF8, 0x0F, 0x3F, 0xE3, 0xFF, 0x81,
  0xEF, 0xFE, 0x7F, 0xF0, 0x7D, 0x8F, 0xDC, 0x7E, 0x0F, 0xE0, 0xFF, 0x07,
  0xC1, 0xF8, 0x1F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x0F, 0x83,
  0xE0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xC1, 0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xE0, 0x1F,
  0x3F, 0xFF, 0xE0, 0x3E, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFE,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x1F, 0xFE, 0x00,
  0x3F, 0x3F, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0xE0, 0x0F, 0xBE, 0x07, 0xF0,
  0x07, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3F, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0xFB, 0xE0, 0x7F, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0x3E,
  0x7F, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x03, 0xFF, 0xF8,
  0xF8, 0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xC0, 0xF7, 0xE0, 0xFE, 0x00, 0xFF,
  0x81, 0xF8, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x07, 0x7C, 0x0F, 0xF0, 0x3D, 0xF8, 0x0F, 0xFF, 0xF3,
  0xE0, 0x0F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0x0F, 0x80, 0x07, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0xF8, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xF0, 0xFC,
  0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0xF0, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xFC, 0x01, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xEF, 0x81, 0xFF, 0xFF, 0x3E, 0x07,
  0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0x87, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x0F, 0x87, 0xC0, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0xFC, 0x0F, 0xF0, 0x3E, 0x0F, 0xC1, 0xFF,
  0x03, 0xE0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x83, 0xEF, 0x07, 0xC0, 0xF8,
  0x3C, 0xF0, 0x7C, 0x0F, 0x87, 0xC7, 0x8F, 0xC0, 0xF8, 0x78, 0x78, 0xF8,
  0x0F, 0x8F, 0x87, 0x8F, 0x80, 0xF8, 0xF0, 0x79, 0xF0, 0x0F, 0x9E, 0x07,
  0x9F, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x0F, 0xBC, 0x07, 0x9E, 0x00, 0xFB,
  0xC0, 0x7B, 0xE0, 0x0F, 0xF8, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x3B, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0x3F, 0xFF, 0xC0,
  0x06, 0x7F, 0xFF, 0xF8, 0x1E, 0x78, 0x0F, 0xFF, 0xFE, 0x60, 0x03, 0xFF,
  0xFE, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 40, 37, 12, -40 },
  { 71, 23, 19, 37, 11, -44 },
  { 126, 36, 40, 37, 1, -40 },
  { 306, 35, 49, 37, 1, -44 },
  { 521, 40, 42, 37, -1, -41 },
  { 731, 33, 42, 37, 0, -41 },
  { 905, 9, 19, 37, 18, -44 },
  { 927, 23, 57, 37, 9, -44 },
  { 1091, 23, 57, 37, 4, -44 },
  { 1255, 22, 21, 37, 11, -44 },
  { 1313, 30, 30, 37, 3, -35 },
  { 1426, 17, 20, 37, 2, -9 },
  { 1469, 18, 5, 37, 9, -19 },
  { 1481, 8, 9, 37, 12, -9 },
  { 1490, 39, 45, 37, 0, -44 },
  { 1710, 31, 42, 37, 4, -41 },
  { 1873, 29, 40, 37, 2, -40 },
  { 2018, 34, 41, 37, 1, -41 },
  { 2193, 32, 42, 37, 3, -41 },
  { 2361, 31, 40, 37, 2, -40 },
  { 2516, 33, 41, 37, 2, -40 },
  { 2686, 31, 42, 37, 4, -41 },
  { 2849, 28, 40, 37, 9, -40 },
  { 2989, 32, 42, 37, 3, -41 },
  { 3157, 30, 42, 37, 4, -41 },
  { 3315, 13, 32, 37, 12, -32 },
  { 3367, 20, 43, 37, 5, -32 },
  { 3475, 30, 31, 37, 3, -36 },
  { 3592, 30, 20, 37, 3, -30 },
  { 3667, 30, 31, 37, 3, -36 },
  { 3784, 30, 41, 37, 5, -41 },
  { 3938, 37, 51, 37, 0, -44 },
  { 4174, 36, 40, 37, -3, -40 },
  { 4354, 33, 40, 37, 2, -40 },
  { 4519, 33, 42, 37, 3, -41 },
  { 4693, 33, 40, 37, 2, -40 },
  { 4858, 35, 40, 37, 2, -40 },
  { 5033, 34, 40, 37, 3, -40 },
  { 5203, 33, 42, 37, 3, -41 },
  { 5377, 34, 40, 37, 2, -40 },
  { 5547, 32, 40, 37, 3, -40 },
  { 5707, 30, 41, 37, 4, -40 },
  { 5861, 37, 40, 37, 2, -40 },
  { 6046, 27, 40, 37, 4, -40 },
  { 6181, 36, 40, 37, 1, -40 },
  { 6361, 34, 40, 37, 2, -40 },
  { 6531, 32, 42, 37, 3, -41 },
  { 6699, 34, 40, 37, 2, -40 },
  { 6869, 32, 53, 37, 3, -41 },
  { 7081, 34, 40, 37, 2, -40 },
  { 7251, 35, 42, 37, 1, -41 },
  { 7435, 33, 40, 37, 6, -40 },
  { 7600, 34, 41, 37, 3, -40 },
  { 7775, 36, 40, 37, 5, -40 },
  { 7955, 38, 40, 37, 3, -40 },
  { 8145, 41, 40, 37, -2, -40 },
  { 8350, 34, 40, 37, 6, -40 },
  { 8520, 39, 40, 37, -1, -40 },
  { 8715, 27, 57, 37, 7, -44 },
  { 8908, 21, 45, 37, 9, -44 },
  { 9027, 28, 57, 37, 2, -44 },
  { 9227, 29, 27, 37, 3, -40 },
  { 9325, 38, 3, 37, -5, 4 },
  { 9340, 12, 8, 37, 17, -44 },
  { 9352, 30, 34, 37, 2, -33 },
  { 9480, 31, 45, 37, 2, -44 },
  { 9655, 30, 34, 37, 3, -33 },
  { 9783, 34, 45, 37, 3, -44 },
  { 9975, 30, 34, 37, 3, -33 },
  { 10103, 32, 44, 37, 6, -44 },
  { 10279, 33, 46, 37, 2, -33 },
  { 10469, 31, 44, 37, 2, -44 },
  { 10640, 30, 44, 37, 1, -44 },
  { 10805, 32, 57, 37, -2, -44 },
  { 11033, 32, 44, 37, 4, -44 },
  { 11209, 30, 44, 37, 1, -44 },
  { 11374, 35, 33, 37, 0, -33 },
  { 11519, 31, 33, 37, 2, -33 },
  { 11647, 30, 34, 37, 3, -33 },
  { 11775, 33, 46, 37, 0, -33 },
  { 11965, 31, 46, 37, 3, -33 },
  { 12144, 28, 33, 37, 6, -33 },
  { 12260, 30, 34, 37, 3, -33 },
  { 12388, 24, 41, 37, 8, -40 },
  { 12511, 30, 33, 37, 4, -32 },
  { 12635, 33, 32, 37, 5, -32 },
  { 12767, 36, 32, 37, 3, -32 },
  { 12911, 36, 32, 37, 0, -32 },
  { 13055, 39, 45, 37, -1, -32 },
  { 13275, 33, 32, 37, 1, -32 },
  { 13407, 31, 57, 37, 6, -44 },
  { 13628, 5, 57, 37, 16, -44 },
  { 13664, 31, 57, 37, -1, -44 },
  { 13885, 32, 8, 37, 3, -24 },
};

const GFXfont LiberationMono_Italic61pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic61pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic61pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _LIBERATIONMONO_ITALIC61PT7B_H_
