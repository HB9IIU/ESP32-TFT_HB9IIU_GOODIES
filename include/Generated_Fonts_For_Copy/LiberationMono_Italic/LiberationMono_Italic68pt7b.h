#ifndef _LIBERATIONMONO_ITALIC68PT7B_H_
#define _LIBERATIONMONO_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x87, 0x8F, 0xF8, 0x03, 0xFC, 0x0F, 0x07, 0xF0, 0x0F,
  0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x3F, 0x00, 0xF0,
  0x0F, 0xC0, 0xFC, 0x01, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xC0, 0x38, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x00,
  0x3F, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xC7, 0xFE, 0x00, 0x00, 0x07, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0x01, 0xFC,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0xC0, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x3C, 0x00, 0xFC, 0x7F, 0x00, 0x78, 0x03, 0xF0, 0x7E, 0x00, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xC0, 0xFF, 0x01, 0xFF,
  0x8F, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x3E, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x87, 0xF8,
  0x00, 0x00, 0x7C, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x60,
  0x03, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xFC, 0x00, 0x3E, 0x03, 0xFB, 0xF0,
  0x01, 0xF0, 0x3F, 0x9F, 0x80, 0x1F, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3F,
  0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x7C, 0x00,
  0x7F, 0x1F, 0x07, 0xE0, 0x01, 0xF9, 0xF0, 0x3F, 0x00, 0x07, 0xEF, 0x81,
  0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x07,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0xC7, 0xF3, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0xC0, 0x78, 0x04, 0x78, 0x3C, 0x1E, 0x7F, 0x1E, 0x3F, 0x3F, 0xEF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7,
  0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x1F, 0x00, 0x70, 0x0E, 0x00, 0x10, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xCF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF3,
  0xFC, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x0F, 0xF0, 0x3F, 0x3F, 0x03,
  0xFC, 0x0F, 0xDF, 0x80, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x80, 0xFD, 0xF8,
  0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xEF,
  0xE0, 0x7F, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xE0, 0x01, 0xFF, 0xF7, 0xE0, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0xFF,
  0xC1, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0x7E, 0x7F, 0xFF, 0x00,
  0x07, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x0F, 0xC1, 0xFF, 0xF0, 0x03, 0xF1,
  0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0x83, 0xFE, 0x03,
  0xF7, 0xE0, 0x7F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xFE, 0x3F, 0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xFE, 0x3D, 0xF0,
  0x1F, 0x03, 0xFF, 0x9E, 0x7C, 0x07, 0x81, 0xF0, 0xF7, 0x9F, 0x03, 0xE0,
  0xF8, 0x1D, 0xE7, 0xC0, 0xF0, 0x7C, 0x07, 0xF1, 0xF0, 0x7C, 0x1E, 0x00,
  0xFC, 0x7C, 0x1E, 0x0F, 0x00, 0x3E, 0x1E, 0x0F, 0x87, 0xC0, 0x1F, 0x87,
  0x83, 0xC1, 0xE0, 0x07, 0xE1, 0xE0, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x7C,
  0x3C, 0x00, 0x7C, 0x1E, 0x1E, 0x1F, 0x00, 0x1E, 0x07, 0x87, 0x87, 0x80,
  0x07, 0x83, 0xC3, 0xE3, 0xE0, 0x03, 0xE0, 0xF0, 0xF0, 0xF0, 0x00, 0xF0,
  0x3C, 0x3C, 0x3C, 0x00, 0x3C, 0x0F, 0x0F, 0x1F, 0x00, 0x1E, 0x07, 0x87,
  0xC7, 0xC0, 0x07, 0x81, 0xE1, 0xE1, 0xE0, 0x03, 0xE0, 0x78, 0x78, 0x78,
  0x00, 0xF0, 0x3C, 0x1E, 0x1E, 0x00, 0x7C, 0x0F, 0x07, 0x8F, 0x80, 0x1F,
  0x03, 0x81, 0xE3, 0xE0, 0x0F, 0x81, 0xE0, 0xF8, 0xF8, 0x03, 0xE0, 0x70,
  0x3E, 0x3E, 0x01, 0xF8, 0x3C, 0x0F, 0x8F, 0x80, 0xFC, 0x1E, 0x03, 0xE1,
  0xE0, 0x77, 0x0F, 0x00, 0xF8, 0x7C, 0x79, 0xC7, 0x80, 0x3E, 0x1F, 0xFC,
  0x7F, 0xC0, 0x0F, 0x83, 0xFE, 0x1F, 0xE0, 0x01, 0xE0, 0x7E, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x03, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x02, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xC7, 0xE0,
  0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xF8,
  0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xF9, 0xFF, 0x00,
  0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xDF, 0x00, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0xFD, 0xF0, 0x07, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x1F,
  0x3F, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x0F, 0xC7, 0xC1,
  0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0xF8, 0x7C,
  0x01, 0xF0, 0xFC, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x3E, 0x1F, 0x80, 0x7E, 0x0F, 0xBE, 0x0F, 0xC0, 0x3E, 0x07, 0xDE,
  0x07, 0xC0, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0x01, 0xF0,
  0x07, 0xC0, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x01, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F,
  0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xF7,
  0xC0, 0x01, 0xF8, 0x03, 0xEF, 0xC0, 0x03, 0xF0, 0x07, 0xDF, 0x80, 0x07,
  0xE0, 0x1F, 0xBF, 0x00, 0x0F, 0x80, 0x3F, 0x3E, 0x00, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x01, 0xF1, 0xF8, 0x01,
  0xF8, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0x1F, 0x9F, 0x00,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0xFC, 0x01, 0xF0, 0x00,
  0x7D, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0xFF, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0xFF,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xEF, 0x01, 0xF8, 0x0F,
  0xC0, 0xFB, 0xE0, 0x7C, 0x03, 0xF0, 0x3C, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x3E, 0x0F, 0x80, 0x3F, 0x07, 0x8F, 0x83, 0xE0, 0x0F, 0xC3, 0xE3, 0xE1,
  0xF8, 0x03, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0xFC, 0x7C, 0x3E, 0x1F, 0x00,
  0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0x03, 0xE3,
  0xE0, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x07,
  0x9F, 0x00, 0x0F, 0x9E, 0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x79, 0xF0,
  0x00, 0xFB, 0xC0, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xBE, 0x00, 0x0F,
  0xF8, 0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x83, 0xFC, 0x01, 0xF7, 0xE0, 0x7F, 0x81,
  0xF9, 0xF8, 0x1F, 0xFF, 0xFC, 0x7F, 0x17, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF,
  0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x7F,
  0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0xFC, 0x01, 0xFB,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xDE, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7E, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x01, 0xFC,
  0x03, 0xEF, 0x80, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF,
  0xF8, 0x03, 0xF1, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xFE,
  0x3F, 0x00, 0x1F, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x0F, 0xBF, 0x00, 0x3F, 0xFF, 0xFD, 0xF8,
  0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xF8, 0x7E, 0x00, 0x0F, 0xFF,
  0x83, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x18, 0x0F, 0xE0, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x40,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x3F, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0xFE, 0x7E, 0x03, 0xFE, 0x07, 0xEF, 0x80, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xBF, 0x01,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xFF, 0x3F,
  0x00, 0x3F, 0xFF, 0x87, 0xE0, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC3,
  0xFF, 0xE0, 0x0F, 0xC3, 0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xFE, 0x03, 0xF7,
  0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF,
  0x80, 0x03, 0xF0, 0x7F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE3, 0xFC, 0x0F, 0xF8,
  0x07, 0xCF, 0xFC, 0x3F, 0xF0, 0x1F, 0x3F, 0xF8, 0xFF, 0xF0, 0x3E, 0xFF,
  0xF3, 0xFF, 0xE0, 0x7F, 0xC7, 0xEF, 0x1F, 0xC0, 0xFF, 0x07, 0xDC, 0x1F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xFC,
  0x01, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0x3F, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x3F, 0xFE, 0x00,
  0xFC, 0x3F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xF8,
  0x1F, 0x7E, 0x07, 0xFC, 0x1F, 0xBC, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0x07, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0xFC, 0x00, 0x1F,
  0x8F, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFD, 0xFF,
  0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xE0, 0x01,
  0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xF8, 0xFC, 0x03, 0xFF,
  0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0x80, 0x1F, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0x80, 0xFB, 0xF0, 0x1F, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xFE,
  0x3F, 0x00, 0x7F, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0x87, 0xE0, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x03, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0x03, 0xE0,
  0xFF, 0xFF, 0x03, 0xE1, 0xFF, 0xFE, 0x03, 0xE3, 0xF8, 0x02, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x38, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x80,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xDF, 0x01, 0xFE, 0x03,
  0xF7, 0xC0, 0x7F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xFE, 0x3F, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x3F, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0x3E, 0x07, 0x8F,
  0x07, 0xE0, 0x1F, 0x07, 0xC7, 0x83, 0xF0, 0x0F, 0x83, 0xE3, 0xC1, 0xF0,
  0x07, 0xC3, 0xE1, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0xF0, 0xFC, 0x01, 0xF1,
  0xF0, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x1F,
  0x3F, 0x00, 0x3E, 0x78, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x07, 0xDF, 0x80,
  0x1F, 0xBC, 0x01, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0xF7, 0xC0, 0x07, 0xFE,
  0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0D, 0xFF, 0xFF, 0xF0, 0x0F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x0F, 0xFF,
  0xFF, 0xA0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
};

const GFXglyph LiberationMono_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 45, 41, 14, -45 },
  { 86, 25, 21, 41, 13, -49 },
  { 152, 40, 45, 41, 1, -45 },
  { 377, 39, 54, 41, 1, -49 },
  { 641, 45, 47, 41, -1, -46 },
  { 906, 37, 47, 41, 0, -46 },
  { 1124, 10, 21, 41, 20, -49 },
  { 1151, 26, 63, 41, 10, -49 },
  { 1356, 25, 63, 41, 5, -49 },
  { 1553, 25, 24, 41, 12, -49 },
  { 1628, 33, 33, 41, 4, -39 },
  { 1765, 18, 22, 41, 3, -10 },
  { 1815, 19, 5, 41, 11, -21 },
  { 1827, 10, 10, 41, 13, -10 },
  { 1840, 43, 50, 41, 0, -49 },
  { 2109, 34, 47, 41, 4, -46 },
  { 2309, 33, 45, 41, 2, -45 },
  { 2495, 38, 46, 41, 1, -46 },
  { 2714, 36, 47, 41, 3, -46 },
  { 2926, 35, 45, 41, 2, -45 },
  { 3123, 36, 46, 41, 3, -45 },
  { 3330, 34, 47, 41, 5, -46 },
  { 3530, 31, 45, 41, 10, -45 },
  { 3705, 35, 47, 41, 3, -46 },
  { 3911, 34, 47, 41, 4, -46 },
  { 4111, 15, 36, 41, 13, -36 },
  { 4179, 22, 48, 41, 6, -36 },
  { 4311, 33, 35, 41, 4, -40 },
  { 4456, 33, 22, 41, 4, -33 },
  { 4547, 33, 35, 41, 4, -40 },
  { 4692, 33, 46, 41, 6, -46 },
  { 4882, 42, 57, 41, 0, -49 },
  { 5182, 40, 45, 41, -3, -45 },
  { 5407, 37, 45, 41, 2, -45 },
  { 5616, 36, 47, 41, 4, -46 },
  { 5828, 37, 45, 41, 2, -45 },
  { 6037, 39, 45, 41, 2, -45 },
  { 6257, 38, 45, 41, 3, -45 },
  { 6471, 36, 47, 41, 4, -46 },
  { 6683, 39, 45, 41, 2, -45 },
  { 6903, 36, 45, 41, 3, -45 },
  { 7106, 33, 46, 41, 5, -45 },
  { 7296, 41, 45, 41, 2, -45 },
  { 7527, 30, 45, 41, 4, -45 },
  { 7696, 41, 45, 41, 1, -45 },
  { 7927, 39, 45, 41, 2, -45 },
  { 8147, 36, 47, 41, 3, -46 },
  { 8359, 38, 45, 41, 2, -45 },
  { 8573, 36, 60, 41, 3, -46 },
  { 8843, 38, 45, 41, 2, -45 },
  { 9057, 39, 47, 41, 1, -46 },
  { 9287, 36, 45, 41, 7, -45 },
  { 9490, 37, 46, 41, 4, -45 },
  { 9703, 40, 45, 41, 6, -45 },
  { 9928, 42, 45, 41, 4, -45 },
  { 10165, 45, 45, 41, -2, -45 },
  { 10419, 39, 45, 41, 6, -45 },
  { 10639, 43, 45, 41, -1, -45 },
  { 10881, 31, 63, 41, 7, -49 },
  { 11126, 23, 50, 41, 10, -49 },
  { 11270, 30, 63, 41, 3, -49 },
  { 11507, 32, 30, 41, 4, -45 },
  { 11627, 42, 3, 41, -5, 4 },
  { 11643, 13, 9, 41, 19, -49 },
  { 11658, 34, 38, 41, 2, -37 },
  { 11820, 35, 50, 41, 2, -49 },
  { 12039, 33, 38, 41, 4, -37 },
  { 12196, 37, 50, 41, 4, -49 },
  { 12428, 33, 38, 41, 4, -37 },
  { 12585, 35, 49, 41, 7, -49 },
  { 12800, 35, 51, 41, 3, -37 },
  { 13024, 33, 49, 41, 3, -49 },
  { 13227, 34, 49, 41, 1, -49 },
  { 13436, 36, 63, 41, -2, -49 },
  { 13720, 36, 49, 41, 4, -49 },
  { 13941, 34, 49, 41, 1, -49 },
  { 14150, 39, 37, 41, 0, -37 },
  { 14331, 33, 37, 41, 3, -37 },
  { 14484, 33, 38, 41, 4, -37 },
  { 14641, 37, 51, 41, 0, -37 },
  { 14877, 34, 51, 41, 4, -37 },
  { 15094, 32, 37, 41, 6, -37 },
  { 15242, 32, 38, 41, 4, -37 },
  { 15394, 27, 46, 41, 9, -45 },
  { 15550, 34, 37, 41, 4, -36 },
  { 15708, 36, 36, 41, 6, -36 },
  { 15870, 41, 36, 41, 3, -36 },
  { 16055, 40, 36, 41, 0, -36 },
  { 16235, 43, 50, 41, -1, -36 },
  { 16504, 37, 36, 41, 1, -36 },
  { 16671, 34, 63, 41, 7, -49 },
  { 16939, 5, 63, 41, 18, -49 },
  { 16979, 35, 63, 41, -1, -49 },
  { 17255, 35, 8, 41, 4, -26 },
};

const GFXfont LiberationMono_Italic68pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic68pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic68pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _LIBERATIONMONO_ITALIC68PT7B_H_
