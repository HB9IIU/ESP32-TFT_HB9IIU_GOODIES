#ifndef _LIBERATIONMONO_ITALIC11PT7B_H_
#define _LIBERATIONMONO_ITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x20, 0xD9, 0xA0, 0x14, 0x49, 0xF9, 0x4F, 0xCA, 0x24,
  0x00, 0x08, 0x79, 0x52, 0x83, 0x82, 0xA5, 0x3C, 0x20, 0x73, 0x29, 0xA0,
  0x82, 0xCA, 0xA7, 0x00, 0x18, 0x93, 0x98, 0x96, 0x6F, 0xC0, 0x68, 0x24,
  0x48, 0x88, 0x88, 0x88, 0x21, 0x11, 0x11, 0x22, 0x48, 0x2B, 0x64, 0xA0,
  0x21, 0x3E, 0x42, 0x00, 0x2D, 0x20, 0xE0, 0xE0, 0x02, 0x08, 0x20, 0x81,
  0x04, 0x10, 0x40, 0x7A, 0x63, 0x58, 0xCB, 0x80, 0x19, 0xA0, 0x84, 0x10,
  0x4F, 0xC0, 0x3C, 0x90, 0x42, 0x31, 0x0F, 0x80, 0x3D, 0x90, 0x46, 0x05,
  0x37, 0x80, 0x0C, 0x52, 0x92, 0xFC, 0x20, 0x80, 0x3D, 0x87, 0x81, 0x07,
  0x27, 0x00, 0x3A, 0x3D, 0x18, 0xCB, 0xC0, 0xF8, 0x88, 0x84, 0x42, 0x00,
  0x3D, 0x94, 0x4E, 0x47, 0x37, 0x80, 0x7E, 0x63, 0x17, 0x8B, 0x80, 0x50,
  0xE0, 0x24, 0x06, 0x94, 0x1F, 0x21, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x82,
  0xE8, 0x00, 0x7C, 0x42, 0x64, 0x01, 0x00, 0x1C, 0x45, 0x7B, 0x5A, 0xB9,
  0xB5, 0x74, 0x80, 0xF0, 0x0C, 0x18, 0x51, 0x23, 0xE8, 0x50, 0x80, 0x3D,
  0x14, 0x5E, 0x45, 0x1F, 0x80, 0x7B, 0x28, 0x20, 0x82, 0x2F, 0x00, 0x39,
  0x14, 0x51, 0x45, 0x2F, 0x00, 0x3E, 0x81, 0x03, 0xE4, 0x08, 0x3F, 0x00,
  0x3E, 0x41, 0x03, 0xE4, 0x08, 0x10, 0x00, 0x7E, 0x61, 0x78, 0xC7, 0xC0,
  0x24, 0x89, 0x13, 0xE4, 0x49, 0x22, 0x00, 0x79, 0x08, 0x42, 0x33, 0xC0,
  0x38, 0x42, 0x21, 0x4B, 0x80, 0x24, 0x91, 0x43, 0x85, 0x89, 0x21, 0x00,
  0x42, 0x11, 0x08, 0x43, 0xC0, 0x66, 0xD5, 0xB2, 0xA4, 0x50, 0xA2, 0x00,
  0x24, 0xC9, 0x52, 0xA5, 0x4A, 0xA2, 0x00, 0x7E, 0x63, 0x18, 0xCB, 0x80,
  0x3D, 0x14, 0x5E, 0x41, 0x08, 0x00, 0x7E, 0x63, 0x18, 0xCB, 0x8C, 0x30,
  0x3C, 0x8D, 0x13, 0xC5, 0x89, 0x23, 0x00, 0x3D, 0x14, 0x0E, 0x06, 0x17,
  0x80, 0xFC, 0x82, 0x08, 0x20, 0x84, 0x00, 0x46, 0x28, 0xA2, 0x8A, 0x4F,
  0x00, 0x86, 0x38, 0x94, 0x51, 0x86, 0x00, 0x86, 0x1A, 0x7A, 0xEA, 0x49,
  0x00, 0x66, 0x48, 0xE0, 0x82, 0x89, 0x21, 0x00, 0x85, 0x25, 0x08, 0x20,
  0x84, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x00, 0x39, 0x08, 0x84,
  0x21, 0x08, 0x87, 0x00, 0x92, 0x24, 0x49, 0x38, 0x42, 0x11, 0x08, 0x42,
  0x13, 0x00, 0x31, 0x95, 0x18, 0x80, 0xFE, 0x90, 0x38, 0x17, 0x92, 0x99,
  0xB0, 0x20, 0x85, 0xD9, 0x45, 0x14, 0xAE, 0x74, 0x61, 0x09, 0x70, 0x08,
  0x27, 0xA2, 0x8A, 0x69, 0x3C, 0x74, 0x7F, 0x09, 0x70, 0x3C, 0x8F, 0x90,
  0x41, 0x04, 0x10, 0x3D, 0x14, 0x51, 0x49, 0xE0, 0x9C, 0x20, 0x85, 0xD9,
  0x45, 0x14, 0x92, 0x08, 0x03, 0x04, 0x10, 0x41, 0x3F, 0x08, 0x0E, 0x10,
  0x88, 0x42, 0x17, 0x00, 0x42, 0x12, 0xAA, 0x72, 0xD2, 0x38, 0x21, 0x04,
  0x10, 0x41, 0x3F, 0x7D, 0x55, 0x65, 0x96, 0x90, 0x5D, 0x94, 0x51, 0x49,
  0x20, 0x74, 0x63, 0x19, 0x70, 0x5D, 0x94, 0x51, 0x4A, 0xE8, 0x20, 0x7C,
  0x63, 0x29, 0x78, 0x42, 0x5B, 0x11, 0x08, 0x40, 0x74, 0x78, 0x29, 0x78,
  0x21, 0x1E, 0x84, 0x21, 0x0E, 0x8C, 0x63, 0x19, 0x78, 0x8E, 0x2D, 0x14,
  0x61, 0x80, 0x86, 0x1A, 0xBA, 0xAA, 0x40, 0x44, 0x50, 0x41, 0x84, 0x91,
  0x00, 0x46, 0x88, 0xA1, 0x43, 0x06, 0x08, 0x60, 0x7C, 0x21, 0x08, 0x43,
  0xE0, 0x1C, 0x82, 0x08, 0xC1, 0x04, 0x10, 0x41, 0xC0, 0xFF, 0xC0, 0x30,
  0x44, 0x20, 0x88, 0x44, 0x27, 0x00, 0xE1, 0xC0,
};

const GFXglyph LiberationMono_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 7, 7, 2, -7 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 7, 7, 0, -7 },
  { 13, 7, 9, 7, 0, -8 },
  { 21, 7, 7, 7, 0, -7 },
  { 28, 6, 7, 7, 0, -7 },
  { 34, 2, 3, 7, 3, -8 },
  { 35, 4, 10, 7, 2, -8 },
  { 40, 4, 10, 7, 1, -8 },
  { 45, 4, 5, 7, 2, -8 },
  { 48, 5, 5, 7, 1, -6 },
  { 52, 3, 4, 7, 0, -2 },
  { 54, 3, 1, 7, 2, -3 },
  { 55, 2, 2, 7, 2, -2 },
  { 56, 7, 8, 7, 0, -8 },
  { 63, 5, 7, 7, 1, -7 },
  { 68, 6, 7, 7, 0, -7 },
  { 74, 6, 7, 7, 0, -7 },
  { 80, 6, 7, 7, 0, -7 },
  { 86, 6, 7, 7, 0, -7 },
  { 92, 6, 7, 7, 0, -7 },
  { 98, 5, 7, 7, 1, -7 },
  { 103, 5, 7, 7, 2, -7 },
  { 108, 6, 7, 7, 0, -7 },
  { 114, 5, 7, 7, 1, -7 },
  { 119, 2, 6, 7, 2, -6 },
  { 121, 3, 8, 7, 1, -6 },
  { 124, 5, 5, 7, 1, -6 },
  { 128, 5, 3, 7, 1, -5 },
  { 130, 5, 5, 7, 1, -6 },
  { 134, 5, 7, 7, 1, -7 },
  { 139, 7, 10, 7, 0, -8 },
  { 148, 7, 7, 7, -1, -7 },
  { 155, 6, 7, 7, 0, -7 },
  { 161, 6, 7, 7, 1, -7 },
  { 167, 6, 7, 7, 0, -7 },
  { 173, 7, 7, 7, 0, -7 },
  { 180, 7, 7, 7, 0, -7 },
  { 187, 5, 7, 7, 1, -7 },
  { 192, 7, 7, 7, 0, -7 },
  { 199, 5, 7, 7, 1, -7 },
  { 204, 5, 7, 7, 1, -7 },
  { 209, 7, 7, 7, 0, -7 },
  { 216, 5, 7, 7, 1, -7 },
  { 221, 7, 7, 7, 0, -7 },
  { 228, 7, 7, 7, 0, -7 },
  { 235, 5, 7, 7, 1, -7 },
  { 240, 6, 7, 7, 0, -7 },
  { 246, 5, 9, 7, 1, -7 },
  { 252, 7, 7, 7, 0, -7 },
  { 259, 6, 7, 7, 0, -7 },
  { 265, 6, 7, 7, 1, -7 },
  { 271, 6, 7, 7, 1, -7 },
  { 277, 6, 7, 7, 1, -7 },
  { 283, 6, 7, 7, 1, -7 },
  { 289, 7, 7, 7, 0, -7 },
  { 296, 6, 7, 7, 1, -7 },
  { 302, 7, 7, 7, 0, -7 },
  { 309, 5, 10, 7, 1, -8 },
  { 316, 3, 8, 7, 2, -8 },
  { 319, 5, 10, 7, 0, -8 },
  { 326, 5, 5, 7, 1, -7 },
  { 330, 7, 1, 7, -1, 1 },
  { 331, 2, 2, 7, 3, -9 },
  { 332, 6, 6, 7, 0, -6 },
  { 337, 6, 8, 7, 0, -8 },
  { 343, 5, 6, 7, 1, -6 },
  { 347, 6, 8, 7, 1, -8 },
  { 353, 5, 6, 7, 1, -6 },
  { 357, 6, 8, 7, 1, -8 },
  { 363, 6, 8, 7, 0, -6 },
  { 369, 6, 8, 7, 0, -8 },
  { 375, 6, 8, 7, 0, -8 },
  { 381, 5, 10, 7, 0, -8 },
  { 388, 5, 8, 7, 1, -8 },
  { 393, 6, 8, 7, 0, -8 },
  { 399, 6, 6, 7, 0, -6 },
  { 404, 6, 6, 7, 0, -6 },
  { 409, 5, 6, 7, 1, -6 },
  { 413, 6, 8, 7, 0, -6 },
  { 419, 5, 8, 7, 1, -6 },
  { 424, 5, 6, 7, 1, -6 },
  { 428, 5, 6, 7, 1, -6 },
  { 432, 5, 8, 7, 1, -8 },
  { 437, 5, 6, 7, 1, -6 },
  { 441, 6, 6, 7, 1, -6 },
  { 446, 6, 6, 7, 1, -6 },
  { 451, 7, 6, 7, 0, -6 },
  { 457, 7, 8, 7, 0, -6 },
  { 464, 6, 6, 7, 0, -6 },
  { 469, 6, 10, 7, 1, -8 },
  { 477, 1, 10, 7, 3, -8 },
  { 479, 5, 10, 7, 0, -8 },
  { 486, 5, 2, 7, 1, -5 },
};

const GFXfont LiberationMono_Italic11pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic11pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic11pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _LIBERATIONMONO_ITALIC11PT7B_H_
