#ifndef _LIBERATIONMONO_ITALIC47PT7B_H_
#define _LIBERATIONMONO_ITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x01, 0xE3, 0x80, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x06,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0E, 0x03, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x70, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x1C,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18,
  0x03, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x73,
  0xF0, 0x3E, 0x0E, 0x1E, 0x07, 0x83, 0x83, 0xE1, 0xE0, 0x70, 0x3C, 0x3C,
  0x0E, 0x06, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0x3F, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xE3, 0xF0,
  0x00, 0x1C, 0x1F, 0x00, 0x03, 0x83, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1C,
  0x07, 0x8E, 0x03, 0x80, 0xF3, 0xC0, 0x70, 0x3E, 0x78, 0x0E, 0x07, 0x8F,
  0x81, 0x81, 0xF1, 0xF8, 0x70, 0x7C, 0x1F, 0x8E, 0x3F, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1E, 0x07, 0xFC, 0x00, 0x78, 0x1F, 0xFC, 0x00, 0xE0, 0x3C, 0x78,
  0x03, 0x80, 0xF0, 0x78, 0x0E, 0x01, 0xC0, 0xF0, 0x38, 0x07, 0x81, 0xE0,
  0xE0, 0x0F, 0x03, 0x83, 0xC0, 0x1C, 0x07, 0x0F, 0x00, 0x38, 0x0E, 0x3C,
  0x00, 0x70, 0x3C, 0xF0, 0x00, 0xE0, 0x71, 0xC0, 0x01, 0xE1, 0xE7, 0x00,
  0x03, 0xFF, 0x9C, 0x00, 0x03, 0xFE, 0x70, 0x00, 0x01, 0xF1, 0xC7, 0xE0,
  0x00, 0x07, 0xBF, 0xE0, 0x00, 0x1E, 0xFF, 0xE0, 0x00, 0x79, 0xE3, 0xC0,
  0x01, 0xE7, 0x83, 0xC0, 0x03, 0x8E, 0x07, 0x80, 0x0E, 0x3C, 0x0E, 0x00,
  0x38, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x70, 0x0F,
  0x03, 0x81, 0xE0, 0x3C, 0x07, 0x03, 0x80, 0xF0, 0x0F, 0x0F, 0x01, 0xC0,
  0x1F, 0xFC, 0x07, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xC3, 0xE0,
  0x07, 0x80, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x7E, 0x00, 0x1E, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0C, 0x0F, 0xF0,
  0x07, 0x1F, 0x3C, 0x07, 0x8F, 0x1E, 0x03, 0x8F, 0x07, 0x83, 0xCF, 0x03,
  0xC1, 0xC7, 0x80, 0xF1, 0xE7, 0x80, 0x78, 0xE3, 0xC0, 0x1E, 0xE1, 0xE0,
  0x0F, 0xF0, 0xF0, 0x03, 0xF0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0xFE, 0x0F,
  0x81, 0xFF, 0xD7, 0xFF, 0xF7, 0xF9, 0xFF, 0xE1, 0xFC, 0x3F, 0xC0, 0x3C,
  0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x02, 0x0E, 0x0B, 0xC7, 0x1D, 0xFB, 0x7E, 0x7F,
  0xFE, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xCE, 0x01, 0xC7, 0x81,
  0xE1, 0xC0, 0xE0, 0xE0, 0x20, 0x40, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0x7E, 0xF9, 0xF3,
  0xEF, 0xDF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0xF8, 0x7C, 0x1E,
  0xF0, 0x7C, 0x3E, 0xF0, 0x7C, 0x3C, 0xF0, 0x7C, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7E, 0x0F, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xBC, 0x01, 0xFC, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3C,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x01, 0xF0,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x7E, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x3E, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x7C,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE3, 0xF8, 0x01, 0xEF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x1E, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x3C, 0xFF, 0xE0, 0x3D, 0xFF,
  0xF0, 0x7B, 0xC1, 0xF8, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7E, 0x07, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0,
  0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0x07, 0xE0, 0x78, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9F, 0x00,
  0x3F, 0x3E, 0x00, 0xFC, 0x3F, 0x07, 0xF8, 0x7F, 0xFC, 0xF0, 0x7F, 0xF3,
  0xC0, 0x3F, 0x87, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0xE0, 0xFC, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7E, 0x07, 0xE1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x3C, 0x0F, 0x1D, 0xC1,
  0xC1, 0xFC, 0xCE, 0x1E, 0x1C, 0x7E, 0x70, 0xE1, 0xC1, 0xF3, 0x8E, 0x1C,
  0x0F, 0x1C, 0x71, 0xC0, 0x78, 0xE3, 0x8E, 0x03, 0x86, 0x38, 0xE0, 0x1C,
  0x71, 0xC7, 0x01, 0xE3, 0x8E, 0x70, 0x0E, 0x1C, 0xE3, 0x80, 0x70, 0xE7,
  0x1C, 0x07, 0x06, 0x39, 0xC0, 0x38, 0x71, 0xCE, 0x01, 0xC3, 0x8E, 0x70,
  0x1C, 0x18, 0xE3, 0x80, 0xE1, 0xC7, 0x1C, 0x0F, 0x0C, 0x38, 0xE0, 0xF0,
  0xE1, 0xC7, 0x0D, 0x8E, 0x0E, 0x38, 0xEC, 0xE0, 0x70, 0xFE, 0x7E, 0x03,
  0x83, 0xC3, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x1F, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0xC7, 0x80, 0x0F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00,
  0xF8, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x04, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x83, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0x01,
  0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0x80, 0x7F, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00,
  0xF8, 0x7E, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0C, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x3F, 0xF9, 0xF0, 0x1F, 0xFC, 0xF8, 0x0F, 0xFE, 0x78,
  0x0F, 0xFE, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78,
  0x7E, 0x00, 0x3C, 0x1F, 0x80, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF0,
  0x3E, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x7C,
  0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0xF0, 0x3F, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x07, 0xBF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFE, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x3F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0xF7, 0x00, 0xFE, 0x0F,
  0x70, 0x1D, 0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x78, 0x3B, 0xC0, 0xE7, 0x87,
  0xBC, 0x0E, 0x78, 0x73, 0xC1, 0xE7, 0x8F, 0x3C, 0x1E, 0x38, 0xE3, 0x81,
  0xE3, 0x9E, 0x78, 0x1C, 0x39, 0xC7, 0x81, 0xC3, 0xF8, 0x78, 0x3C, 0x3F,
  0x87, 0x83, 0xC3, 0xF0, 0x70, 0x3C, 0x1F, 0x07, 0x03, 0x81, 0xE0, 0xF0,
  0x38, 0x1E, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x0F, 0xC0,
  0x07, 0x81, 0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x3C, 0x0F, 0xF0, 0x07, 0x81,
  0xFE, 0x00, 0xF0, 0x3D, 0xC0, 0x1E, 0x07, 0x3C, 0x07, 0x81, 0xE7, 0x80,
  0xF0, 0x3C, 0xF0, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E,
  0x3C, 0x1E, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x0F, 0x0F,
  0x03, 0xC1, 0xE1, 0xE0, 0x78, 0x3C, 0x38, 0x0E, 0x03, 0xCF, 0x03, 0xC0,
  0x79, 0xE0, 0x78, 0x0F, 0x3C, 0x0F, 0x00, 0xE7, 0x81, 0xE0, 0x1E, 0xF0,
  0x38, 0x03, 0xDC, 0x0F, 0x00, 0x7F, 0x81, 0xE0, 0x07, 0xF0, 0x3C, 0x00,
  0xFE, 0x07, 0x80, 0x1F, 0xC0, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0xC1, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x3F,
  0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xFE,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1E, 0x3F, 0x00, 0x0F, 0x87, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x1E, 0x07, 0xC0,
  0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0x83, 0xF0, 0x78,
  0x1E, 0x1D, 0xC1, 0xC0, 0x78, 0x77, 0x0F, 0x01, 0xE3, 0xDC, 0x3C, 0x07,
  0x8E, 0x78, 0xE0, 0x1E, 0x79, 0xE7, 0x80, 0x79, 0xC7, 0x9E, 0x01, 0xEF,
  0x1E, 0x70, 0x07, 0x38, 0x3B, 0xC0, 0x1C, 0xE0, 0xEF, 0x00, 0x77, 0x03,
  0xB8, 0x01, 0xDC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x39,
  0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x3C,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xE0,
  0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xF0, 0x0F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x8F, 0x00, 0xFF,
  0x1F, 0x07, 0xBE, 0x3F, 0xFE, 0x7F, 0xBF, 0xF8, 0x7E, 0x1F, 0x80, 0x7C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x87, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F, 0x3F, 0xFC,
  0x0F, 0x70, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0xF7, 0xFF, 0xC0,
  0xF3, 0xFF, 0x80, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xF3, 0xC0, 0x03,
  0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0x0F, 0x00, 0xFF, 0xE7, 0x80, 0xFF, 0xFB, 0xC0, 0xFC, 0x1D, 0xE0, 0xF8,
  0x07, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3F,
  0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x77, 0x80, 0xFF, 0xFB, 0xC0, 0x3F, 0xF1,
  0xE0, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x7E, 0x07, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x07,
  0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0x80, 0xFF, 0xE7, 0x80, 0xFF, 0xFB, 0xC0, 0xFC, 0x1D, 0xE0,
  0xF8, 0x06, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x3F, 0x07, 0xC0, 0x3F, 0x83, 0xF0, 0x77, 0x80, 0xFF, 0xF3, 0xC0, 0x3F,
  0xF1, 0xE0, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0xE0, 0x3E, 0x7F, 0xF0, 0x79, 0xFF, 0xE0,
  0xF7, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x7C, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F,
  0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x9F, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x1E, 0x07, 0x81, 0xE7, 0xE3,
  0xF8, 0x3D, 0xFE, 0xFF, 0x87, 0xE3, 0xD8, 0xF0, 0xF8, 0x7E, 0x1E, 0x1E,
  0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x78, 0xF8, 0x3C, 0x0F, 0x1E, 0x07, 0x81,
  0xE3, 0xC0, 0xF0, 0x38, 0x78, 0x1C, 0x0F, 0x0F, 0x07, 0x81, 0xE3, 0xC0,
  0xF0, 0x3C, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xE1, 0xE0, 0x78, 0x3C,
  0x3C, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F,
  0x03, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7,
  0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xF0, 0x1E, 0x3F,
  0xF8, 0x3C, 0xFF, 0xF0, 0x7B, 0x83, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x7E, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x07,
  0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x1F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0,
  0x03, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0xF1,
  0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x0F, 0x70, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x1F,
  0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x80, 0x7C, 0x07, 0xF0, 0x3E, 0x03, 0xDF, 0xFF, 0x00, 0xF3, 0xFF,
  0x80, 0x3C, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x1E, 0x03, 0xFF, 0x9E, 0x07, 0xFF, 0xDE, 0x0F, 0xC1,
  0xDE, 0x1F, 0x00, 0xFE, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03,
  0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x1D, 0xE0, 0x7F, 0xF9, 0xE0, 0x3F, 0xF1,
  0xE0, 0x1F, 0xC3, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x03,
  0xFC, 0x3C, 0x3F, 0xF0, 0xF1, 0xFF, 0xC3, 0xCF, 0xFF, 0x0F, 0x7C, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x1F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC6, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xF0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0x87, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0xC7, 0x80, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0x78,
  0x3F, 0xF8, 0xF0, 0x1F, 0xC1, 0xE0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0xCF, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x81, 0xE0, 0x78, 0x78, 0x3F, 0x07, 0x87, 0x83, 0xF0, 0x78,
  0x78, 0x77, 0x0F, 0x07, 0x87, 0x70, 0xF0, 0x70, 0xE7, 0x0F, 0x07, 0x0E,
  0x71, 0xE0, 0x71, 0xC7, 0x1E, 0x0F, 0x1C, 0x71, 0xC0, 0xF3, 0x87, 0x3C,
  0x0F, 0x38, 0x7B, 0xC0, 0xF7, 0x03, 0xB8, 0x0F, 0x70, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x3C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFE,
  0x0E, 0xE0, 0x7F, 0xFE, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xF0,
};

const GFXglyph LiberationMono_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 31, 28, 9, -31 },
  { 44, 17, 15, 28, 9, -34 },
  { 76, 27, 31, 28, 1, -31 },
  { 181, 27, 38, 28, 1, -34 },
  { 310, 31, 31, 28, -1, -31 },
  { 431, 25, 31, 28, 0, -31 },
  { 528, 7, 15, 28, 14, -34 },
  { 542, 18, 44, 28, 7, -34 },
  { 641, 18, 44, 28, 3, -34 },
  { 740, 17, 16, 28, 8, -34 },
  { 774, 23, 23, 28, 3, -27 },
  { 841, 13, 15, 28, 2, -7 },
  { 866, 14, 4, 28, 7, -14 },
  { 873, 7, 7, 28, 9, -7 },
  { 880, 30, 34, 28, 0, -34 },
  { 1008, 24, 31, 28, 3, -31 },
  { 1101, 23, 31, 28, 1, -31 },
  { 1191, 26, 31, 28, 1, -31 },
  { 1292, 25, 31, 28, 2, -31 },
  { 1389, 24, 31, 28, 1, -31 },
  { 1482, 25, 31, 28, 2, -31 },
  { 1579, 24, 31, 28, 3, -31 },
  { 1672, 21, 31, 28, 7, -31 },
  { 1754, 25, 31, 28, 2, -31 },
  { 1851, 23, 31, 28, 3, -31 },
  { 1941, 10, 25, 28, 9, -25 },
  { 1973, 15, 33, 28, 4, -25 },
  { 2035, 23, 23, 28, 3, -27 },
  { 2102, 23, 15, 28, 3, -23 },
  { 2146, 23, 23, 28, 3, -27 },
  { 2213, 23, 31, 28, 4, -31 },
  { 2303, 29, 40, 28, 0, -34 },
  { 2448, 28, 31, 28, -2, -31 },
  { 2557, 26, 31, 28, 1, -31 },
  { 2658, 25, 31, 28, 3, -31 },
  { 2755, 26, 31, 28, 1, -31 },
  { 2856, 27, 31, 28, 1, -31 },
  { 2961, 27, 31, 28, 2, -31 },
  { 3066, 25, 31, 28, 3, -31 },
  { 3163, 27, 31, 28, 1, -31 },
  { 3268, 25, 31, 28, 2, -31 },
  { 3365, 23, 31, 28, 3, -31 },
  { 3455, 29, 31, 28, 1, -31 },
  { 3568, 21, 31, 28, 3, -31 },
  { 3650, 28, 31, 28, 1, -31 },
  { 3759, 27, 31, 28, 1, -31 },
  { 3864, 25, 31, 28, 2, -31 },
  { 3961, 27, 31, 28, 1, -31 },
  { 4066, 25, 41, 28, 2, -31 },
  { 4195, 27, 31, 28, 1, -31 },
  { 4300, 26, 31, 28, 1, -31 },
  { 4401, 25, 31, 28, 5, -31 },
  { 4498, 26, 31, 28, 3, -31 },
  { 4599, 28, 31, 28, 4, -31 },
  { 4708, 30, 31, 28, 2, -31 },
  { 4825, 32, 31, 28, -2, -31 },
  { 4949, 27, 31, 28, 4, -31 },
  { 5054, 30, 31, 28, -1, -31 },
  { 5171, 21, 44, 28, 5, -34 },
  { 5287, 16, 34, 28, 7, -34 },
  { 5355, 21, 44, 28, 2, -34 },
  { 5471, 22, 21, 28, 3, -31 },
  { 5529, 29, 2, 28, -4, 3 },
  { 5537, 9, 6, 28, 13, -34 },
  { 5544, 23, 25, 28, 2, -25 },
  { 5616, 24, 34, 28, 2, -34 },
  { 5718, 23, 25, 28, 3, -25 },
  { 5790, 25, 34, 28, 3, -34 },
  { 5897, 23, 25, 28, 3, -25 },
  { 5969, 24, 34, 28, 5, -34 },
  { 6071, 25, 35, 28, 2, -25 },
  { 6181, 23, 34, 28, 2, -34 },
  { 6279, 23, 34, 28, 1, -34 },
  { 6377, 24, 44, 28, -1, -34 },
  { 6509, 25, 34, 28, 3, -34 },
  { 6616, 23, 34, 28, 1, -34 },
  { 6714, 27, 25, 28, 0, -25 },
  { 6799, 23, 25, 28, 2, -25 },
  { 6871, 23, 25, 28, 3, -25 },
  { 6943, 26, 35, 28, 0, -25 },
  { 7057, 24, 35, 28, 3, -25 },
  { 7162, 22, 25, 28, 4, -25 },
  { 7231, 22, 25, 28, 3, -25 },
  { 7300, 19, 31, 28, 6, -31 },
  { 7374, 23, 25, 28, 3, -25 },
  { 7446, 25, 25, 28, 4, -25 },
  { 7525, 28, 25, 28, 2, -25 },
  { 7613, 28, 25, 28, 0, -25 },
  { 7701, 29, 35, 28, 0, -25 },
  { 7828, 25, 25, 28, 1, -25 },
  { 7907, 24, 44, 28, 5, -34 },
  { 8039, 4, 44, 28, 12, -34 },
  { 8061, 23, 44, 28, 0, -34 },
  { 8188, 24, 6, 28, 3, -19 },
};

const GFXfont LiberationMono_Italic47pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic47pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic47pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _LIBERATIONMONO_ITALIC47PT7B_H_
