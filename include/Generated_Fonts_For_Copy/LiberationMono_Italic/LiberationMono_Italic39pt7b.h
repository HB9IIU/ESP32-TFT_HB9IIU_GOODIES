#ifndef _LIBERATIONMONO_ITALIC39PT7B_H_
#define _LIBERATIONMONO_ITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x78, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0x70, 0x71,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x0E,
  0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0xC0, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xF8, 0xC7, 0xC3, 0xC3, 0x0F, 0x1E, 0x0C, 0x3C, 0x78, 0x70,
  0x61, 0xC1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x18, 0x00, 0x3E, 0x60, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xDF, 0xC0, 0x03,
  0x0F, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x71, 0x81, 0xC1, 0xCE, 0x06, 0x07,
  0x3C, 0x18, 0x3C, 0xF0, 0xE1, 0xE3, 0xF3, 0x8F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xF0, 0x01, 0xC1, 0xFE, 0x00, 0xE0, 0xE1, 0xC0, 0x70, 0x38,
  0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x07, 0x07, 0x0E, 0x01, 0xC1, 0xC3, 0x00,
  0x60, 0x61, 0x80, 0x18, 0x38, 0xE0, 0x06, 0x0E, 0x70, 0x01, 0xC7, 0x38,
  0x00, 0x7F, 0x9C, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x01,
  0x9F, 0xE0, 0x00, 0xCE, 0x1C, 0x00, 0x73, 0x87, 0x00, 0x39, 0xC1, 0xC0,
  0x1C, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x07, 0x06, 0x06, 0x03, 0x83, 0x83,
  0x80, 0xC0, 0x60, 0xE0, 0x60, 0x1C, 0x70, 0x38, 0x07, 0xF8, 0x1C, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xE1,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x38, 0x01,
  0xC7, 0x80, 0x0E, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x60, 0xFE, 0x03,
  0x8F, 0x70, 0x38, 0xF3, 0xC1, 0xCF, 0x0E, 0x0C, 0x70, 0x78, 0xE7, 0x81,
  0xCE, 0x38, 0x0F, 0x71, 0xC0, 0x3F, 0x0E, 0x00, 0xF8, 0x78, 0x07, 0xC3,
  0xE0, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xF1, 0xF8, 0xFE, 0x03, 0x80, 0x3C,
  0xF3, 0xCE, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x18, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x38, 0x18, 0xE3, 0x7B, 0x7F, 0xFF,
  0xF3, 0xFE, 0x01, 0xE0, 0x0D, 0x80, 0x67, 0x03, 0x9C, 0x1C, 0x38, 0x20,
  0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xF7, 0xDE,
  0x79, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0x73,
  0xC0, 0x07, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0xF8, 0xF7, 0x8F, 0x8F,
  0x70, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x87, 0x80,
  0xF0, 0x7C, 0x1E, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x1F,
  0x9E, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC1, 0xF0,
  0x78, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1F, 0x0F, 0x00, 0xF1, 0xE0,
  0x0F, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x78, 0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xDE, 0x00, 0x39, 0xE0, 0x07, 0x1C, 0x00,
  0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x78, 0x70, 0x07, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xCF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0x07, 0xC3, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x07,
  0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xF0, 0xF0,
  0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x1F,
  0x81, 0xCF, 0xFC, 0x3B, 0xFF, 0xCF, 0xE0, 0xF9, 0xF0, 0x0F, 0xBC, 0x00,
  0xF7, 0x80, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03,
  0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x1E, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00,
  0xE1, 0xE0, 0x1E, 0x0F, 0x07, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x3E, 0x07, 0xC7, 0x80, 0x3C, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCF, 0x00, 0x78, 0xF8, 0x1F, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFC, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x1C, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0xC0,
  0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0x9E, 0x07,
  0xE1, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0xF0, 0x0F, 0x0F,
  0x01, 0xF0, 0x78, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x81,
  0xF3, 0xC0, 0x1E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x78, 0x3C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x06, 0x07,
  0x00, 0x07, 0x06, 0x0F, 0x3F, 0x0E, 0x1F, 0xB7, 0x0C, 0x79, 0xB3, 0x1C,
  0x60, 0xE7, 0x18, 0xE0, 0xE7, 0x39, 0xC0, 0xE7, 0x31, 0x81, 0xC7, 0x33,
  0x81, 0xC6, 0x73, 0x81, 0x86, 0x73, 0x01, 0x8E, 0x67, 0x03, 0x8E, 0x67,
  0x03, 0x0C, 0xE7, 0x07, 0x1C, 0xE6, 0x07, 0x18, 0xE6, 0x0E, 0x18, 0xE6,
  0x1E, 0x30, 0xE7, 0x36, 0x60, 0xE7, 0xE7, 0xE0, 0xE3, 0xC3, 0x80, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xEF, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0,
  0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1E, 0x01, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0,
  0x07, 0x87, 0x80, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0xF0, 0x0F, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xC0, 0x1F, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x3C,
  0x78, 0x01, 0xE7, 0x80, 0x04, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x21, 0xE0, 0x03,
  0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1E, 0x07, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x0F, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00,
  0x71, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C,
  0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x3C, 0x03, 0xC1, 0xC0, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0x87,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x83, 0xFE, 0x38, 0x1F, 0xF3, 0xC0, 0xFF, 0x9E, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x01,
  0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xC1,
  0xE0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0E, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0F, 0x01,
  0xC1, 0xE0, 0x78, 0x3E, 0x1E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0E, 0x0F, 0x80, 0x0E, 0x1F,
  0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1D, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xDC, 0x0E, 0xE1, 0xDC, 0x0E, 0x73, 0x9C, 0x1C, 0x73, 0x9C,
  0x1C, 0x77, 0x1C, 0x1C, 0x77, 0x3C, 0x1C, 0x7E, 0x38, 0x1C, 0x7E, 0x38,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x1F, 0x00, 0x70, 0x7C, 0x01, 0xC3, 0xF0, 0x0F, 0x0F, 0xE0, 0x38, 0x3B,
  0x80, 0xE0, 0xEE, 0x03, 0x83, 0xB8, 0x0E, 0x1E, 0xF0, 0x78, 0x71, 0xC1,
  0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x78, 0x70, 0xF0, 0xE3, 0xC3,
  0xC3, 0x8F, 0x0E, 0x0E, 0x38, 0x38, 0x3C, 0xE0, 0xE0, 0x73, 0x83, 0x81,
  0xCE, 0x1E, 0x07, 0xF8, 0x70, 0x1F, 0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xFC,
  0x1C, 0x03, 0xF0, 0xF0, 0x07, 0xC3, 0x80, 0x1E, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x07, 0x8F, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xC0,
  0x3E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x1C,
  0x03, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x3E,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0x77, 0x80, 0x07, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x80, 0xF0, 0x7C, 0x1F, 0x03,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83,
  0xC0, 0x3F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x7C,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0x07, 0x00, 0x3C,
  0x1E, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81,
  0xF0, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C,
  0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0,
  0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x38,
  0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEF, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0x70, 0x78, 0x38, 0x70, 0x78, 0x38, 0x70, 0xF8, 0x78,
  0x70, 0xD8, 0x70, 0x71, 0xD8, 0x70, 0xF1, 0xD8, 0x70, 0xF3, 0x98, 0xE0,
  0xF3, 0x98, 0xE0, 0xF3, 0x18, 0xE0, 0xE7, 0x1D, 0xC0, 0xE6, 0x1D, 0xC0,
  0xEE, 0x1D, 0xC0, 0xEE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x38, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x38,
  0xF0, 0x00, 0xF3, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x0E, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x38, 0x30, 0x0E, 0x1C,
  0x01, 0x8E, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE1, 0xE0,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x38, 0x70, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x1F, 0x8F, 0x83, 0x78, 0x7F, 0xF7, 0xE7, 0xFC, 0x3E,
  0x1F, 0x83, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x71, 0xF8, 0x0F,
  0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x7E, 0x0F, 0x87, 0x7F, 0xF0, 0x73, 0xFE, 0x07, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xE0,
  0x1E, 0x78, 0x01, 0xCE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0xF7, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3F, 0x1E,
  0x07, 0xFE, 0xF0, 0x7F, 0xF7, 0x07, 0xC1, 0xF8, 0x3C, 0x07, 0xC3, 0xC0,
  0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x3F, 0x03, 0xFF, 0xB8, 0x0F,
  0xF9, 0xC0, 0x3F, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC1, 0xF1, 0xE0, 0x1E, 0x78, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x07,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x18, 0x78, 0x07, 0x8F, 0x83, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xFB, 0xC1, 0xFF,
  0xDE, 0x1F, 0x07, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xC3,
  0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0xC1, 0xE0, 0xFE, 0x0F, 0xFE, 0xF0, 0x3F, 0xE7, 0x00, 0xFC, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0xE1,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x71, 0xF8, 0x1E, 0xFF, 0xC3, 0xBF, 0xF8, 0x7F, 0x0F,
  0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x80, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0x1C,
  0x1E, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00,
  0x1D, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0xF0, 0x03, 0xC7,
  0x80, 0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0x80, 0x78, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x78, 0x78, 0x3B, 0xF3, 0xF1, 0xDF, 0xDF, 0xC7,
  0xC7, 0xC7, 0x1E, 0x1E, 0x1C, 0x78, 0x78, 0x71, 0xC1, 0xC1, 0xC7, 0x07,
  0x07, 0x3C, 0x1C, 0x1C, 0xF0, 0xF0, 0xF3, 0x83, 0x83, 0x8E, 0x0E, 0x0E,
  0x38, 0x38, 0x39, 0xE0, 0xE0, 0xE7, 0x87, 0x87, 0x9C, 0x1C, 0x1C, 0x70,
  0x70, 0x71, 0xC1, 0xC1, 0xCF, 0x07, 0x07, 0x3C, 0x3C, 0x3C, 0xE0, 0xE0,
  0xF0, 0x1E, 0x3F, 0x03, 0x8F, 0xF8, 0x77, 0xFF, 0x0F, 0xE1, 0xF1, 0xF0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1,
  0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00,
  0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0x83, 0xE1, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0x8F, 0xC0, 0x3D, 0xFF, 0x81, 0xDF,
  0xFC, 0x0E, 0xC1, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x00, 0xE1,
  0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3E,
  0x01, 0xE1, 0xF8, 0x3E, 0x0E, 0xFF, 0xE0, 0x73, 0xFE, 0x03, 0x8F, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x70, 0x7F, 0xEF, 0x0F, 0xFE, 0xE1, 0xF0, 0x7E, 0x1E, 0x03, 0xE3, 0xC0,
  0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x83, 0xF8, 0x7F, 0xF7, 0x03, 0xFE, 0x70,
  0x1F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1C,
  0x1F, 0xC7, 0x1F, 0xF1, 0xCF, 0xF8, 0x77, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x80, 0xF1, 0xE0, 0x0E, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE3, 0x00,
  0x1C, 0xF0, 0x07, 0x9F, 0x01, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x02, 0x3F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xC0, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0x9C, 0x00, 0xE3,
  0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03, 0x8E,
  0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x38,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x1F, 0x1E, 0x0F, 0xE3, 0xFF, 0xB8, 0x7F,
  0xE7, 0x03, 0xF0, 0xE0, 0xF0, 0x00, 0x7B, 0x80, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01,
  0xC3, 0xC0, 0x0F, 0x1C, 0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0x3C, 0x1E, 0x1E, 0x78, 0x7C, 0x38, 0xE1,
  0xF8, 0x71, 0xC3, 0xF1, 0xE3, 0x8E, 0xE3, 0x87, 0x1D, 0xC7, 0x0E, 0x71,
  0x9C, 0x1C, 0xE3, 0x38, 0x3B, 0x86, 0x70, 0x77, 0x0D, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x1E, 0x07,
  0x80, 0x1C, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x7B, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x83, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x00, 0x01, 0xCE, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x83, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
};

const GFXglyph LiberationMono_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 26, 23, 8, -26 },
  { 31, 15, 12, 23, 7, -28 },
  { 54, 23, 26, 23, 1, -26 },
  { 129, 22, 32, 23, 1, -29 },
  { 217, 26, 26, 23, -1, -26 },
  { 302, 21, 26, 23, 0, -26 },
  { 371, 6, 12, 23, 11, -28 },
  { 380, 14, 36, 23, 6, -28 },
  { 443, 14, 36, 23, 3, -28 },
  { 506, 14, 13, 23, 7, -28 },
  { 529, 19, 19, 23, 2, -22 },
  { 575, 10, 13, 23, 2, -6 },
  { 592, 11, 3, 23, 6, -11 },
  { 597, 6, 6, 23, 7, -6 },
  { 602, 25, 28, 23, 0, -28 },
  { 690, 20, 26, 23, 2, -26 },
  { 755, 19, 26, 23, 1, -26 },
  { 817, 21, 26, 23, 1, -26 },
  { 886, 20, 26, 23, 2, -26 },
  { 951, 20, 26, 23, 1, -26 },
  { 1016, 20, 26, 23, 2, -26 },
  { 1081, 19, 26, 23, 3, -26 },
  { 1143, 18, 26, 23, 5, -26 },
  { 1202, 20, 26, 23, 2, -26 },
  { 1267, 20, 26, 23, 2, -26 },
  { 1332, 9, 21, 23, 7, -21 },
  { 1356, 13, 28, 23, 3, -21 },
  { 1402, 19, 20, 23, 2, -23 },
  { 1450, 19, 12, 23, 2, -19 },
  { 1479, 19, 20, 23, 2, -23 },
  { 1527, 19, 26, 23, 3, -26 },
  { 1589, 24, 33, 23, 0, -28 },
  { 1688, 23, 26, 23, -2, -26 },
  { 1763, 21, 26, 23, 1, -26 },
  { 1832, 21, 26, 23, 2, -26 },
  { 1901, 21, 26, 23, 1, -26 },
  { 1970, 23, 26, 23, 1, -26 },
  { 2045, 22, 26, 23, 2, -26 },
  { 2117, 21, 26, 23, 2, -26 },
  { 2186, 22, 26, 23, 1, -26 },
  { 2258, 21, 26, 23, 2, -26 },
  { 2327, 19, 26, 23, 3, -26 },
  { 2389, 24, 26, 23, 1, -26 },
  { 2467, 17, 26, 23, 3, -26 },
  { 2523, 24, 26, 23, 0, -26 },
  { 2601, 22, 26, 23, 1, -26 },
  { 2673, 20, 26, 23, 2, -26 },
  { 2738, 22, 26, 23, 1, -26 },
  { 2810, 20, 34, 23, 2, -26 },
  { 2895, 22, 26, 23, 1, -26 },
  { 2967, 22, 26, 23, 1, -26 },
  { 3039, 21, 26, 23, 4, -26 },
  { 3108, 22, 26, 23, 2, -26 },
  { 3180, 23, 26, 23, 3, -26 },
  { 3255, 24, 26, 23, 2, -26 },
  { 3333, 26, 26, 23, -1, -26 },
  { 3418, 22, 26, 23, 4, -26 },
  { 3490, 25, 26, 23, -1, -26 },
  { 3572, 18, 36, 23, 4, -28 },
  { 3653, 13, 28, 23, 6, -28 },
  { 3699, 17, 36, 23, 2, -28 },
  { 3776, 18, 17, 23, 2, -26 },
  { 3815, 24, 2, 23, -3, 2 },
  { 3821, 7, 5, 23, 11, -28 },
  { 3826, 20, 21, 23, 1, -21 },
  { 3879, 20, 28, 23, 1, -28 },
  { 3949, 19, 21, 23, 2, -21 },
  { 3999, 21, 28, 23, 2, -28 },
  { 4073, 19, 21, 23, 2, -21 },
  { 4123, 20, 28, 23, 4, -28 },
  { 4193, 21, 29, 23, 1, -21 },
  { 4270, 19, 28, 23, 2, -28 },
  { 4337, 19, 28, 23, 1, -28 },
  { 4404, 20, 36, 23, -1, -28 },
  { 4494, 21, 28, 23, 2, -28 },
  { 4568, 19, 28, 23, 1, -28 },
  { 4635, 22, 21, 23, 0, -21 },
  { 4693, 19, 21, 23, 2, -21 },
  { 4743, 19, 21, 23, 2, -21 },
  { 4793, 21, 29, 23, 0, -21 },
  { 4870, 20, 29, 23, 2, -21 },
  { 4943, 18, 21, 23, 4, -21 },
  { 4991, 19, 21, 23, 2, -21 },
  { 5041, 15, 26, 23, 5, -26 },
  { 5090, 19, 21, 23, 3, -21 },
  { 5140, 21, 21, 23, 3, -21 },
  { 5196, 23, 21, 23, 2, -21 },
  { 5257, 23, 21, 23, 0, -21 },
  { 5318, 24, 29, 23, 0, -21 },
  { 5405, 21, 21, 23, 1, -21 },
  { 5461, 20, 36, 23, 4, -28 },
  { 5551, 3, 36, 23, 10, -28 },
  { 5565, 19, 36, 23, 0, -28 },
  { 5651, 20, 5, 23, 2, -16 },
};

const GFXfont LiberationMono_Italic39pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic39pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic39pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _LIBERATIONMONO_ITALIC39PT7B_H_
