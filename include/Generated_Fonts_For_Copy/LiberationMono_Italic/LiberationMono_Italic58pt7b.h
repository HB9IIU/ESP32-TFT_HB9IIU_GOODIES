#ifndef _LIBERATIONMONO_ITALIC58PT7B_H_
#define _LIBERATIONMONO_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7C,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x3C, 0x7F, 0x00, 0xFC,
  0x1E, 0x1F, 0xC0, 0xFC, 0x0F, 0x07, 0xE0, 0x7C, 0x07, 0x01, 0xF0, 0x7E,
  0x03, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0x70, 0x1F, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x00,
  0xFC, 0x1C, 0x00, 0x00, 0x7F, 0xDE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x00, 0x78, 0x3F,
  0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x30, 0x07, 0x80, 0x7C, 0xF8, 0x03, 0x80,
  0x3E, 0x7C, 0x01, 0xC0, 0x3E, 0x3F, 0x01, 0xE0, 0x1F, 0x1F, 0x80, 0xF0,
  0x1F, 0x07, 0xE0, 0x78, 0x3F, 0x83, 0xFE, 0x38, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x1F, 0xFE, 0x00,
  0x07, 0x80, 0xF8, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0xF8, 0x01, 0xF0,
  0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0xF0,
  0x00, 0x7C, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0x3C, 0x3C, 0x00, 0x03, 0xE1,
  0xE1, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x78, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0x1E, 0x1F, 0xF8,
  0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0x87, 0xC3, 0xE0, 0x00, 0x3C,
  0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x78,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x0F, 0x03,
  0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x07,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x7E, 0x00,
  0x07, 0x83, 0xF8, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x1F,
  0xF8, 0x00, 0xF0, 0x7E, 0xF8, 0x03, 0xE1, 0xF9, 0xF0, 0x07, 0x87, 0xC1,
  0xF0, 0x0F, 0x1F, 0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0x78, 0xF8, 0x07,
  0xC1, 0xE1, 0xF0, 0x0F, 0x83, 0xC3, 0xC0, 0x0F, 0x8F, 0x0F, 0x80, 0x1F,
  0xBE, 0x1F, 0x00, 0x1F, 0x78, 0x3E, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFF,
  0x03, 0xF8, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xE7, 0xFF, 0xF8, 0x7F,
  0xC7, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x3E, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3,
  0xE1, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x18, 0x1C, 0x0C,
  0xF0, 0xE1, 0xEF, 0xEF, 0x7F, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0x78, 0x01,
  0xE3, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x10, 0x08,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0xFE, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x0F, 0xE0, 0xFC, 0xF8,
  0x3F, 0x83, 0xE3, 0xE0, 0xFE, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F,
  0xC0, 0xF9, 0xF0, 0x7F, 0x07, 0xE7, 0xC1, 0xFC, 0x1F, 0x1F, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x7C, 0x00, 0x7F, 0xE3, 0xE0, 0x03, 0xFC, 0x1F, 0x00, 0x1E, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7E,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x7E,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0xFF, 0x00, 0x03, 0xEF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xE0,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x07, 0xC3, 0xFF,
  0xC0, 0x3E, 0x7F, 0xFF, 0x01, 0xF7, 0xFF, 0xFC, 0x1F, 0x7C, 0x0F, 0xF0,
  0xFF, 0x80, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC1, 0xF7, 0xC0, 0xFF, 0xFF, 0xBE, 0x07, 0xFF,
  0xF1, 0xE0, 0x0F, 0xFF, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x07,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x0E, 0x03,
  0xC0, 0x7F, 0x9E, 0xF0, 0x38, 0x1F, 0xF9, 0xCF, 0x07, 0x83, 0xE3, 0xBC,
  0xF0, 0x70, 0x78, 0x1F, 0x8E, 0x0F, 0x0F, 0x81, 0xF8, 0xE0, 0xE0, 0xF0,
  0x0F, 0x0E, 0x1E, 0x1E, 0x01, 0xF0, 0xE1, 0xE1, 0xC0, 0x1F, 0x1E, 0x1C,
  0x3C, 0x01, 0xE1, 0xE3, 0xC3, 0x80, 0x1E, 0x1E, 0x3C, 0x78, 0x01, 0xC1,
  0xC3, 0x87, 0x80, 0x3C, 0x1C, 0x38, 0xF0, 0x03, 0xC3, 0xC7, 0x8F, 0x00,
  0x38, 0x38, 0x78, 0xF0, 0x07, 0x83, 0x87, 0x8E, 0x00, 0x70, 0x78, 0x71,
  0xE0, 0x0F, 0x07, 0x07, 0x1E, 0x00, 0xF0, 0x70, 0x71, 0xE0, 0x1E, 0x0E,
  0x0F, 0x1E, 0x03, 0xE0, 0xE0, 0xF1, 0xE0, 0x7E, 0x1C, 0x0F, 0x1E, 0x0F,
  0xC3, 0xC0, 0xF1, 0xF1, 0xDC, 0x78, 0x0F, 0x0F, 0xF9, 0xFF, 0x00, 0xF0,
  0xFF, 0x0F, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x08, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x7F, 0x07, 0xC0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0x8F, 0x80,
  0x3F, 0xFF, 0x1F, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0x7C,
  0xFE, 0x00, 0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFC, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0xF7, 0x80, 0x1D, 0xE0, 0x1E, 0xF0,
  0x07, 0xBC, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F,
  0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xE7, 0x80, 0x79, 0xF0, 0x78, 0xF0,
  0x1F, 0x1E, 0x0F, 0x3E, 0x03, 0xE3, 0xC3, 0xC7, 0xC0, 0x7C, 0x7C, 0xF8,
  0xF8, 0x0F, 0x0F, 0x9E, 0x1E, 0x01, 0xE1, 0xF7, 0xC3, 0xC0, 0x7C, 0x1E,
  0xF0, 0xF8, 0x0F, 0x83, 0xDC, 0x1F, 0x01, 0xF0, 0x7F, 0x83, 0xE0, 0x3C,
  0x0F, 0xE0, 0x78, 0x07, 0x81, 0xFC, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x0F, 0x80, 0x7F,
  0x00, 0x07, 0xC0, 0x7F, 0x80, 0x03, 0xE0, 0x3F, 0xE0, 0x01, 0xF0, 0x1F,
  0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xBC, 0x00, 0x7C, 0x07,
  0xDF, 0x00, 0x3E, 0x03, 0xEF, 0x80, 0x1F, 0x01, 0xF7, 0xC0, 0x0F, 0x80,
  0xF9, 0xE0, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE0,
  0x3E, 0x3E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x78,
  0x07, 0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x1F,
  0x01, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x07, 0x87,
  0xC0, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x00, 0xF8,
  0xF8, 0x0F, 0x80, 0x3E, 0x78, 0x07, 0x80, 0x1F, 0x7C, 0x07, 0xC0, 0x0F,
  0xBE, 0x03, 0xE0, 0x07, 0xDF, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0xF8, 0x00,
  0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x3F, 0xE0, 0x3E, 0x00,
  0x0F, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x03, 0xFC, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x01,
  0xFF, 0x03, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0x80, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x01, 0xE0, 0x7C,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0xE0, 0x3C,
  0x07, 0xC1, 0xEF, 0x07, 0xC0, 0x7C, 0x1E, 0xF0, 0x7C, 0x07, 0xC1, 0xEF,
  0x07, 0x80, 0x7C, 0x3C, 0xF0, 0xF8, 0x07, 0x83, 0xCF, 0x0F, 0x80, 0x78,
  0x78, 0xF0, 0xF0, 0x07, 0x87, 0x8F, 0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0,
  0x0F, 0x8F, 0x0F, 0x1E, 0x00, 0xF9, 0xE0, 0xF3, 0xE0, 0x0F, 0x9E, 0x0F,
  0x3E, 0x00, 0xFB, 0xC0, 0xF3, 0xC0, 0x0F, 0xBC, 0x0F, 0x3C, 0x00, 0xFF,
  0x80, 0xF7, 0xC0, 0x0F, 0xF8, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x77, 0x80,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x3E, 0x0F, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0xE1,
  0xF8, 0x03, 0xFF, 0x0F, 0xE0, 0x7D, 0xF8, 0x3F, 0xFF, 0xCF, 0xF9, 0xFF,
  0xFC, 0x3F, 0xC7, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x07, 0xF0, 0x00, 0xF8, 0x7F, 0xF0, 0x03, 0xE7, 0xFF, 0xE0, 0x0F,
  0xBF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0x81, 0xF7, 0x00, 0x7E, 0x07, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0x7F, 0x80, 0x0F, 0x81, 0xFE, 0x00, 0x7E, 0x07, 0xDE, 0x07, 0xF0,
  0x1F, 0x7F, 0xFF, 0x80, 0xF8, 0xFF, 0xFC, 0x03, 0xE1, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0xF8, 0xFC, 0x00, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xFE, 0xF8,
  0x03, 0xF8, 0x1E, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x00,
  0x7F, 0x03, 0xDF, 0x00, 0x3F, 0xFF, 0xDF, 0x00, 0x3F, 0xFF, 0x9F, 0x00,
  0x1F, 0xFE, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xBF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x06, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x01, 0xFF, 0xF9, 0xF0, 0x07, 0xFF,
  0xFB, 0xE0, 0x1F, 0xC0, 0xF7, 0xC0, 0x7E, 0x00, 0xEF, 0x81, 0xF8, 0x00,
  0xFF, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x7F, 0x80, 0xFC, 0x01, 0xDF, 0x01, 0xFC, 0x0F, 0xBE, 0x01, 0xFF,
  0xFE, 0xF8, 0x03, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xC3, 0xE0, 0x01, 0xFE,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x1F, 0xE0, 0x07, 0xC3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0x01, 0xF7, 0xFF, 0xF8, 0x0F, 0x7C, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0x07,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xE7,
  0xF8, 0x7F, 0x80, 0xF7, 0xFC, 0x7F, 0xE0, 0xFB, 0xFF, 0x7F, 0xF0, 0x7B,
  0x8F, 0xB8, 0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x1F, 0x83, 0xF8, 0x3E, 0x0F,
  0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8,
  0xF8, 0x07, 0x80, 0x78, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0x80, 0x78, 0x07,
  0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x7C, 0x07, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x0F, 0x87, 0x80, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0x03, 0xC3, 0xE0, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x0F,
  0xFF, 0x00, 0xF9, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x7D, 0xF0, 0x7F,
  0x83, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x7F, 0xF0, 0x00, 0xF9,
  0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFE, 0x01, 0xF7,
  0x00, 0x7E, 0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xE0,
  0x03, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0x78, 0x1F, 0xC0, 0x1F, 0x7F,
  0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x3E, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xFF,
  0xBE, 0x03, 0xF8, 0x1E, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0xFC, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x03, 0xDF, 0x00, 0xFF,
  0xFE, 0x7C, 0x03, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0x87, 0xC0, 0x07, 0xF8,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7C,
  0x0F, 0xFE, 0x07, 0xC3, 0xFF, 0xE0, 0x7C, 0x7F, 0xFE, 0x07, 0xCF, 0xFF,
  0xE0, 0x7C, 0xFC, 0x02, 0x07, 0xDE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x38, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x77, 0xC1, 0xFC,
  0x0F, 0xBC, 0x0F, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x9F, 0x00, 0xFF, 0xF0,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x78, 0xF8, 0x07, 0xE0, 0x3E, 0x3E, 0x03, 0xF8, 0x0F,
  0x8F, 0x80, 0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xE0,
  0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x83, 0xDE, 0x0F, 0x83, 0xE1, 0xE7,
  0x83, 0xE0, 0xF8, 0x78, 0xE1, 0xF0, 0x3E, 0x3C, 0x3C, 0x7C, 0x0F, 0x8F,
  0x0F, 0x1E, 0x03, 0xE7, 0x83, 0xCF, 0x80, 0xF9, 0xE0, 0xF3, 0xE0, 0x3E,
  0xF0, 0x3C, 0xF0, 0x0F, 0xBC, 0x0F, 0x7C, 0x03, 0xDE, 0x03, 0xDF, 0x00,
  0xF7, 0x80, 0xF7, 0x80, 0x3D, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x17, 0xFF, 0xFE, 0x03, 0xDF, 0xFF, 0xFF,
  0xFF, 0x70, 0x1F, 0xFF, 0xFB, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00,
};

const GFXglyph LiberationMono_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 38, 35, 12, -38 },
  { 63, 21, 18, 35, 11, -42 },
  { 111, 34, 38, 35, 1, -38 },
  { 273, 33, 47, 35, 1, -42 },
  { 467, 38, 40, 35, -1, -39 },
  { 657, 31, 40, 35, 0, -39 },
  { 812, 9, 18, 35, 17, -42 },
  { 833, 21, 54, 35, 9, -42 },
  { 975, 22, 54, 35, 4, -42 },
  { 1124, 21, 20, 35, 10, -42 },
  { 1177, 28, 28, 35, 3, -33 },
  { 1275, 16, 19, 35, 2, -8 },
  { 1313, 17, 5, 35, 9, -17 },
  { 1324, 8, 8, 35, 11, -8 },
  { 1332, 37, 43, 35, 0, -42 },
  { 1531, 30, 40, 35, 3, -39 },
  { 1681, 29, 38, 35, 1, -38 },
  { 1819, 32, 39, 35, 1, -39 },
  { 1975, 30, 40, 35, 3, -39 },
  { 2125, 29, 38, 35, 2, -38 },
  { 2263, 31, 39, 35, 2, -38 },
  { 2415, 29, 40, 35, 4, -39 },
  { 2560, 27, 38, 35, 8, -38 },
  { 2689, 30, 40, 35, 3, -39 },
  { 2839, 29, 40, 35, 3, -39 },
  { 2984, 13, 31, 35, 11, -31 },
  { 3035, 19, 42, 35, 5, -31 },
  { 3135, 28, 30, 35, 3, -34 },
  { 3240, 28, 18, 35, 3, -28 },
  { 3303, 28, 30, 35, 3, -34 },
  { 3408, 28, 39, 35, 5, -39 },
  { 3545, 36, 49, 35, 0, -42 },
  { 3766, 35, 38, 35, -3, -38 },
  { 3933, 31, 38, 35, 2, -38 },
  { 4081, 31, 40, 35, 3, -39 },
  { 4236, 31, 38, 35, 2, -38 },
  { 4384, 33, 38, 35, 2, -38 },
  { 4541, 32, 38, 35, 3, -38 },
  { 4693, 31, 40, 35, 3, -39 },
  { 4848, 33, 38, 35, 2, -38 },
  { 5005, 30, 38, 35, 3, -38 },
  { 5148, 28, 39, 35, 4, -38 },
  { 5285, 35, 38, 35, 2, -38 },
  { 5452, 25, 38, 35, 4, -38 },
  { 5571, 35, 38, 35, 1, -38 },
  { 5738, 33, 38, 35, 2, -38 },
  { 5895, 30, 40, 35, 3, -39 },
  { 6045, 32, 38, 35, 2, -38 },
  { 6197, 30, 51, 35, 3, -39 },
  { 6389, 32, 38, 35, 2, -38 },
  { 6541, 33, 40, 35, 1, -39 },
  { 6706, 31, 38, 35, 6, -38 },
  { 6854, 32, 39, 35, 3, -38 },
  { 7010, 34, 38, 35, 5, -38 },
  { 7172, 36, 38, 35, 3, -38 },
  { 7343, 39, 38, 35, -2, -38 },
  { 7529, 33, 38, 35, 5, -38 },
  { 7686, 37, 38, 35, -1, -38 },
  { 7862, 26, 54, 35, 6, -42 },
  { 8038, 20, 43, 35, 8, -42 },
  { 8146, 26, 54, 35, 2, -42 },
  { 8322, 27, 26, 35, 3, -38 },
  { 8410, 35, 3, 35, -4, 4 },
  { 8424, 11, 7, 35, 16, -41 },
  { 8434, 29, 33, 35, 2, -32 },
  { 8554, 30, 43, 35, 2, -42 },
  { 8716, 29, 33, 35, 3, -32 },
  { 8836, 32, 43, 35, 3, -42 },
  { 9008, 29, 33, 35, 3, -32 },
  { 9128, 30, 42, 35, 6, -42 },
  { 9286, 31, 44, 35, 2, -32 },
  { 9457, 29, 42, 35, 2, -42 },
  { 9610, 29, 42, 35, 1, -42 },
  { 9763, 31, 54, 35, -2, -42 },
  { 9973, 30, 42, 35, 4, -42 },
  { 10131, 28, 42, 35, 1, -42 },
  { 10278, 33, 32, 35, 0, -32 },
  { 10410, 29, 32, 35, 2, -32 },
  { 10526, 29, 33, 35, 3, -32 },
  { 10646, 32, 44, 35, 0, -32 },
  { 10822, 30, 44, 35, 3, -32 },
  { 10987, 28, 32, 35, 5, -32 },
  { 11099, 28, 33, 35, 3, -32 },
  { 11215, 22, 40, 35, 8, -39 },
  { 11325, 29, 32, 35, 4, -31 },
  { 11441, 31, 31, 35, 5, -31 },
  { 11562, 34, 31, 35, 3, -31 },
  { 11694, 34, 31, 35, 0, -31 },
  { 11826, 36, 43, 35, 0, -31 },
  { 12020, 31, 31, 35, 1, -31 },
  { 12141, 29, 54, 35, 6, -42 },
  { 12337, 5, 54, 35, 15, -42 },
  { 12371, 30, 54, 35, -1, -42 },
  { 12574, 30, 7, 35, 3, -23 },
};

const GFXfont LiberationMono_Italic58pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic58pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic58pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _LIBERATIONMONO_ITALIC58PT7B_H_
