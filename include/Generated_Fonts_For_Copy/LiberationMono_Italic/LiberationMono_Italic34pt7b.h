#ifndef _LIBERATIONMONO_ITALIC34PT7B_H_
#define _LIBERATIONMONO_ITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3,
  0x87, 0x0C, 0x18, 0x00, 0x00, 0x07, 0x8E, 0x1C, 0x00, 0x38, 0x7B, 0xC3,
  0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0x60, 0xE7,
  0x06, 0x38, 0x30, 0x00, 0x30, 0x30, 0x01, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x06, 0x03, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x04, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x02, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x08, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x04, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x1E, 0x67, 0x87, 0x0C, 0x78, 0xE1, 0x87, 0x1C, 0x30, 0xE3, 0x06,
  0x00, 0x71, 0xC0, 0x0F, 0x30, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x06, 0x1C, 0x00, 0xC3, 0xC0, 0x18, 0x3B, 0x83, 0x07, 0x70, 0x60,
  0xCE, 0x1C, 0x39, 0xE3, 0x0F, 0x1E, 0x63, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x18, 0x7F,
  0x80, 0xC1, 0x8E, 0x07, 0x0E, 0x18, 0x38, 0x30, 0x61, 0xC0, 0xC1, 0x8E,
  0x07, 0x0E, 0x70, 0x1C, 0x31, 0x80, 0x71, 0xCC, 0x00, 0xFE, 0x60, 0x01,
  0xF3, 0x00, 0x00, 0x19, 0xF0, 0x00, 0xEF, 0xE0, 0x07, 0x71, 0xC0, 0x39,
  0x87, 0x01, 0xCE, 0x1C, 0x0E, 0x38, 0x70, 0x30, 0xC1, 0x81, 0x83, 0x06,
  0x0C, 0x0E, 0x38, 0x60, 0x1F, 0xC3, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xE0, 0x1C, 0x38, 0x0E, 0x06, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x30,
  0x70, 0x0C, 0x78, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x0C, 0x77, 0x07,
  0x39, 0xC1, 0xDC, 0x38, 0xE6, 0x0E, 0x33, 0x81, 0xDC, 0xE0, 0x7E, 0x38,
  0x0F, 0x0E, 0x03, 0xC3, 0xC1, 0xFC, 0x7F, 0xE7, 0xC7, 0xE0, 0xF0, 0x7B,
  0xDC, 0xE7, 0x39, 0x9C, 0xE7, 0x30, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x00, 0x30, 0x03, 0x04, 0x31, 0xF6, 0xF7, 0xFE, 0x1F,
  0x80, 0xF0, 0x1B, 0x03, 0x38, 0x71, 0x86, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x18, 0x06, 0x00, 0x7F, 0xDF, 0xFF, 0xFC, 0x7B, 0xDE,
  0xF7, 0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x83, 0xC1, 0xC3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0xF1, 0xDC, 0x78, 0xFC, 0x38,
  0x7E, 0x3C, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x0E, 0x1C, 0x07, 0x0F, 0x0F, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x7C, 0x01, 0xDC, 0x1F, 0x9C, 0x1C, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x78,
  0x3C, 0x3C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF,
  0x83, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x07,
  0x9E, 0x07, 0x87, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0x70, 0x03, 0x38, 0x03, 0x1C, 0x03, 0x0E,
  0x03, 0x0E, 0x03, 0x07, 0x03, 0x03, 0x83, 0x01, 0xC3, 0x00, 0xE3, 0x80,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0xFC, 0x07, 0xFF, 0x83, 0xE0, 0xF0, 0xF0, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x3C, 0x01, 0xC7, 0x00,
  0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0x81, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x39, 0xF8, 0x39, 0xFF, 0x1F, 0x87, 0x8F, 0x01, 0xE7, 0x00, 0x73,
  0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0x60, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x0F, 0x0F, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x0E, 0x1E, 0x0E, 0x07, 0xFC, 0x03, 0xFF,
  0x07, 0x83, 0xC7, 0x00, 0xE7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x07, 0x1E, 0x07, 0x87, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0xC0, 0xF1, 0xC0, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDE, 0x01, 0xE7,
  0x01, 0xE3, 0xC3, 0xF0, 0xFF, 0xB8, 0x3F, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x70, 0x0E, 0x38, 0x0E, 0x1E, 0x0E, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0x0F, 0x1E, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1E, 0x0F,
  0x38, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x38, 0x38, 0x03, 0x00,
  0xE0, 0x30, 0x03, 0x03, 0x00, 0x1C, 0x38, 0xF3, 0x61, 0x8F, 0xD3, 0x18,
  0xE7, 0x98, 0xCE, 0x1C, 0xCC, 0x60, 0xC6, 0x66, 0x06, 0x77, 0x30, 0x73,
  0x33, 0x83, 0x19, 0x98, 0x18, 0xCC, 0xC1, 0x86, 0x6E, 0x0C, 0x66, 0x60,
  0xE3, 0x33, 0x06, 0x31, 0x98, 0x71, 0x8C, 0xE7, 0x98, 0x63, 0xEF, 0x83,
  0x9E, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30, 0x0E, 0x07,
  0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xC0,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xE0, 0x3C,
  0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C,
  0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xE0, 0x3E, 0x38, 0x03, 0x8E, 0x00,
  0xF7, 0x80, 0x1D, 0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x73,
  0xC0, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0xF8, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x11, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x08, 0xE0, 0x07, 0x3C, 0x03, 0x87,
  0x01, 0xE1, 0xE0, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x38, 0x3E, 0x07, 0x01, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x78, 0x3E, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x78, 0x78,
  0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x1F, 0xEF, 0x0F, 0xFB, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x3C, 0x03, 0x87, 0x00, 0xE1, 0xE0,
  0xF8, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x0F, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x38, 0xF0,
  0x3C, 0x78, 0x1C, 0x1C, 0x0E, 0x0F, 0x1E, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x01, 0xE0,
  0xF0, 0x0E, 0x0F, 0x00, 0x70, 0xF0, 0x03, 0x9F, 0x00, 0x1D, 0xE0, 0x01,
  0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x3C,
  0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x1F, 0x03, 0x60, 0xFC, 0x1F, 0x06, 0xE1, 0xB8, 0x77, 0x1D, 0xC3, 0xB8,
  0xCC, 0x1C, 0xCE, 0xE0, 0xE6, 0x67, 0x06, 0x37, 0x38, 0x71, 0xF1, 0xC3,
  0x8F, 0x8C, 0x1C, 0x78, 0xE0, 0xE1, 0x87, 0x06, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3E, 0x03, 0x87, 0xC0, 0x71,
  0xF8, 0x0C, 0x3B, 0x83, 0x87, 0x70, 0x70, 0xEE, 0x0E, 0x19, 0xC1, 0xC7,
  0x1C, 0x30, 0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x86, 0x38, 0x60, 0xE7, 0x1C,
  0x1C, 0xC3, 0x83, 0xB8, 0x70, 0x3F, 0x0E, 0x07, 0xE1, 0x80, 0xFC, 0x70,
  0x1F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0xF0, 0xF0, 0x78, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x3D, 0xC0,
  0x0F, 0x70, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07,
  0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8F,
  0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x38, 0x0F, 0x07, 0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x70, 0xE0, 0x3C, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x1C,
  0x03, 0x8E, 0x00, 0xE7, 0x80, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xFC, 0x00,
  0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xE1, 0xE0, 0x3F,
  0xF0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x38, 0x0F, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x0E, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC,
  0x03, 0x87, 0x00, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x00, 0xF1, 0xC0,
  0x1E, 0x38, 0x01, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0xC0, 0x1C, 0x3C, 0x0F,
  0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x01, 0xE3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x1E, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x78, 0x3C, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x01, 0xCF,
  0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x87, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xDC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3B, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x1C, 0x38, 0xE1, 0xE1, 0xC7, 0x0F,
  0x0E, 0x38, 0xF8, 0xE1, 0xC6, 0xC7, 0x0E, 0x76, 0x38, 0x73, 0x33, 0x83,
  0xB9, 0xDC, 0x1D, 0x8E, 0xC0, 0xFC, 0x76, 0x07, 0xC3, 0xF0, 0x36, 0x1F,
  0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x00, 0x07, 0x80, 0x1C,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3D,
  0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xE0, 0x0E, 0x1C, 0x03, 0x83, 0xC0,
  0xE0, 0x38, 0x3C, 0x07, 0x0F, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xD8, 0x01, 0x98, 0x03, 0x98, 0x03,
  0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x0E, 0x18, 0x0E, 0x38,
  0x06, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0xE1, 0xC3, 0x87, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0xC0,
  0xE1, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E,
  0x07, 0x9E, 0x03, 0x8E, 0x01, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0xC0, 0xF9,
  0xE1, 0xDC, 0x7F, 0xCF, 0x9F, 0x87, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0xF8, 0x1E, 0xFF, 0x07, 0x61, 0xE1, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03,
  0xCF, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0xC3, 0xC1, 0xDF,
  0xE0, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0x83, 0xC3, 0x80,
  0xE3, 0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0x70,
  0xF0, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x0F,
  0x8E, 0x0F, 0xFB, 0x87, 0x86, 0xE3, 0xC0, 0xF0, 0xE0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x07, 0xC1, 0xFF,
  0x70, 0x3F, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1E, 0x0F, 0x1C, 0x07,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0xF0, 0x1C, 0x78, 0x78,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF1,
  0xC1, 0xFF, 0x70, 0xF0, 0xDC, 0x78, 0x1F, 0x1C, 0x07, 0x8E, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x01, 0xE1, 0xE1, 0xF8, 0x3F, 0xEE,
  0x07, 0xE3, 0x80, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x1C, 0x3C, 0x0E, 0x07,
  0x87, 0x81, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x7C,
  0x1E, 0xFF, 0x0E, 0xC3, 0xC7, 0xC0, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x20, 0x78, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x1C, 0x07, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x07, 0x8E, 0x01, 0xC3, 0xC0,
  0x70, 0x70, 0x1C, 0x1E, 0x07, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x1C, 0xE1, 0xE1, 0xDF, 0x7E, 0x1E,
  0x74, 0xF1, 0xC3, 0x87, 0x1C, 0x38, 0x73, 0x87, 0x06, 0x38, 0x70, 0xE3,
  0x87, 0x0E, 0x38, 0x70, 0xE3, 0x07, 0x0E, 0x70, 0x60, 0xC7, 0x0E, 0x1C,
  0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xCE, 0x0C, 0x18, 0xE1, 0xC3,
  0x8E, 0x1C, 0x38, 0x0C, 0x3E, 0x0E, 0x7F, 0xC7, 0x61, 0xE3, 0xE0, 0x71,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x38, 0xE0,
  0x1C, 0x70, 0x0E, 0x70, 0x07, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0x83,
  0xC7, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x1F, 0xE0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xF3,
  0xC0, 0x70, 0xF0, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0x1F, 0x01,
  0xCF, 0xF0, 0x3B, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC3,
  0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E,
  0x01, 0xC3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xF0, 0x70, 0x3B,
  0xFC, 0x0E, 0x3F, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0x87,
  0xFD, 0xC7, 0x86, 0xE7, 0x81, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xE7, 0x00, 0xF3, 0x80, 0xF1, 0xE1, 0xF8, 0x7F, 0xDC, 0x1F, 0x8E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x1C, 0x3F, 0x1C, 0xFF, 0x1D, 0xFF, 0x1F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1E, 0x0F, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x38, 0x7F,
  0xF0, 0x1F, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x01,
  0xFF, 0xF7, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x11, 0xFF, 0x81, 0xFE, 0x00, 0x1C, 0x03, 0x9E, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x01, 0xE7,
  0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF8, 0x7F, 0xDC, 0x1F, 0x8E, 0x00, 0xE0,
  0x03, 0xFC, 0x00, 0xEF, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x07,
  0x87, 0x01, 0xC1, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x8F, 0x00,
  0xE3, 0x80, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x1E, 0x1C, 0xE1, 0xE1, 0x8E, 0x36, 0x38,
  0xE3, 0x63, 0x8E, 0x66, 0x70, 0xE6, 0x67, 0x0E, 0xC6, 0x70, 0xCC, 0x6E,
  0x0D, 0x86, 0xE0, 0xD8, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0x0E, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x03,
  0x87, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x1C, 0x00, 0xE1, 0xE0,
  0x1C, 0x0E, 0x03, 0x80, 0xF0, 0x70, 0x07, 0x0F, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0xE0, 0x03, 0x87, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x06, 0x38, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x78, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x03, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0xF0, 0x7F, 0xE0, 0x07, 0xC0,
};

const GFXglyph LiberationMono_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 22, 20, 7, -22 },
  { 21, 13, 11, 20, 6, -25 },
  { 39, 21, 22, 20, 0, -22 },
  { 97, 19, 28, 20, 1, -25 },
  { 164, 22, 22, 20, 0, -22 },
  { 225, 18, 22, 20, 0, -22 },
  { 275, 5, 11, 20, 10, -25 },
  { 282, 13, 32, 20, 5, -25 },
  { 334, 13, 32, 20, 2, -25 },
  { 386, 12, 12, 20, 6, -25 },
  { 404, 16, 16, 20, 2, -20 },
  { 436, 10, 11, 20, 1, -5 },
  { 450, 10, 3, 20, 5, -10 },
  { 454, 5, 5, 20, 6, -5 },
  { 458, 22, 25, 20, 0, -25 },
  { 527, 17, 22, 20, 2, -22 },
  { 574, 16, 22, 20, 1, -22 },
  { 618, 18, 22, 20, 1, -22 },
  { 668, 17, 22, 20, 2, -22 },
  { 715, 17, 22, 20, 1, -22 },
  { 762, 18, 22, 20, 1, -22 },
  { 812, 17, 22, 20, 2, -22 },
  { 859, 15, 22, 20, 5, -22 },
  { 901, 17, 22, 20, 2, -22 },
  { 948, 17, 22, 20, 2, -22 },
  { 995, 8, 18, 20, 6, -18 },
  { 1013, 11, 24, 20, 3, -18 },
  { 1046, 16, 17, 20, 2, -20 },
  { 1080, 16, 10, 20, 2, -17 },
  { 1100, 16, 17, 20, 2, -20 },
  { 1134, 16, 22, 20, 3, -22 },
  { 1178, 21, 29, 20, 0, -25 },
  { 1255, 21, 22, 20, -2, -22 },
  { 1313, 18, 22, 20, 1, -22 },
  { 1363, 18, 22, 20, 2, -22 },
  { 1413, 19, 22, 20, 1, -22 },
  { 1466, 20, 22, 20, 1, -22 },
  { 1521, 20, 22, 20, 1, -22 },
  { 1576, 18, 22, 20, 2, -22 },
  { 1626, 19, 22, 20, 1, -22 },
  { 1679, 18, 22, 20, 2, -22 },
  { 1729, 17, 22, 20, 2, -22 },
  { 1776, 21, 22, 20, 1, -22 },
  { 1834, 15, 22, 20, 2, -22 },
  { 1876, 21, 22, 20, 0, -22 },
  { 1934, 19, 22, 20, 1, -22 },
  { 1987, 18, 22, 20, 2, -22 },
  { 2037, 19, 22, 20, 1, -22 },
  { 2090, 18, 29, 20, 2, -22 },
  { 2156, 19, 22, 20, 1, -22 },
  { 2209, 19, 22, 20, 1, -22 },
  { 2262, 19, 22, 20, 3, -22 },
  { 2315, 19, 22, 20, 2, -22 },
  { 2368, 20, 22, 20, 3, -22 },
  { 2423, 21, 22, 20, 2, -22 },
  { 2481, 23, 22, 20, -1, -22 },
  { 2545, 19, 22, 20, 3, -22 },
  { 2598, 22, 22, 20, -1, -22 },
  { 2659, 15, 32, 20, 4, -25 },
  { 2719, 12, 25, 20, 5, -25 },
  { 2757, 16, 32, 20, 1, -25 },
  { 2821, 16, 15, 20, 2, -22 },
  { 2851, 21, 2, 20, -3, 2 },
  { 2857, 6, 4, 20, 10, -24 },
  { 2860, 17, 18, 20, 1, -18 },
  { 2899, 18, 25, 20, 1, -25 },
  { 2956, 17, 18, 20, 2, -18 },
  { 2995, 18, 25, 20, 2, -25 },
  { 3052, 16, 18, 20, 2, -18 },
  { 3088, 17, 25, 20, 4, -25 },
  { 3142, 18, 25, 20, 1, -18 },
  { 3199, 17, 25, 20, 1, -25 },
  { 3253, 16, 25, 20, 1, -25 },
  { 3303, 18, 32, 20, -1, -25 },
  { 3375, 18, 25, 20, 2, -25 },
  { 3432, 17, 25, 20, 0, -25 },
  { 3486, 20, 18, 20, 0, -18 },
  { 3531, 17, 18, 20, 1, -18 },
  { 3570, 17, 18, 20, 2, -18 },
  { 3609, 19, 25, 20, 0, -18 },
  { 3669, 17, 25, 20, 2, -18 },
  { 3723, 16, 18, 20, 3, -18 },
  { 3759, 16, 18, 20, 2, -18 },
  { 3795, 14, 23, 20, 4, -23 },
  { 3836, 17, 18, 20, 2, -18 },
  { 3875, 18, 18, 20, 3, -18 },
  { 3916, 20, 18, 20, 2, -18 },
  { 3961, 20, 18, 20, 0, -18 },
  { 4006, 21, 25, 20, 0, -18 },
  { 4072, 18, 18, 20, 1, -18 },
  { 4113, 17, 32, 20, 4, -25 },
  { 4181, 3, 32, 20, 9, -25 },
  { 4193, 17, 32, 20, 0, -25 },
  { 4261, 17, 4, 20, 2, -13 },
};

const GFXfont LiberationMono_Italic34pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic34pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic34pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _LIBERATIONMONO_ITALIC34PT7B_H_
