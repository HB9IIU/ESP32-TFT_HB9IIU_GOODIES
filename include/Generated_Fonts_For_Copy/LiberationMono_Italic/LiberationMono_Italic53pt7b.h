#ifndef _LIBERATIONMONO_ITALIC53PT7B_H_
#define _LIBERATIONMONO_ITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x07, 0xE7, 0xC0, 0xFC, 0xF8,
  0x1F, 0xBF, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xF0, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x1C, 0x7F, 0x03, 0xE0, 0x70,
  0xFC, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x0E, 0x03, 0xC1, 0xE0, 0x38, 0x0E,
  0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xF8, 0x70, 0x00, 0x07, 0xF9, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x38, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x3C,
  0x30, 0x07, 0x01, 0xF3, 0xE0, 0x3C, 0x07, 0xCF, 0x80, 0xE0, 0x1E, 0x3E,
  0x03, 0x80, 0xF8, 0x7C, 0x0E, 0x0F, 0xC1, 0xFC, 0x38, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3C, 0x0F, 0xFF, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0x03, 0xC0, 0x78,
  0x1C, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x78, 0x0E, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x78, 0x1C,
  0x00, 0x78, 0x0F, 0x07, 0x80, 0x0F, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x78,
  0x78, 0x00, 0x3C, 0x0F, 0x1E, 0x00, 0x07, 0xC3, 0xC7, 0x80, 0x00, 0x7F,
  0xF1, 0xE0, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x3C, 0x7F,
  0xE0, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x03, 0xC7, 0xC7, 0xC0, 0x00, 0xF1,
  0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x07, 0x0F, 0x01, 0xE0, 0x01,
  0xC1, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x03, 0x80,
  0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0xE0, 0x01,
  0xFF, 0xE0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x3E,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x60, 0x1F, 0xF0, 0x07, 0x81, 0xFF, 0x80, 0x3C, 0x1F, 0x3E, 0x01, 0xE1,
  0xF1, 0xF0, 0x1E, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x3E, 0x0F, 0x0F, 0x80,
  0xF0, 0x78, 0x78, 0x07, 0xC7, 0x87, 0xC0, 0x1F, 0x3C, 0x3E, 0x00, 0xFB,
  0xC1, 0xE0, 0x03, 0xFE, 0x0F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7E, 0x07, 0xFF, 0xDB, 0xFF,
  0xFE, 0xFF, 0x8F, 0xFF, 0xE3, 0xFC, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0x80,
  0x1E, 0x00, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x18, 0x38, 0x3F, 0xCE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x81, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0x81, 0xE0,
  0xF0, 0x70, 0x3C, 0x08, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0xFC, 0x1F, 0x7C,
  0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x79, 0xF0, 0xFE, 0x1F, 0x3C, 0x1F, 0x83,
  0xE7, 0x83, 0xF0, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF7, 0xC0, 0x1F, 0xF1, 0xF0,
  0x07, 0xF0, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8,
  0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xFF,
  0x00, 0x0F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFE, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x03, 0xF8, 0x03, 0xC7, 0xFF, 0x81, 0xF3, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x1E, 0xF0, 0x3F, 0x87, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x03,
  0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0xFF, 0x0F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0x78, 0x1F, 0xFF, 0xDF, 0x00, 0xFF, 0xE3,
  0xE0, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF9, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x03, 0xC0, 0x7C, 0x07, 0x03, 0x81, 0xFE, 0x77, 0x07, 0x83,
  0xFE, 0xE7, 0x0F, 0x07, 0x86, 0xE7, 0x0E, 0x0F, 0x06, 0xE7, 0x0E, 0x1E,
  0x07, 0xC7, 0x1E, 0x3C, 0x07, 0xC7, 0x1C, 0x38, 0x07, 0x87, 0x3C, 0x78,
  0x07, 0x87, 0x38, 0x70, 0x07, 0x0F, 0x38, 0xF0, 0x07, 0x0E, 0x38, 0xE0,
  0x0F, 0x0E, 0x79, 0xE0, 0x0E, 0x1E, 0x71, 0xE0, 0x0E, 0x1C, 0x71, 0xC0,
  0x1C, 0x1C, 0x71, 0xC0, 0x3C, 0x3C, 0x71, 0xC0, 0x38, 0x38, 0xF1, 0xC0,
  0x78, 0x78, 0xF3, 0xC0, 0xF8, 0x70, 0xF1, 0xC1, 0xB0, 0xE0, 0xF1, 0xE3,
  0xB1, 0xE0, 0xF1, 0xFF, 0x3F, 0xC0, 0xF0, 0xFE, 0x3F, 0x80, 0xF0, 0x78,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE1, 0xF0, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x78, 0xFC,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x81, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3E, 0x01,
  0xFE, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x18, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xFC, 0x7C, 0x03, 0xFF,
  0xCF, 0xC0, 0x7F, 0xFC, 0xF8, 0x07, 0xFF, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x81,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x7F,
  0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x07, 0xBC, 0x01, 0xFC, 0x07, 0xBC, 0x03, 0xFC, 0x07, 0xBC,
  0x07, 0xBC, 0x07, 0xBC, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x7C, 0x0F, 0xBC,
  0x0F, 0x78, 0x0F, 0x3E, 0x1E, 0x78, 0x0F, 0x1E, 0x1E, 0x78, 0x0F, 0x1E,
  0x3C, 0x78, 0x0F, 0x1E, 0x38, 0xF8, 0x1F, 0x1E, 0x78, 0xF8, 0x1E, 0x1E,
  0x70, 0xF0, 0x1E, 0x1E, 0xF0, 0xF0, 0x1E, 0x0E, 0xE0, 0xF0, 0x1E, 0x0F,
  0xE0, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3C, 0x0F, 0xC1, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xF0,
  0x00, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x3F, 0xC0, 0x07, 0xC0, 0x7F, 0x80,
  0x0F, 0x80, 0xFF, 0x80, 0x1E, 0x01, 0xEF, 0x00, 0x3C, 0x03, 0xDE, 0x00,
  0x78, 0x0F, 0xBE, 0x01, 0xF0, 0x1F, 0x7C, 0x03, 0xE0, 0x3C, 0x78, 0x07,
  0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xF0, 0x1E, 0x03, 0xE1, 0xE0, 0x7C,
  0x07, 0xC3, 0xC0, 0xF8, 0x0F, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x83, 0xC0,
  0x3C, 0x0F, 0x07, 0x80, 0xF8, 0x1E, 0x1F, 0x01, 0xF0, 0x3E, 0x3E, 0x03,
  0xE0, 0x7C, 0x7C, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xE0, 0x3E,
  0x01, 0xF7, 0xC0, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xDF, 0x01, 0xE0,
  0x07, 0xBC, 0x03, 0xC0, 0x0F, 0xF8, 0x07, 0x80, 0x1F, 0xF0, 0x1F, 0x00,
  0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x7F, 0x00, 0xF0, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x03,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xF8, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x70, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x01, 0xF0, 0x1F, 0x07,
  0x80, 0xF8, 0x0F, 0x03, 0xC0, 0xFC, 0x07, 0x81, 0xE0, 0x7E, 0x07, 0xC1,
  0xF0, 0x7F, 0x03, 0xC0, 0xF8, 0x3F, 0xC1, 0xE0, 0x7C, 0x1D, 0xE1, 0xF0,
  0x3E, 0x1E, 0xF0, 0xF0, 0x1F, 0x0E, 0x78, 0x78, 0x0F, 0x8F, 0x3C, 0x7C,
  0x07, 0xC7, 0x1E, 0x3C, 0x03, 0xE7, 0x8F, 0x1E, 0x01, 0xE3, 0xC7, 0x9F,
  0x00, 0xF3, 0xC3, 0xCF, 0x00, 0x79, 0xE0, 0xE7, 0x80, 0x3D, 0xE0, 0x73,
  0xC0, 0x1E, 0xF0, 0x3B, 0xC0, 0x0F, 0x70, 0x1D, 0xE0, 0x07, 0xF8, 0x0E,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0x0F, 0xC0, 0x07, 0x87, 0xE0, 0x01, 0xE1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x03, 0xBC, 0x3F, 0x03, 0xCF, 0x8F, 0xFF,
  0xE3, 0xFD, 0xFF, 0xF0, 0xFF, 0x3F, 0xF8, 0x3F, 0xC7, 0xF0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x1F, 0x1F,
  0xFC, 0x03, 0xE7, 0xFF, 0xC0, 0x7D, 0xFF, 0xFC, 0x0F, 0x78, 0x3F, 0x81,
  0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0x7F, 0x00, 0x3E, 0x0F, 0xE0, 0x0F, 0xC1, 0xEF, 0x07, 0xF0, 0x7D, 0xFF,
  0xFC, 0x0F, 0x9F, 0xFF, 0x01, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0xC0, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x1F, 0x00, 0x3F, 0xF8, 0xF8, 0x07, 0xFF, 0xE7, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x3C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x81, 0xFF, 0x00, 0xFF, 0xFE, 0xF8,
  0x03, 0xFF, 0xE7, 0xC0, 0x0F, 0xFE, 0x3C, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0xC0, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0x01, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF,
  0x9E, 0x03, 0xF8, 0x3D, 0xE0, 0x7E, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0,
  0xF8, 0x00, 0xFE, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0x3F,
  0x03, 0xDE, 0x03, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xE3,
  0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x7F, 0x00, 0x7C, 0x7F, 0xF0, 0x1F, 0x3F, 0xFE, 0x07, 0xDF,
  0xFF, 0xC1, 0xEF, 0x03, 0xF0, 0x7F, 0x00, 0x7C, 0x3F, 0x80, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x60, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x3C, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF3, 0xF0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0xF8, 0x0F, 0x3F, 0x87, 0xF8, 0x1E, 0xFF, 0x9F, 0xF0,
  0x3F, 0xFF, 0x7F, 0xE0, 0x7F, 0x3F, 0xC7, 0xE1, 0xF8, 0x3F, 0x07, 0xC3,
  0xF0, 0x7E, 0x0F, 0x07, 0xC0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x1E,
  0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xF0, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x0F, 0x81, 0xF0,
  0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x1F,
  0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xF1, 0xFF, 0xC0,
  0x7C, 0xFF, 0xF8, 0x1E, 0x7F, 0xFF, 0x07, 0xBC, 0x0F, 0xC1, 0xFC, 0x01,
  0xF0, 0xFE, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x8F,
  0xFE, 0x00, 0x7C, 0xFF, 0xF8, 0x03, 0xEF, 0xFF, 0xE0, 0x1E, 0xF0, 0x3F,
  0x00, 0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x1F,
  0x80, 0xF7, 0x83, 0xF8, 0x07, 0xBF, 0xFF, 0x80, 0x7C, 0xFF, 0xF8, 0x03,
  0xE3, 0xFF, 0x80, 0x1F, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFC, 0x7C, 0x0F, 0xFF, 0xCF, 0x83, 0xFF, 0xFD, 0xE0, 0x7E, 0x07, 0xFC,
  0x1F, 0x80, 0x7F, 0x87, 0xE0, 0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x87, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xFF,
  0xFD, 0xF0, 0x1F, 0xFF, 0x3E, 0x01, 0xFF, 0xC7, 0x80, 0x1F, 0xE0, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0x87, 0x81, 0xFF, 0xC3, 0xC3, 0xFF, 0xC1, 0xF3, 0xFF, 0xE0, 0xF9,
  0xF0, 0x00, 0x7D, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7F,
  0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x30, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x83, 0xE0, 0x0F, 0xE0, 0x7E,
  0x07, 0xBC, 0x0F, 0xFF, 0xE7, 0x81, 0xFF, 0xF9, 0xF0, 0x1F, 0xFE, 0x3E,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x78, 0xF8, 0x1F, 0x81, 0xF1, 0xE0, 0x3F, 0x03,
  0xC3, 0xC0, 0xFE, 0x07, 0x87, 0x81, 0xDC, 0x1F, 0x0F, 0x07, 0xB8, 0x3C,
  0x1E, 0x0E, 0x70, 0x78, 0x3C, 0x3C, 0xE1, 0xF0, 0x78, 0x71, 0xC3, 0xC0,
  0xF1, 0xE3, 0xCF, 0x81, 0xE3, 0x87, 0x9F, 0x03, 0xCF, 0x0F, 0x3C, 0x07,
  0x9C, 0x1E, 0x78, 0x0F, 0x78, 0x1D, 0xE0, 0x1E, 0xE0, 0x3B, 0xC0, 0x3F,
  0xC0, 0x77, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x05, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph LiberationMono_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 35, 32, 11, -35 },
  { 54, 19, 17, 32, 10, -38 },
  { 95, 31, 35, 32, 1, -35 },
  { 231, 30, 42, 32, 1, -38 },
  { 389, 35, 37, 32, -1, -36 },
  { 551, 29, 37, 32, 0, -36 },
  { 686, 8, 17, 32, 16, -38 },
  { 703, 20, 49, 32, 8, -38 },
  { 826, 20, 49, 32, 4, -38 },
  { 949, 18, 18, 32, 10, -38 },
  { 990, 26, 26, 32, 3, -31 },
  { 1075, 15, 17, 32, 2, -8 },
  { 1107, 16, 4, 32, 8, -15 },
  { 1115, 8, 8, 32, 10, -8 },
  { 1123, 34, 39, 32, 0, -38 },
  { 1289, 27, 37, 32, 3, -36 },
  { 1414, 26, 35, 32, 1, -35 },
  { 1528, 29, 36, 32, 1, -36 },
  { 1659, 28, 37, 32, 2, -36 },
  { 1789, 27, 35, 32, 2, -35 },
  { 1908, 28, 36, 32, 2, -35 },
  { 2034, 26, 37, 32, 4, -36 },
  { 2155, 25, 35, 32, 7, -35 },
  { 2265, 28, 37, 32, 2, -36 },
  { 2395, 27, 37, 32, 3, -36 },
  { 2520, 12, 28, 32, 10, -28 },
  { 2562, 17, 37, 32, 5, -28 },
  { 2641, 26, 27, 32, 3, -31 },
  { 2729, 26, 17, 32, 3, -26 },
  { 2785, 26, 27, 32, 3, -31 },
  { 2873, 25, 36, 32, 5, -36 },
  { 2986, 32, 44, 32, 0, -38 },
  { 3162, 32, 35, 32, -3, -35 },
  { 3302, 29, 35, 32, 1, -35 },
  { 3429, 28, 37, 32, 3, -36 },
  { 3559, 29, 35, 32, 1, -35 },
  { 3686, 31, 35, 32, 1, -35 },
  { 3822, 30, 35, 32, 2, -35 },
  { 3954, 28, 37, 32, 3, -36 },
  { 4084, 31, 35, 32, 1, -35 },
  { 4220, 28, 35, 32, 3, -35 },
  { 4343, 26, 36, 32, 4, -35 },
  { 4460, 33, 35, 32, 1, -35 },
  { 4605, 24, 35, 32, 3, -35 },
  { 4710, 32, 35, 32, 1, -35 },
  { 4850, 31, 35, 32, 1, -35 },
  { 4986, 28, 37, 32, 3, -36 },
  { 5116, 30, 35, 32, 1, -35 },
  { 5248, 28, 47, 32, 3, -36 },
  { 5413, 30, 35, 32, 1, -35 },
  { 5545, 30, 37, 32, 1, -36 },
  { 5684, 29, 35, 32, 5, -35 },
  { 5811, 29, 36, 32, 3, -35 },
  { 5942, 32, 35, 32, 4, -35 },
  { 6082, 33, 35, 32, 3, -35 },
  { 6227, 36, 35, 32, -2, -35 },
  { 6385, 30, 35, 32, 5, -35 },
  { 6517, 34, 35, 32, -1, -35 },
  { 6666, 24, 49, 32, 6, -38 },
  { 6813, 18, 39, 32, 8, -38 },
  { 6901, 24, 49, 32, 2, -38 },
  { 7048, 25, 23, 32, 3, -35 },
  { 7120, 33, 2, 32, -4, 3 },
  { 7129, 10, 7, 32, 15, -38 },
  { 7138, 26, 30, 32, 2, -29 },
  { 7236, 27, 39, 32, 2, -38 },
  { 7368, 26, 30, 32, 3, -29 },
  { 7466, 29, 39, 32, 3, -38 },
  { 7608, 26, 30, 32, 3, -29 },
  { 7706, 27, 38, 32, 6, -38 },
  { 7835, 28, 40, 32, 2, -29 },
  { 7975, 26, 38, 32, 2, -38 },
  { 8099, 26, 38, 32, 1, -38 },
  { 8223, 28, 49, 32, -2, -38 },
  { 8395, 28, 38, 32, 3, -38 },
  { 8528, 26, 38, 32, 1, -38 },
  { 8652, 31, 29, 32, 0, -29 },
  { 8765, 26, 29, 32, 2, -29 },
  { 8860, 26, 30, 32, 3, -29 },
  { 8958, 29, 40, 32, 0, -29 },
  { 9103, 27, 40, 32, 3, -29 },
  { 9238, 25, 29, 32, 5, -29 },
  { 9329, 25, 30, 32, 3, -29 },
  { 9423, 21, 36, 32, 7, -35 },
  { 9518, 27, 29, 32, 3, -28 },
  { 9616, 29, 28, 32, 4, -28 },
  { 9718, 31, 28, 32, 3, -28 },
  { 9827, 31, 28, 32, 0, -28 },
  { 9936, 33, 39, 32, 0, -28 },
  { 10097, 28, 28, 32, 1, -28 },
  { 10195, 27, 49, 32, 5, -38 },
  { 10361, 4, 49, 32, 14, -38 },
  { 10386, 27, 49, 32, -1, -38 },
  { 10552, 27, 7, 32, 3, -21 },
};

const GFXfont LiberationMono_Italic53pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic53pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic53pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _LIBERATIONMONO_ITALIC53PT7B_H_
