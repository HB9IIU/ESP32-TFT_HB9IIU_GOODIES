#ifndef _LIBERATIONMONO_ITALIC70PT7B_H_
#define _LIBERATIONMONO_ITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xE3, 0xE7, 0xFE, 0x00, 0xFF, 0x03, 0xE0, 0xFF,
  0x00, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x01, 0xF8,
  0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x38, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xF8, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x0F,
  0x80, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xCF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0xF0, 0x00,
  0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0x3C,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x0C, 0x00, 0x7C, 0x01, 0xF8, 0xFC, 0x00,
  0x78, 0x01, 0xF8, 0xFC, 0x00, 0x78, 0x01, 0xF8, 0xFE, 0x00, 0x78, 0x01,
  0xF8, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0xF0,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xE1, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00,
  0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0x00, 0x0F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0xEF, 0xC0, 0x03,
  0xE0, 0x7E, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x81, 0xF0, 0x00,
  0xFC, 0x3E, 0x0F, 0xC0, 0x01, 0xF9, 0xF0, 0x3F, 0x00, 0x07, 0xFF, 0xC0,
  0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xE0,
  0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x78, 0x3F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x40, 0x3C, 0x06,
  0x7C, 0x1E, 0x1F, 0x3F, 0xCE, 0x7F, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1,
  0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E,
  0x3F, 0x01, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0xFE, 0x7E, 0x03, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0xC0, 0xFC, 0x7E, 0x07, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x80, 0xFC,
  0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0x7F, 0xF8, 0xFC,
  0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x00, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x01, 0xFB, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x00,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x18, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x1F, 0x8F,
  0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xF8, 0x1F,
  0xBF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF,
  0xFC, 0x3F, 0x00, 0x3F, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x38, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xFE, 0x1E, 0xF8, 0x07, 0x80, 0xFF, 0xE3,
  0xDF, 0x01, 0xF0, 0x3F, 0xFC, 0xF1, 0xE0, 0x3C, 0x0F, 0xC3, 0xDE, 0x3C,
  0x0F, 0x83, 0xF0, 0x3F, 0x87, 0x81, 0xE0, 0xFC, 0x07, 0xF0, 0xF0, 0x7C,
  0x1F, 0x00, 0xFE, 0x1E, 0x0F, 0x07, 0xC0, 0x1F, 0x87, 0xC3, 0xE0, 0xF0,
  0x03, 0xF0, 0xF8, 0x78, 0x3E, 0x00, 0x7C, 0x1E, 0x0F, 0x0F, 0x80, 0x0F,
  0x83, 0xC3, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x78, 0x3C, 0x00, 0x7C, 0x0F,
  0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xE3, 0xE1, 0xE0, 0x01, 0xF0, 0x78, 0x7C,
  0x7C, 0x00, 0x7C, 0x0F, 0x0F, 0x0F, 0x80, 0x0F, 0x81, 0xE1, 0xE1, 0xE0,
  0x01, 0xE0, 0x7C, 0x3C, 0x3C, 0x00, 0x7C, 0x0F, 0x0F, 0x8F, 0x80, 0x0F,
  0x81, 0xE1, 0xE1, 0xF0, 0x01, 0xE0, 0x7C, 0x3C, 0x3E, 0x00, 0x7C, 0x0F,
  0x07, 0x87, 0x80, 0x0F, 0x81, 0xE0, 0xF0, 0xF0, 0x03, 0xE0, 0x78, 0x1E,
  0x1E, 0x00, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x1F, 0x83, 0xC0, 0xF8, 0x78,
  0x07, 0xE0, 0x78, 0x1F, 0x0F, 0x01, 0xDC, 0x1E, 0x03, 0xE1, 0xF0, 0x7F,
  0x87, 0xC0, 0x7C, 0x3E, 0x1E, 0xF1, 0xF0, 0x0F, 0x87, 0xFF, 0x9F, 0xFC,
  0x01, 0xF0, 0x7F, 0xE3, 0xFF, 0x00, 0x1E, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xC0,
  0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x00,
  0xC0, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x00,
  0x03, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x10, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0xC7,
  0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xF1, 0xFC, 0x00, 0xFF,
  0xFF, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x07, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x03,
  0xF3, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x03, 0xF3, 0xE0,
  0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x3F, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0xC1, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x7C, 0x7E, 0x01,
  0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x0F, 0x87, 0xC0, 0x1F, 0x07,
  0xC7, 0xC1, 0xF0, 0x07, 0xC1, 0xF1, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0xBE, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x03, 0xE0,
  0x0F, 0xC0, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x7E, 0x00, 0xF8,
  0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xF3,
  0xE0, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x01,
  0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x3F, 0x00, 0x0F, 0xDF,
  0x80, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x0E, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x00, 0xF8, 0x0F,
  0xBC, 0x07, 0xE0, 0x3F, 0x01, 0xE7, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0x9E, 0x07, 0xE0, 0x1F, 0x83, 0xE3, 0xE0, 0xF8,
  0x03, 0xF0, 0x7C, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xE1, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x3E, 0x3F, 0x00, 0x3F, 0x1F,
  0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xC0, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x1F,
  0x1F, 0x00, 0x1F, 0x9F, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x03, 0xDF, 0x00, 0x07, 0xFE,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0x00,
  0x03, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xF8, 0x00,
  0xF7, 0xE0, 0x7F, 0x00, 0x3E, 0xFC, 0x0F, 0xF0, 0x3F, 0x9F, 0x81, 0xFF,
  0xFF, 0xE3, 0xF8, 0x9F, 0xFF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0x80,
  0x7E, 0x7F, 0xFF, 0xF8, 0x0F, 0xDF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x07, 0xE7,
  0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0xF0, 0x03,
  0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00,
  0xFF, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xE0, 0x3F,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0xF1, 0xF8, 0x00,
  0x7F, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x0F, 0x80, 0x07, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xC0, 0xFB, 0xF8,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x7E, 0xFC, 0x01, 0xFF, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFE,
  0x3F, 0x00, 0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x00, 0x7E, 0x0F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xF8,
  0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0xFF, 0xF8, 0x0F, 0xDF, 0x81,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0x01, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x01, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0xC0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x01,
  0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x01, 0xFF,
  0x9F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF1, 0xFF,
  0x03, 0xFE, 0x01, 0xF3, 0xFF, 0x8F, 0xFF, 0x01, 0xF7, 0xFF, 0x9F, 0xFF,
  0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0x03, 0xEE, 0x1F, 0xBC, 0x7F, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x0F,
  0xC3, 0xFF, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xFC,
  0x07, 0xEF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xF0, 0x00,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xF1, 0xFF,
  0xFE, 0x00, 0x1F, 0x8F, 0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x07, 0xE7, 0xFF,
  0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0xF0, 0x00, 0x7E, 0x0F, 0xFF, 0x80, 0x01,
  0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xC7,
  0xE0, 0x0F, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xDF, 0x80, 0x7F, 0xFF, 0xF9, 0xF8,
  0x03, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xF8,
  0x3F, 0x00, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E,
  0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x1F, 0x8F, 0xFF, 0xF8, 0x0F,
  0xCF, 0xF0, 0x04, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1E, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x03, 0xFE, 0x0F,
  0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFB, 0xF0,
  0x3F, 0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x0F,
  0xC0, 0x1F, 0xFF, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x1F, 0x80,
  0x7F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x1F, 0x81, 0xE7, 0xC0, 0xF8,
  0x07, 0xE0, 0xF9, 0xF0, 0x7E, 0x01, 0xF8, 0x7C, 0x7C, 0x1F, 0x80, 0x7E,
  0x1F, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x83, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0xF0, 0xFC, 0x01, 0xF1, 0xF0, 0x3C, 0x7E, 0x00, 0x7C, 0x7C, 0x0F, 0x9F,
  0x80, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x01,
  0xF7, 0xC0, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0x1F, 0x78,
  0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0x3F, 0xFF, 0xF8, 0x00, 0x77,
  0xFF, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x7F, 0xFF,
  0xFE, 0xE0, 0x00, 0xFF, 0xFF, 0xC8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 16, 46, 42, 14, -46 },
  { 93, 26, 22, 42, 13, -51 },
  { 165, 41, 46, 42, 1, -46 },
  { 401, 40, 56, 42, 1, -50 },
  { 681, 46, 48, 42, -1, -47 },
  { 957, 38, 48, 42, 0, -47 },
  { 1185, 10, 22, 42, 21, -51 },
  { 1213, 26, 66, 42, 11, -51 },
  { 1428, 26, 66, 42, 5, -51 },
  { 1643, 25, 25, 42, 13, -51 },
  { 1722, 34, 35, 42, 4, -41 },
  { 1871, 19, 23, 42, 3, -10 },
  { 1926, 20, 5, 42, 11, -21 },
  { 1939, 10, 10, 42, 13, -10 },
  { 1952, 44, 52, 42, 0, -51 },
  { 2238, 36, 48, 42, 4, -47 },
  { 2454, 34, 46, 42, 2, -46 },
  { 2650, 39, 47, 42, 1, -47 },
  { 2880, 37, 48, 42, 3, -47 },
  { 3102, 36, 46, 42, 2, -46 },
  { 3309, 37, 47, 42, 3, -46 },
  { 3527, 35, 48, 42, 5, -47 },
  { 3737, 32, 46, 42, 10, -46 },
  { 3921, 37, 48, 42, 3, -47 },
  { 4143, 35, 48, 42, 4, -47 },
  { 4353, 16, 37, 42, 13, -37 },
  { 4427, 23, 50, 42, 6, -37 },
  { 4571, 34, 36, 42, 4, -41 },
  { 4724, 34, 22, 42, 4, -34 },
  { 4818, 34, 36, 42, 4, -41 },
  { 4971, 34, 47, 42, 6, -47 },
  { 5171, 43, 61, 42, 0, -51 },
  { 5499, 42, 46, 42, -4, -46 },
  { 5741, 38, 46, 42, 2, -46 },
  { 5960, 37, 48, 42, 4, -47 },
  { 6182, 38, 46, 42, 2, -46 },
  { 6401, 40, 46, 42, 2, -46 },
  { 6631, 39, 46, 42, 3, -46 },
  { 6856, 37, 48, 42, 4, -47 },
  { 7078, 40, 46, 42, 2, -46 },
  { 7308, 37, 46, 42, 3, -46 },
  { 7521, 34, 47, 42, 5, -46 },
  { 7721, 43, 46, 42, 2, -46 },
  { 7969, 30, 46, 42, 5, -46 },
  { 8142, 42, 46, 42, 1, -46 },
  { 8384, 40, 46, 42, 2, -46 },
  { 8614, 37, 48, 42, 3, -47 },
  { 8836, 39, 46, 42, 2, -46 },
  { 9061, 37, 61, 42, 3, -47 },
  { 9344, 40, 46, 42, 2, -46 },
  { 9574, 40, 48, 42, 1, -47 },
  { 9814, 38, 46, 42, 7, -46 },
  { 10033, 38, 47, 42, 4, -46 },
  { 10257, 41, 46, 42, 6, -46 },
  { 10493, 43, 46, 42, 4, -46 },
  { 10741, 47, 46, 42, -2, -46 },
  { 11012, 39, 46, 42, 7, -46 },
  { 11237, 44, 46, 42, -1, -46 },
  { 11490, 31, 66, 42, 8, -51 },
  { 11746, 24, 52, 42, 10, -51 },
  { 11902, 31, 66, 42, 3, -51 },
  { 12158, 33, 31, 42, 4, -46 },
  { 12286, 43, 3, 42, -5, 4 },
  { 12303, 13, 9, 42, 20, -50 },
  { 12318, 35, 39, 42, 2, -38 },
  { 12489, 35, 52, 42, 3, -51 },
  { 12717, 34, 39, 42, 4, -38 },
  { 12883, 38, 52, 42, 4, -51 },
  { 13130, 34, 39, 42, 4, -38 },
  { 13296, 37, 51, 42, 7, -51 },
  { 13532, 37, 53, 42, 3, -38 },
  { 13778, 35, 51, 42, 3, -51 },
  { 14002, 35, 51, 42, 1, -51 },
  { 14226, 37, 66, 42, -2, -51 },
  { 14532, 37, 51, 42, 4, -51 },
  { 14768, 35, 51, 42, 1, -51 },
  { 14992, 40, 38, 42, 0, -38 },
  { 15182, 35, 38, 42, 3, -38 },
  { 15349, 34, 39, 42, 4, -38 },
  { 15515, 38, 53, 42, 0, -38 },
  { 15767, 36, 53, 42, 4, -38 },
  { 16006, 33, 38, 42, 6, -38 },
  { 16163, 33, 39, 42, 4, -38 },
  { 16324, 28, 48, 42, 9, -47 },
  { 16492, 34, 38, 42, 5, -37 },
  { 16654, 37, 37, 42, 6, -37 },
  { 16826, 42, 37, 42, 3, -37 },
  { 17021, 42, 37, 42, 0, -37 },
  { 17216, 44, 52, 42, -1, -37 },
  { 17502, 38, 37, 42, 1, -37 },
  { 17678, 36, 66, 42, 7, -51 },
  { 17975, 6, 66, 42, 18, -51 },
  { 18025, 36, 66, 42, -1, -51 },
  { 18322, 36, 9, 42, 4, -28 },
};

const GFXfont LiberationMono_Italic70pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic70pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic70pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _LIBERATIONMONO_ITALIC70PT7B_H_
