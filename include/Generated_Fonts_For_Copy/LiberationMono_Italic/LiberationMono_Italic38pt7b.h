#ifndef _LIBERATIONMONO_ITALIC38PT7B_H_
#define _LIBERATIONMONO_ITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0xE0, 0xE0, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xC1,
  0xE7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x70, 0x30, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x60, 0x30,
  0x01, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xF8, 0xCF, 0x83, 0x87, 0x1E, 0x1E, 0x1C, 0x38, 0x70, 0x60, 0xE1,
  0xC1, 0x80, 0x07, 0x86, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x37, 0xE0, 0x01, 0xC7, 0xC0, 0x07, 0x0F,
  0x00, 0x18, 0x1C, 0x00, 0x60, 0x73, 0x81, 0x83, 0xCE, 0x0E, 0x0E, 0x3C,
  0x38, 0x78, 0xF8, 0xC7, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0x83, 0xFC, 0x03, 0x83, 0x8E, 0x03, 0x81, 0x83, 0x81, 0x81, 0xC1,
  0xC1, 0x80, 0xE0, 0xE1, 0x80, 0x60, 0x61, 0xC0, 0x30, 0x71, 0xC0, 0x18,
  0x39, 0xC0, 0x0C, 0x19, 0xC0, 0x07, 0x1D, 0xC0, 0x03, 0xFD, 0xC0, 0x00,
  0xF8, 0xCF, 0x80, 0x00, 0xCF, 0xF0, 0x00, 0xEE, 0x38, 0x00, 0xEE, 0x1C,
  0x00, 0xE7, 0x06, 0x00, 0xE3, 0x07, 0x00, 0xE3, 0x83, 0x80, 0xE1, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0xE0, 0x60, 0x3C, 0x60, 0x70, 0x0F,
  0xF0, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x80,
  0x30, 0x78, 0x01, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x61, 0xEE, 0x07, 0x1E, 0x70, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x1C, 0x70,
  0x79, 0xC7, 0x01, 0xCE, 0x38, 0x07, 0xE1, 0xC0, 0x3E, 0x0F, 0x00, 0xF0,
  0x7C, 0x1F, 0xE5, 0xFF, 0xFF, 0xC7, 0xFE, 0x7E, 0x1F, 0xC0, 0xF0, 0x3D,
  0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x04, 0x30, 0xFD, 0xBD,
  0xFF, 0xC3, 0xF0, 0x0F, 0x00, 0xFC, 0x06, 0x60, 0x63, 0x87, 0x1C, 0x30,
  0x40, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7D, 0xE7, 0x9E, 0x7B, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x78, 0x3E, 0x0F, 0x01,
  0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80,
  0x0E, 0x78, 0xF0, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x1E, 0xF1,
  0xF1, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0x70, 0x70, 0x0F, 0x07, 0xC3, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0xFE, 0xE0, 0x1F, 0x9C, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0x83, 0xE0, 0x78, 0x07, 0x07, 0x80, 0x3C, 0x38, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x00, 0xE1, 0xE0, 0x0F,
  0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xF0,
  0x07, 0x8F, 0x81, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1D,
  0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x00, 0xE3, 0xC0, 0x1C,
  0x38, 0x03, 0x83, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x78, 0x38,
  0x07, 0x07, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xCF, 0xC0, 0x3B, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x07, 0xC3,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xCE, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x83, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x07, 0xC1, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0x8F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x1F, 0x81, 0xCF, 0xF8, 0x3F, 0xFF, 0x8F, 0xE0,
  0xF9, 0xF0, 0x0F, 0x3C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0xF3, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x01, 0xE0, 0xF0, 0x7C, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8,
  0x1E, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C,
  0x01, 0xC1, 0xF0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03,
  0xE0, 0x78, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCE, 0x00, 0x3C,
  0xE0, 0x03, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x81, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xC1, 0xF1, 0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xE0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x9E, 0x01, 0xF3, 0xE0,
  0xFE, 0x3F, 0xFB, 0x83, 0xFE, 0x70, 0x3F, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE0, 0xF0, 0x78, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0x83, 0xE3, 0xC0, 0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xE0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0xC1, 0xC0,
  0x01, 0x83, 0x07, 0x9B, 0x0C, 0x3F, 0x76, 0x18, 0xE3, 0xCC, 0x63, 0x87,
  0x98, 0xC6, 0x0F, 0x33, 0x9C, 0x1C, 0x66, 0x30, 0x38, 0xCC, 0xE0, 0x63,
  0xB9, 0x80, 0xC6, 0x67, 0x03, 0x8C, 0xCE, 0x06, 0x19, 0x98, 0x1C, 0x77,
  0x30, 0x38, 0xCE, 0x60, 0xE1, 0x9C, 0xC1, 0xC6, 0x39, 0x87, 0x9C, 0x73,
  0x9B, 0x30, 0xE7, 0xE7, 0xC1, 0xC7, 0x8F, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x10, 0x07, 0x00, 0x70, 0x0F, 0x03, 0xC0, 0x0F, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x0E, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0x9E, 0x00, 0x07, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1E, 0x03, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0,
  0x1E, 0x1E, 0x00, 0xE0, 0xF0, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xFC, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00,
  0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38,
  0x03, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x0F, 0x00, 0xF1, 0xE0,
  0x07, 0x1C, 0x00, 0x63, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x18, 0xF0, 0x01, 0xCF, 0x00, 0x3C,
  0x78, 0x07, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1E, 0x07, 0xE0,
  0xF0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x1E,
  0x00, 0x38, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x0F,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0xF8, 0x38, 0x1F, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x0F, 0x00, 0xF1, 0xE0,
  0x0F, 0x3C, 0x00, 0x63, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x83, 0xFE, 0x70, 0x3F, 0xEF, 0x03, 0xFE, 0xF0, 0x01, 0xCF,
  0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38,
  0x78, 0x03, 0x87, 0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1E,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0,
  0x0F, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x80, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x3C,
  0x3E, 0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3C,
  0x01, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x3D, 0xF0, 0x00, 0x77, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x3E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x03, 0xF0, 0xEE, 0x07, 0xC1, 0xDC, 0x1F, 0x83, 0xB8, 0x77,
  0x07, 0x70, 0xEE, 0x0E, 0xE3, 0x9C, 0x39, 0xC7, 0x70, 0x71, 0xDC, 0xE0,
  0xE3, 0xB1, 0xC1, 0xC7, 0xE3, 0x83, 0x8F, 0x87, 0x0E, 0x1F, 0x1E, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0xFC, 0x03,
  0x83, 0xF0, 0x0E, 0x0F, 0xC0, 0x38, 0x3F, 0x81, 0xE0, 0xEE, 0x07, 0x07,
  0xB8, 0x1C, 0x1C, 0xE0, 0x70, 0x73, 0xC1, 0xC1, 0xC7, 0x0F, 0x07, 0x1C,
  0x38, 0x3C, 0x70, 0xE0, 0xE1, 0xE3, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x78,
  0x38, 0x3D, 0xC0, 0xE0, 0x77, 0x07, 0x81, 0xDC, 0x1C, 0x07, 0x70, 0x70,
  0x1F, 0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xE0, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F,
  0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF8, 0x0F, 0x07, 0xC3, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1E, 0x01, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0,
  0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x07, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE1, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF8, 0x0F, 0x07, 0xC3, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x03,
  0xC1, 0xC0, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xC3, 0xC0, 0x0E, 0x07, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01,
  0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00,
  0x3C, 0x7E, 0x07, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0x0F,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x70,
  0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x03, 0x83,
  0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x78, 0x78,
  0x70, 0xF8, 0x70, 0xF0, 0xF8, 0x70, 0xF0, 0xF8, 0x70, 0xF1, 0xF8, 0xE0,
  0xF1, 0xB8, 0xE0, 0xF3, 0xB8, 0xE0, 0xE3, 0x39, 0xC0, 0xE7, 0x39, 0xC0,
  0xE6, 0x39, 0xC0, 0xEE, 0x1B, 0x80, 0xEC, 0x1B, 0x80, 0xFC, 0x1B, 0x80,
  0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x3C, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xF3,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xEF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0x9C, 0x00, 0x78, 0xF0, 0x07, 0x83, 0x80, 0x38, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0xDC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xB8, 0x00, 0xCE, 0x00,
  0x71, 0x80, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0x81, 0xC0, 0xE0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x19, 0xC0, 0x07,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE0,
  0xE0, 0x1C, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x1C,
  0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x1F, 0x1F, 0x0E, 0xF1, 0xFF, 0x9F, 0xBF,
  0xE3, 0xF1, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF1, 0xF8,
  0x0F, 0x7F, 0xC0, 0xEF, 0xFE, 0x0F, 0xC1, 0xE0, 0xF8, 0x0F, 0x1F, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x3C,
  0x03, 0xC7, 0xC0, 0x78, 0x7E, 0x0F, 0x87, 0x7F, 0xF0, 0x77, 0xFE, 0x0F,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE1,
  0xE0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x0F, 0x83, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F,
  0x1C, 0x07, 0xFC, 0xE0, 0x7F, 0xF7, 0x07, 0xC1, 0xF8, 0x3C, 0x07, 0xC3,
  0xC0, 0x3C, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03,
  0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xB8,
  0x0F, 0xFB, 0xC0, 0x3F, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xFE, 0x07, 0x83, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0xCE, 0x00, 0x7B, 0xC0,
  0x0F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x18, 0x78, 0x07, 0x0F, 0x83,
  0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x70, 0x1F, 0xF3, 0x81,
  0xFF, 0xDC, 0x1F, 0x0E, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x70, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8,
  0x78, 0x0F, 0x81, 0xE0, 0xFC, 0x0F, 0xFE, 0xE0, 0x3F, 0xEF, 0x00, 0xFC,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x0E, 0x03,
  0xC1, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0xFC, 0x0F, 0x7F, 0xC1, 0xDF, 0xFC, 0x3F,
  0x07, 0x87, 0xC0, 0x71, 0xF0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xE0,
  0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1E, 0x38, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x80, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x0E,
  0x01, 0xE0, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xE0, 0xF0, 0x1E, 0x1E, 0x01,
  0xC3, 0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xE7, 0x00, 0x38, 0x78, 0x03, 0x83, 0x80, 0x78, 0x3C,
  0x07, 0x81, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00,
  0x78, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x78, 0x78, 0x33, 0xE7, 0xF1, 0xDF, 0xFF,
  0xC7, 0xCF, 0xCF, 0x1E, 0x1E, 0x1C, 0x78, 0x70, 0x71, 0xC1, 0xC1, 0xC7,
  0x0F, 0x0E, 0x3C, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x8E, 0x0E,
  0x0E, 0x38, 0x38, 0x79, 0xE1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C,
  0x70, 0x70, 0x71, 0xC1, 0xC3, 0xCF, 0x0F, 0x0E, 0x38, 0x38, 0x38, 0xE0,
  0xE0, 0xE0, 0x0E, 0x1F, 0x81, 0xCF, 0xF8, 0x3B, 0xFF, 0x87, 0xE0, 0xF0,
  0xF8, 0x0E, 0x3E, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x03, 0xC7, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0x83, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0xCE, 0x00, 0x7B, 0xC0, 0x0F, 0x70,
  0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x0F, 0x07, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0x0F, 0xC0, 0x39, 0xFF, 0x01,
  0xDF, 0xFC, 0x0F, 0xC1, 0xE0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x3C,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0xC0, 0x3C,
  0x3E, 0x03, 0xC1, 0xF8, 0x3E, 0x0E, 0xFF, 0xE0, 0x77, 0xFE, 0x03, 0x8F,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0xE0, 0xFF, 0x9C, 0x3F, 0xFB, 0x8F, 0x83, 0xF1, 0xE0, 0x3E, 0x78,
  0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x79, 0xC0,
  0x0F, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x7C, 0xF0, 0x1F, 0x1F, 0x06, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7, 0x81, 0xF8,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x0F, 0xC7, 0x8F,
  0xF1, 0xEF, 0xFC, 0x7B, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3C, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x39, 0x80, 0x1E, 0xE0, 0x07, 0x3E, 0x07,
  0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x02, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0x1E, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0E, 0x3C,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x78, 0xF0,
  0x1F, 0x0F, 0x07, 0xE1, 0xFF, 0xDC, 0x3F, 0xF3, 0x81, 0xF8, 0xF0, 0xF0,
  0x00, 0xF7, 0x00, 0x0F, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7,
  0x80, 0x38, 0x38, 0x07, 0x83, 0x80, 0x70, 0x38, 0x0F, 0x03, 0xC1, 0xE0,
  0x3C, 0x1C, 0x03, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70,
  0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xCE, 0x0F, 0x07, 0x38,
  0x3C, 0x1C, 0xE1, 0xF0, 0xE3, 0x86, 0xC3, 0x8E, 0x3B, 0x9E, 0x38, 0xCE,
  0x70, 0xE7, 0x39, 0xC3, 0x98, 0xE7, 0x0E, 0xE3, 0xB8, 0x3B, 0x06, 0xE0,
  0xFC, 0x1B, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x39, 0xE0, 0x00, 0x77,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0x83, 0x80,
  0x0E, 0x07, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0E, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x07, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x06, 0x7F, 0xFF, 0xEC, 0x0F, 0xFE,
  0x00, 0x1F, 0x80,
};

const GFXglyph LiberationMono_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 8, 25, 23, 8, -25 },
  { 26, 14, 12, 23, 7, -28 },
  { 47, 22, 25, 23, 1, -25 },
  { 116, 22, 31, 23, 1, -28 },
  { 202, 25, 25, 23, -1, -25 },
  { 281, 21, 25, 23, 0, -25 },
  { 347, 6, 12, 23, 11, -28 },
  { 356, 14, 36, 23, 6, -28 },
  { 419, 14, 36, 23, 3, -28 },
  { 482, 13, 14, 23, 7, -28 },
  { 505, 19, 19, 23, 2, -22 },
  { 551, 10, 12, 23, 2, -6 },
  { 566, 11, 3, 23, 6, -11 },
  { 571, 6, 6, 23, 7, -6 },
  { 576, 24, 28, 23, 0, -28 },
  { 660, 20, 25, 23, 2, -25 },
  { 723, 19, 25, 23, 1, -25 },
  { 783, 21, 25, 23, 1, -25 },
  { 849, 20, 25, 23, 2, -25 },
  { 912, 20, 25, 23, 1, -25 },
  { 975, 20, 25, 23, 2, -25 },
  { 1038, 19, 25, 23, 3, -25 },
  { 1098, 18, 25, 23, 5, -25 },
  { 1155, 20, 25, 23, 2, -25 },
  { 1218, 19, 25, 23, 2, -25 },
  { 1278, 9, 21, 23, 7, -21 },
  { 1302, 13, 27, 23, 3, -21 },
  { 1346, 19, 19, 23, 2, -22 },
  { 1392, 19, 13, 23, 2, -19 },
  { 1423, 19, 19, 23, 2, -22 },
  { 1469, 19, 25, 23, 3, -25 },
  { 1529, 23, 33, 23, 0, -28 },
  { 1624, 23, 25, 23, -2, -25 },
  { 1696, 21, 25, 23, 1, -25 },
  { 1762, 20, 25, 23, 2, -25 },
  { 1825, 21, 25, 23, 1, -25 },
  { 1891, 22, 25, 23, 1, -25 },
  { 1960, 21, 25, 23, 2, -25 },
  { 2026, 20, 25, 23, 2, -25 },
  { 2089, 22, 25, 23, 1, -25 },
  { 2158, 20, 25, 23, 2, -25 },
  { 2221, 18, 25, 23, 3, -25 },
  { 2278, 23, 25, 23, 1, -25 },
  { 2350, 17, 25, 23, 2, -25 },
  { 2404, 23, 25, 23, 0, -25 },
  { 2476, 22, 25, 23, 1, -25 },
  { 2545, 20, 25, 23, 2, -25 },
  { 2608, 21, 25, 23, 1, -25 },
  { 2674, 20, 33, 23, 2, -25 },
  { 2757, 22, 25, 23, 1, -25 },
  { 2826, 21, 25, 23, 1, -25 },
  { 2892, 20, 25, 23, 4, -25 },
  { 2955, 21, 25, 23, 2, -25 },
  { 3021, 23, 25, 23, 3, -25 },
  { 3093, 24, 25, 23, 2, -25 },
  { 3168, 25, 25, 23, -1, -25 },
  { 3247, 21, 25, 23, 4, -25 },
  { 3313, 24, 25, 23, -1, -25 },
  { 3388, 17, 36, 23, 4, -28 },
  { 3465, 13, 28, 23, 6, -28 },
  { 3511, 17, 36, 23, 2, -28 },
  { 3588, 18, 17, 23, 2, -25 },
  { 3627, 23, 2, 23, -3, 2 },
  { 3633, 7, 5, 23, 11, -27 },
  { 3638, 19, 21, 23, 1, -21 },
  { 3688, 20, 28, 23, 1, -28 },
  { 3758, 19, 21, 23, 2, -21 },
  { 3808, 21, 28, 23, 2, -28 },
  { 3882, 19, 21, 23, 2, -21 },
  { 3932, 20, 28, 23, 4, -28 },
  { 4002, 21, 29, 23, 1, -21 },
  { 4079, 19, 28, 23, 1, -28 },
  { 4146, 18, 28, 23, 1, -28 },
  { 4209, 20, 36, 23, -1, -28 },
  { 4299, 20, 28, 23, 2, -28 },
  { 4369, 18, 28, 23, 1, -28 },
  { 4432, 22, 21, 23, 0, -21 },
  { 4490, 19, 21, 23, 1, -21 },
  { 4540, 19, 21, 23, 2, -21 },
  { 4590, 21, 29, 23, 0, -21 },
  { 4667, 19, 29, 23, 2, -21 },
  { 4736, 18, 21, 23, 3, -21 },
  { 4784, 18, 21, 23, 2, -21 },
  { 4832, 15, 26, 23, 5, -26 },
  { 4881, 19, 21, 23, 2, -21 },
  { 4931, 20, 21, 23, 3, -21 },
  { 4984, 22, 21, 23, 2, -21 },
  { 5042, 23, 21, 23, 0, -21 },
  { 5103, 23, 29, 23, 0, -21 },
  { 5187, 20, 21, 23, 1, -21 },
  { 5240, 19, 36, 23, 4, -28 },
  { 5326, 3, 36, 23, 10, -28 },
  { 5340, 19, 36, 23, 0, -28 },
  { 5426, 20, 5, 23, 2, -15 },
};

const GFXfont LiberationMono_Italic38pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic38pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic38pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _LIBERATIONMONO_ITALIC38PT7B_H_
