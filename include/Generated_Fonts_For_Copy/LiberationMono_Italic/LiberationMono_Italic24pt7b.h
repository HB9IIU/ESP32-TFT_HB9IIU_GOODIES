#ifndef _LIBERATIONMONO_ITALIC24PT7B_H_
#define _LIBERATIONMONO_ITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x23, 0x18, 0xC0, 0x03, 0x18, 0x71,
  0xB9, 0xD8, 0xEC, 0x66, 0x33, 0x1B, 0x08, 0x01, 0x04, 0x02, 0x10, 0x0C,
  0x20, 0x10, 0xC0, 0x61, 0x07, 0xFF, 0x81, 0x08, 0x04, 0x10, 0x08, 0x60,
  0x30, 0x83, 0xFF, 0xE1, 0x84, 0x02, 0x08, 0x04, 0x30, 0x18, 0x40, 0x21,
  0x80, 0x00, 0x40, 0x03, 0x00, 0x3F, 0x03, 0xFF, 0x1C, 0x9C, 0x62, 0x31,
  0x98, 0x06, 0x60, 0x1F, 0xC0, 0x1F, 0xC0, 0x17, 0x80, 0xC6, 0x03, 0x1B,
  0x8C, 0x6E, 0x21, 0x9C, 0x9C, 0x7F, 0xE0, 0x7F, 0x00, 0x60, 0x01, 0x80,
  0x1E, 0x06, 0x66, 0x19, 0x8C, 0x63, 0x18, 0x86, 0x32, 0x0C, 0x4C, 0x19,
  0xB0, 0x1E, 0xC0, 0x03, 0x78, 0x0D, 0x98, 0x32, 0x30, 0x4C, 0x61, 0x18,
  0xC6, 0x31, 0x18, 0x66, 0x60, 0x78, 0x01, 0xE0, 0x3F, 0x83, 0x8C, 0x18,
  0x60, 0xC2, 0x06, 0xE0, 0x3C, 0x03, 0xC3, 0x36, 0x1B, 0x39, 0xB0, 0xCD,
  0x87, 0xCC, 0x1C, 0x70, 0xF1, 0xFD, 0xE7, 0xC7, 0x76, 0x66, 0xCC, 0xC0,
  0x03, 0x03, 0x03, 0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01,
  0x80, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06,
  0x07, 0x00, 0x0C, 0x06, 0x1A, 0x6F, 0xF1, 0xC1, 0xE1, 0x98, 0x88, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x1C, 0x38, 0xE1, 0x87, 0x0C, 0x10, 0x60,
  0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0x0C, 0x70, 0x63, 0x03, 0xB8, 0x1D, 0x9C, 0xCC,
  0xE6, 0x67, 0x33, 0x01, 0xB8, 0x1D, 0xC0, 0xC6, 0x0E, 0x38, 0xE1, 0xFE,
  0x07, 0xE0, 0x00, 0xC0, 0x38, 0x1E, 0x1E, 0xC3, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x3F, 0xFF, 0xFF,
  0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x07, 0x18, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xE0, 0xFF, 0x86, 0x0C, 0x60, 0x70, 0x03,
  0x00, 0x18, 0x03, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0x00, 0x1D, 0x80, 0xEE,
  0x06, 0x70, 0x71, 0xFF, 0x07, 0xE0, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x36,
  0x02, 0x60, 0x66, 0x0C, 0xE1, 0x8C, 0x30, 0xC6, 0x0C, 0xC0, 0xCF, 0xFF,
  0xFF, 0xF0, 0x18, 0x01, 0x80, 0x18, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x70,
  0x03, 0x00, 0x1B, 0xE0, 0xFF, 0x8E, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x1D,
  0x80, 0xCC, 0x0E, 0x70, 0xE1, 0xFE, 0x07, 0xE0, 0x07, 0xC1, 0xFE, 0x38,
  0x73, 0x00, 0x60, 0x06, 0xF8, 0xDF, 0xCF, 0x0E, 0xE0, 0xEC, 0x06, 0xC0,
  0xEC, 0x0C, 0xC0, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x7F, 0xFF, 0xFC, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0C, 0x70,
  0x73, 0x03, 0x18, 0x18, 0xE1, 0x83, 0xF8, 0x1F, 0xC3, 0x83, 0x18, 0x1D,
  0x80, 0xCC, 0x06, 0x70, 0x71, 0xFF, 0x07, 0xE0, 0x07, 0xC0, 0xFF, 0x1C,
  0x73, 0x03, 0x30, 0x37, 0x03, 0x70, 0x33, 0x0F, 0x3F, 0xB1, 0xF7, 0x00,
  0x60, 0x06, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xE0, 0x39, 0xCC, 0xE0, 0x00,
  0x00, 0x07, 0x39, 0xCC, 0x00, 0x07, 0x07, 0x06, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x1C, 0x38, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x00, 0x10,
  0x0F, 0x03, 0xE1, 0xF0, 0xFC, 0x0E, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0x00, 0x70, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x0C, 0x00, 0x0F, 0xC3,
  0xFE, 0x70, 0x76, 0x07, 0xC0, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x01, 0xF0,
  0x06, 0x30, 0x10, 0x30, 0x40, 0x21, 0x1D, 0xE6, 0x6E, 0xC9, 0x8D, 0xB6,
  0x13, 0x6C, 0x64, 0x90, 0xC9, 0x61, 0x16, 0xC6, 0x6D, 0x8C, 0x9B, 0x33,
  0x36, 0xE4, 0x67, 0x70, 0xC0, 0x00, 0xC0, 0xC1, 0xC3, 0x00, 0xF8, 0x00,
  0x00, 0x60, 0x03, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63,
  0x81, 0x86, 0x0C, 0x18, 0x70, 0x61, 0xFF, 0x8F, 0xFE, 0x30, 0x1D, 0xC0,
  0x76, 0x00, 0xF0, 0x03, 0x1F, 0xE1, 0xFF, 0x8E, 0x0E, 0x60, 0x73, 0x03,
  0x98, 0x19, 0xC1, 0x8F, 0xF8, 0x7F, 0xE3, 0x03, 0x98, 0x0C, 0xC0, 0x6E,
  0x07, 0x60, 0x73, 0xFF, 0x1F, 0xF0, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x33, 0x01, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x46, 0x06, 0x38, 0x70, 0xFF, 0x03, 0xE0, 0x1F, 0xC1, 0xFF, 0x0E,
  0x1C, 0x60, 0x73, 0x03, 0x98, 0x1D, 0xC0, 0xEE, 0x07, 0x60, 0x33, 0x01,
  0x98, 0x1C, 0xC0, 0xCE, 0x0E, 0x60, 0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xF8,
  0xFF, 0xE3, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1F, 0xF8,
  0x7F, 0xE1, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE1, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x73, 0x01, 0x38, 0x01, 0x80, 0x0C, 0x3E, 0x63, 0xF7, 0x01, 0xB8, 0x1D,
  0xC0, 0xC6, 0x06, 0x38, 0x70, 0xFF, 0x03, 0xE0, 0x18, 0x19, 0xC0, 0xCE,
  0x06, 0x60, 0x73, 0x03, 0x18, 0x19, 0xC0, 0xCF, 0xFE, 0x7F, 0xF3, 0x03,
  0x98, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x03, 0x98, 0x18, 0x1F, 0xF8,
  0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0x1F, 0xF8,
  0x07, 0xE0, 0xFC, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x60, 0xCC, 0x39, 0xC6, 0x3F, 0x83, 0xE0, 0x18, 0x1C,
  0xE0, 0xE3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xCC, 0x07, 0x60, 0x1F, 0xC0,
  0x7F, 0x01, 0xCE, 0x06, 0x38, 0x18, 0x70, 0xE0, 0xC3, 0x03, 0x8C, 0x06,
  0x30, 0x1C, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0x1C, 0x0E,
  0x38, 0x38, 0x78, 0x70, 0xF1, 0xE3, 0x62, 0xC6, 0xCD, 0x8D, 0x92, 0x19,
  0x6C, 0x32, 0x98, 0x47, 0x31, 0x8C, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06,
  0x10, 0x0C, 0x60, 0x18, 0x18, 0x19, 0xE0, 0xCF, 0x06, 0x78, 0x33, 0x63,
  0x1B, 0x19, 0x98, 0xCC, 0xC6, 0x63, 0x33, 0x1B, 0x98, 0xD8, 0xC6, 0xCC,
  0x1E, 0x60, 0xF3, 0x07, 0x98, 0x38, 0x07, 0xE0, 0x7F, 0x87, 0x1C, 0x70,
  0x73, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x07, 0xE0, 0x37, 0x01, 0xB8, 0x1D,
  0xC0, 0xCE, 0x0E, 0x38, 0xE1, 0xFE, 0x03, 0xC0, 0x1F, 0xE1, 0xFF, 0x8E,
  0x0E, 0x60, 0x33, 0x01, 0x98, 0x0D, 0xC0, 0xCE, 0x0E, 0x7F, 0xE3, 0xFC,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0x1C, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x07, 0xE0,
  0x37, 0x01, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xE0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xE1, 0xFF,
  0xCE, 0x0E, 0x60, 0x33, 0x01, 0x98, 0x1D, 0xC1, 0xCF, 0xFC, 0x7F, 0x83,
  0x1C, 0x18, 0x60, 0xC3, 0x0E, 0x1C, 0x60, 0x63, 0x03, 0x98, 0x0C, 0x03,
  0xF0, 0x3F, 0xE1, 0xC1, 0xC6, 0x03, 0x18, 0x00, 0x60, 0x01, 0xE0, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xB8, 0x06, 0x60, 0x39, 0xC1, 0xC7,
  0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0x39, 0xC0, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81, 0xCE, 0x06,
  0x38, 0x18, 0xE0, 0xE3, 0x87, 0x07, 0xF8, 0x0F, 0xC0, 0xC0, 0x1F, 0x80,
  0x6E, 0x03, 0x98, 0x0C, 0x60, 0x71, 0x81, 0x86, 0x0C, 0x1C, 0x30, 0x71,
  0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xD8, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x63,
  0x19, 0xC6, 0x33, 0x8C, 0x6D, 0x31, 0x9A, 0x63, 0x26, 0xC6, 0xCF, 0x0D,
  0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0x0C, 0x03, 0x0E, 0x06, 0x06,
  0x0C, 0x07, 0x18, 0x03, 0x38, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xE0, 0x06, 0x60, 0x0C, 0x70, 0x1C, 0x30, 0x38, 0x38, 0x70,
  0x18, 0x60, 0x1C, 0xE0, 0x19, 0x80, 0xE7, 0x07, 0x0C, 0x18, 0x38, 0xC0,
  0x66, 0x01, 0xB0, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x7F,
  0xF8, 0x0F, 0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xFC, 0x3F, 0x00, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0x0F, 0xE1, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0x80, 0x3C, 0x06,
  0xC0, 0x4C, 0x0C, 0xC0, 0x84, 0x18, 0x63, 0x06, 0x30, 0x66, 0x06, 0x40,
  0x20, 0xFF, 0xFE, 0xE6, 0x30, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x06, 0x00,
  0x61, 0xFE, 0x7F, 0xE7, 0x0C, 0xC0, 0xCC, 0x1C, 0xC2, 0xCF, 0xEF, 0x78,
  0xE0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x33, 0xE3, 0x7F, 0x3C, 0x73,
  0x83, 0x30, 0x37, 0x03, 0x60, 0x36, 0x07, 0x60, 0x66, 0x0E, 0xF1, 0xCD,
  0xFC, 0xCF, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x06, 0x60, 0xC7, 0xF8, 0x1F, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0xFB, 0x8F, 0xF8, 0xE1, 0xC6, 0x0E,
  0x60, 0x73, 0x03, 0x98, 0x19, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x8F,
  0xF8, 0x3C, 0xC0, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x60, 0x37, 0xFF,
  0x7F, 0xFE, 0x00, 0xE0, 0x0E, 0x06, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0xFF, 0x1C, 0x01, 0x80, 0xFF, 0xEF, 0xFE, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x00, 0x0F, 0xB0, 0xFF, 0x8E, 0x3C, 0x60, 0xE6, 0x07, 0x30, 0x39, 0x81,
  0x8C, 0x0C, 0xE0, 0x67, 0x07, 0x18, 0x78, 0xFF, 0x83, 0xCC, 0x00, 0x63,
  0x07, 0x1C, 0x70, 0x7F, 0x01, 0xF0, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x3B, 0xE3, 0x7F, 0x3C, 0x73, 0x03, 0x30, 0x37, 0x07, 0x60, 0x66,
  0x06, 0x60, 0x66, 0x06, 0xE0, 0xEC, 0x0C, 0xC0, 0xC0, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x0F, 0xF0, 0x7E, 0x00, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x73, 0x0C, 0x23, 0x86, 0x70, 0x6C,
  0x07, 0xC0, 0x7E, 0x06, 0x60, 0xC7, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC1,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x07,
  0xFF, 0xFF, 0xF0, 0x37, 0x38, 0xFF, 0xF3, 0x9C, 0xCC, 0x63, 0x31, 0x8D,
  0x8C, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x19, 0x8C, 0x6C, 0x63, 0x31, 0x8C,
  0xC6, 0x30, 0x33, 0xE3, 0x7F, 0x3C, 0x73, 0x03, 0x30, 0x37, 0x07, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0xE0, 0xEC, 0x0C, 0xC0, 0xC0, 0x07, 0xC1,
  0xFE, 0x38, 0x73, 0x03, 0x60, 0x36, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x6E,
  0x0E, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x19, 0xF0, 0xDF, 0xC7, 0x8E, 0x38,
  0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x31, 0x83, 0x9E, 0x38,
  0xDF, 0xC6, 0x78, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x0F, 0xB0, 0xFF, 0x8E, 0x1C, 0x60, 0xE6, 0x07, 0x30, 0x39, 0x81, 0x9C,
  0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x78, 0xFF, 0x83, 0xCC, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x31, 0xE6, 0xFC, 0xF8, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x00,
  0x07, 0xC1, 0xFE, 0x38, 0x33, 0x00, 0x30, 0x03, 0xE0, 0x0F, 0xC0, 0x1E,
  0x00, 0x6C, 0x06, 0xE0, 0xC7, 0xFC, 0x3F, 0x00, 0x08, 0x06, 0x01, 0x83,
  0xFF, 0xFF, 0x8C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x07, 0xF1, 0xF8, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6C,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC3, 0xCF, 0xF8, 0x79, 0x80,
  0xE0, 0x3F, 0x01, 0x98, 0x18, 0xC1, 0xC6, 0x0C, 0x30, 0xE1, 0xC6, 0x06,
  0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x01, 0x80, 0x00, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xB0, 0x06, 0xC7, 0x1B, 0x14, 0xCC, 0xD3, 0x32, 0x4C,
  0xD9, 0x63, 0x47, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC0, 0x18, 0x1C, 0x70,
  0x60, 0xC3, 0x03, 0x98, 0x06, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0D,
  0xC0, 0x63, 0x03, 0x0E, 0x1C, 0x18, 0xE0, 0x70, 0x30, 0x0E, 0x70, 0x18,
  0x60, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x03, 0x18, 0x06, 0x60, 0x0C,
  0xC0, 0x1B, 0x00, 0x36, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00,
  0xFF, 0xE7, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x70,
  0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0xFC, 0x0F, 0x80, 0x3C, 0x0B, 0xF8, 0xD1, 0xFD,
  0x03, 0xC0,
};

const GFXglyph LiberationMono_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 16, 14, 5, -16 },
  { 11, 9, 7, 14, 4, -17 },
  { 19, 15, 16, 14, 0, -16 },
  { 49, 14, 20, 14, 0, -18 },
  { 84, 15, 16, 14, 0, -16 },
  { 114, 13, 16, 14, 0, -16 },
  { 140, 4, 7, 14, 7, -17 },
  { 144, 9, 22, 14, 4, -17 },
  { 169, 9, 22, 14, 2, -17 },
  { 194, 9, 8, 14, 4, -17 },
  { 203, 12, 12, 14, 1, -14 },
  { 221, 7, 8, 14, 1, -4 },
  { 228, 7, 2, 14, 4, -7 },
  { 230, 3, 4, 14, 5, -4 },
  { 232, 15, 17, 14, 0, -17 },
  { 264, 13, 16, 14, 1, -16 },
  { 290, 11, 16, 14, 1, -16 },
  { 312, 14, 16, 14, 0, -16 },
  { 340, 13, 16, 14, 1, -16 },
  { 366, 12, 16, 14, 1, -16 },
  { 390, 13, 16, 14, 1, -16 },
  { 416, 12, 16, 14, 2, -16 },
  { 440, 11, 16, 14, 3, -16 },
  { 462, 13, 16, 14, 1, -16 },
  { 488, 12, 16, 14, 1, -16 },
  { 512, 5, 13, 14, 5, -13 },
  { 521, 8, 17, 14, 2, -13 },
  { 538, 12, 12, 14, 1, -14 },
  { 556, 12, 8, 14, 1, -12 },
  { 568, 12, 12, 14, 1, -14 },
  { 586, 12, 16, 14, 2, -16 },
  { 610, 15, 20, 14, 0, -17 },
  { 648, 14, 16, 14, -1, -16 },
  { 676, 13, 16, 14, 1, -16 },
  { 702, 13, 16, 14, 1, -16 },
  { 728, 13, 16, 14, 1, -16 },
  { 754, 14, 16, 14, 1, -16 },
  { 782, 14, 16, 14, 1, -16 },
  { 810, 13, 16, 14, 1, -16 },
  { 836, 13, 16, 14, 1, -16 },
  { 862, 13, 16, 14, 1, -16 },
  { 888, 11, 16, 14, 2, -16 },
  { 910, 14, 16, 14, 1, -16 },
  { 938, 10, 16, 14, 2, -16 },
  { 958, 15, 16, 14, 0, -16 },
  { 988, 13, 16, 14, 1, -16 },
  { 1014, 13, 16, 14, 1, -16 },
  { 1040, 13, 16, 14, 1, -16 },
  { 1066, 13, 21, 14, 1, -16 },
  { 1101, 13, 16, 14, 1, -16 },
  { 1127, 14, 16, 14, 0, -16 },
  { 1155, 13, 16, 14, 2, -16 },
  { 1181, 14, 16, 14, 1, -16 },
  { 1209, 14, 16, 14, 2, -16 },
  { 1237, 15, 16, 14, 1, -16 },
  { 1267, 16, 16, 14, -1, -16 },
  { 1299, 14, 16, 14, 2, -16 },
  { 1327, 15, 16, 14, 0, -16 },
  { 1357, 10, 22, 14, 3, -17 },
  { 1385, 9, 17, 14, 3, -17 },
  { 1405, 11, 22, 14, 1, -17 },
  { 1436, 12, 11, 14, 1, -16 },
  { 1453, 15, 1, 14, -2, 1 },
  { 1455, 4, 3, 14, 7, -17 },
  { 1457, 12, 13, 14, 1, -13 },
  { 1477, 12, 17, 14, 1, -17 },
  { 1503, 12, 13, 14, 1, -13 },
  { 1523, 13, 17, 14, 1, -17 },
  { 1551, 12, 13, 14, 1, -13 },
  { 1571, 12, 17, 14, 3, -17 },
  { 1597, 13, 18, 14, 1, -13 },
  { 1627, 12, 17, 14, 1, -17 },
  { 1653, 12, 17, 14, 0, -17 },
  { 1679, 13, 22, 14, -1, -17 },
  { 1715, 12, 17, 14, 2, -17 },
  { 1741, 12, 17, 14, 0, -17 },
  { 1767, 14, 13, 14, 0, -13 },
  { 1790, 12, 13, 14, 1, -13 },
  { 1810, 12, 13, 14, 1, -13 },
  { 1830, 13, 18, 14, 0, -13 },
  { 1860, 13, 18, 14, 1, -13 },
  { 1890, 11, 13, 14, 2, -13 },
  { 1908, 12, 13, 14, 1, -13 },
  { 1928, 10, 16, 14, 3, -16 },
  { 1948, 12, 13, 14, 2, -13 },
  { 1968, 13, 13, 14, 2, -13 },
  { 1990, 14, 13, 14, 1, -13 },
  { 2013, 14, 13, 14, 0, -13 },
  { 2036, 15, 18, 14, 0, -13 },
  { 2070, 13, 13, 14, 0, -13 },
  { 2092, 13, 22, 14, 2, -17 },
  { 2128, 2, 22, 14, 6, -17 },
  { 2134, 12, 22, 14, 0, -17 },
  { 2167, 13, 4, 14, 1, -10 },
};

const GFXfont LiberationMono_Italic24pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic24pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic24pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _LIBERATIONMONO_ITALIC24PT7B_H_
