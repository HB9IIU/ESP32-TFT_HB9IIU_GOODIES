#ifndef _LIBERATIONMONO_ITALIC71PT7B_H_
#define _LIBERATIONMONO_ITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFE,
  0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8,
  0x78, 0xFF, 0xC0, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x0F, 0xE0, 0x3E, 0x07,
  0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x07,
  0xFC, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x00,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x30, 0x01, 0xF0,
  0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x78, 0x01, 0xF8,
  0x7F, 0x00, 0x3C, 0x00, 0xFC, 0x1F, 0x80, 0x1E, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0x80,
  0xFF, 0x00, 0xFF, 0xC3, 0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x83, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0,
  0x00, 0x3F, 0x87, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFF,
  0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x7D, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x06, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x01, 0xFF,
  0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x7F, 0x1F, 0x80, 0x0F,
  0x83, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x7E, 0x00, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0xF8, 0x3F, 0x00, 0x07, 0xF7, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0x03,
  0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x1F, 0xC3, 0xF8,
  0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x60, 0x3C, 0x03, 0x7C,
  0x1E, 0x0F, 0xBF, 0xCF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF1, 0xF0, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x07,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xEF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x01, 0xFE, 0x07, 0xF3, 0xF0, 0x1F, 0xE0, 0x7F, 0x3F,
  0x03, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F,
  0xC0, 0xFE, 0x7E, 0x07, 0xFC, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xC0,
  0x01, 0xFF, 0xFB, 0xF8, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x07, 0xFE, 0x0F,
  0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x01,
  0xF1, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x80, 0x01, 0xFB,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x7E,
  0x0F, 0xFF, 0x80, 0x1F, 0x87, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFF, 0xC0,
  0x7E, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xC0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0x80,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xFC,
  0x79, 0xE0, 0x0F, 0x00, 0xFF, 0xC7, 0x9E, 0x01, 0xF0, 0x3F, 0xFE, 0x79,
  0xF0, 0x1E, 0x07, 0xE1, 0xEF, 0x1F, 0x03, 0xE0, 0xFC, 0x0E, 0xF1, 0xE0,
  0x3C, 0x0F, 0x80, 0x7F, 0x1E, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xE0, 0x78,
  0x3E, 0x00, 0x7E, 0x1E, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0xF8, 0x7C,
  0x00, 0x7C, 0x1E, 0x0F, 0x07, 0x80, 0x0F, 0xC1, 0xE1, 0xF0, 0xF8, 0x00,
  0xF8, 0x3E, 0x1F, 0x0F, 0x00, 0x0F, 0x83, 0xC1, 0xE1, 0xF0, 0x00, 0xF0,
  0x3C, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xC3, 0xE1, 0xE0, 0x01, 0xF0, 0x7C,
  0x3C, 0x3E, 0x00, 0x3E, 0x07, 0x83, 0xC3, 0xE0, 0x03, 0xE0, 0x78, 0x3C,
  0x3C, 0x00, 0x3C, 0x07, 0x87, 0xC7, 0xC0, 0x07, 0xC0, 0xF8, 0x7C, 0x7C,
  0x00, 0x7C, 0x0F, 0x07, 0x87, 0xC0, 0x0F, 0x80, 0xF0, 0x78, 0x7C, 0x00,
  0xF8, 0x1E, 0x07, 0x87, 0x80, 0x1F, 0x81, 0xE0, 0x78, 0x78, 0x01, 0xF0,
  0x3C, 0x0F, 0x87, 0x80, 0x3F, 0x03, 0xC0, 0xF8, 0x78, 0x07, 0xF0, 0x78,
  0x0F, 0x87, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x7C, 0x1E, 0xE0, 0xF0, 0x0F,
  0x87, 0xE3, 0xCF, 0x3E, 0x00, 0xF8, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0x83,
  0xFF, 0x0F, 0xF8, 0x00, 0x78, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0x80, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0x80, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0x02,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x00,
  0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xFF,
  0x8F, 0xE0, 0x03, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xC7, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0x7C, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x80,
  0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xCF, 0xC0,
  0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x00, 0x7C,
  0x3E, 0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x03, 0xF0, 0xFC,
  0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x9F, 0x07, 0xE0, 0x0F, 0x83, 0xF3, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xDF, 0x07, 0xE0,
  0x0F, 0xC0, 0xFF, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xFE, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xC0, 0x7C, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x00,
  0x7E, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x01,
  0xFB, 0xF0, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x03, 0xF1, 0xF0,
  0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x0F, 0x8F,
  0xC0, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x3F, 0x00, 0x07,
  0xEF, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0x80,
  0x7E, 0x00, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xF0,
  0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x00, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xF0,
  0x1F, 0x80, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x07, 0xE0, 0x7D, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x0F, 0xC0, 0xF9, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF1, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x00, 0xFC, 0x3E,
  0x1F, 0x0F, 0x80, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x1F,
  0x1F, 0x80, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x0F, 0x1F,
  0x00, 0x0F, 0xDF, 0x00, 0xF3, 0xF0, 0x00, 0xFD, 0xF0, 0x0F, 0xBE, 0x00,
  0x0F, 0x9E, 0x00, 0xFB, 0xE0, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0x0F,
  0xBC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0x0F,
  0xC0, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x1F, 0xFC,
  0x3F, 0x80, 0x1F, 0x7F, 0x0F, 0xF8, 0x1F, 0x9F, 0xC3, 0xFF, 0xFF, 0xC7,
  0xF1, 0x7F, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0xF0,
  0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x01, 0xF8, 0xFF,
  0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F,
  0x7E, 0x07, 0xFE, 0x03, 0xF7, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0xE0, 0x0F, 0xC7,
  0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x03,
  0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xF1, 0xFC, 0x00, 0x7F, 0xFF, 0xF3,
  0xF8, 0x01, 0xFF, 0xFF, 0xF7, 0xE0, 0x03, 0xFE, 0x07, 0xEF, 0xC0, 0x0F,
  0xF0, 0x03, 0xDF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0xFC,
  0x00, 0x3F, 0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0xC3, 0xF0, 0x00, 0x3F,
  0xFF, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x07, 0xFF,
  0xF8, 0x7E, 0x00, 0x7F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xFF, 0x3F, 0x00,
  0x7F, 0xC0, 0xFD, 0xF8, 0x07, 0xF8, 0x01, 0xEF, 0xC0, 0x7F, 0x80, 0x07,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x7E, 0x01, 0xFF, 0x01, 0xF3,
  0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xF1, 0xF8, 0x00, 0xFF,
  0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x7F, 0xFC, 0x00,
  0x7E, 0x1F, 0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xEF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x7F, 0x81, 0xFF, 0x00, 0x7C,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3E, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0x7F, 0xF9,
  0xFF, 0xF8, 0x1F, 0xF8, 0xFD, 0xE1, 0xFC, 0x0F, 0xB0, 0x3F, 0xE0, 0x7E,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x07, 0xE1, 0xFF, 0xFE, 0x01, 0xF8, 0xFF,
  0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0x03, 0xF9, 0xFF,
  0xFF, 0x80, 0x07, 0xF7, 0xFF, 0xFF, 0x80, 0x0F, 0xDF, 0x81, 0xFF, 0x80,
  0x1F, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0xFF, 0xFF,
  0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0xFE, 0x7E,
  0x01, 0xFF, 0xFF, 0xF7, 0xE0, 0x1F, 0xF0, 0x3F, 0x7E, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0x80, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x7D, 0xF8, 0x07, 0xFF, 0xFF, 0x9F, 0x80,
  0x3F, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0xFF, 0x83,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x03, 0xF0, 0x0F, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0xF8, 0x1F, 0x9F,
  0xE0, 0x04, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3D, 0xF8, 0x1F, 0xF0, 0x1F, 0xBF,
  0x03, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFC,
  0x3F, 0x00, 0x3F, 0xFF, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xFE, 0x01, 0xF8, 0x1F, 0x80, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xDF, 0x01, 0xF8, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E,
  0x01, 0xF8, 0x3E, 0x3C, 0x0F, 0xC0, 0x3F, 0x07, 0xC7, 0x83, 0xF0, 0x07,
  0xE1, 0xF0, 0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x1F, 0x0F, 0xC0, 0x1F, 0x8F,
  0x83, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x0F,
  0x8F, 0xC0, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x3E, 0x7E,
  0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0x07, 0xCF, 0x00, 0x79, 0xF0, 0x00,
  0xFB, 0xE0, 0x0F, 0x7E, 0x00, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x03, 0xFF,
  0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0x3F, 0xFF, 0xF8, 0x00, 0x37, 0xFF, 0xFF, 0xF0, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 16, 47, 43, 14, -47 },
  { 95, 26, 22, 43, 13, -51 },
  { 167, 42, 47, 43, 1, -47 },
  { 414, 41, 58, 43, 1, -52 },
  { 712, 47, 49, 43, -1, -48 },
  { 1000, 38, 49, 43, 0, -48 },
  { 1233, 11, 22, 43, 21, -51 },
  { 1264, 26, 66, 43, 11, -51 },
  { 1479, 27, 66, 43, 5, -51 },
  { 1702, 25, 25, 43, 13, -51 },
  { 1781, 35, 35, 43, 4, -41 },
  { 1935, 19, 23, 43, 3, -10 },
  { 1990, 21, 6, 43, 11, -22 },
  { 2006, 10, 10, 43, 14, -10 },
  { 2019, 45, 52, 43, 0, -51 },
  { 2312, 36, 49, 43, 4, -48 },
  { 2533, 35, 47, 43, 2, -47 },
  { 2739, 39, 48, 43, 1, -48 },
  { 2973, 37, 49, 43, 3, -48 },
  { 3200, 36, 47, 43, 2, -47 },
  { 3412, 38, 48, 43, 3, -47 },
  { 3640, 35, 49, 43, 5, -48 },
  { 3855, 33, 47, 43, 10, -47 },
  { 4049, 37, 49, 43, 3, -48 },
  { 4276, 36, 49, 43, 4, -48 },
  { 4497, 15, 38, 43, 14, -38 },
  { 4569, 23, 51, 43, 6, -38 },
  { 4716, 35, 36, 43, 4, -41 },
  { 4874, 35, 23, 43, 4, -35 },
  { 4975, 35, 36, 43, 4, -41 },
  { 5133, 35, 48, 43, 6, -48 },
  { 5343, 44, 61, 43, 0, -51 },
  { 5679, 43, 47, 43, -4, -47 },
  { 5932, 39, 47, 43, 2, -47 },
  { 6162, 38, 49, 43, 4, -48 },
  { 6395, 39, 47, 43, 2, -47 },
  { 6625, 41, 47, 43, 2, -47 },
  { 6866, 40, 47, 43, 3, -47 },
  { 7101, 38, 49, 43, 4, -48 },
  { 7334, 40, 47, 43, 2, -47 },
  { 7569, 38, 47, 43, 3, -47 },
  { 7793, 35, 48, 43, 5, -47 },
  { 8003, 43, 47, 43, 2, -47 },
  { 8256, 31, 47, 43, 5, -47 },
  { 8439, 43, 47, 43, 1, -47 },
  { 8692, 40, 47, 43, 2, -47 },
  { 8927, 37, 49, 43, 4, -48 },
  { 9154, 40, 47, 43, 2, -47 },
  { 9389, 37, 62, 43, 4, -48 },
  { 9676, 40, 47, 43, 2, -47 },
  { 9911, 40, 49, 43, 1, -48 },
  { 10156, 38, 47, 43, 7, -47 },
  { 10380, 39, 48, 43, 4, -47 },
  { 10614, 42, 47, 43, 6, -47 },
  { 10861, 44, 47, 43, 4, -47 },
  { 11120, 47, 47, 43, -2, -47 },
  { 11397, 40, 47, 43, 7, -47 },
  { 11632, 45, 47, 43, -1, -47 },
  { 11897, 32, 66, 43, 8, -51 },
  { 12161, 25, 52, 43, 10, -51 },
  { 12324, 32, 66, 43, 3, -51 },
  { 12588, 33, 31, 43, 4, -47 },
  { 12716, 43, 3, 43, -5, 4 },
  { 12733, 13, 9, 43, 20, -51 },
  { 12748, 34, 40, 43, 3, -39 },
  { 12918, 36, 52, 43, 3, -51 },
  { 13152, 35, 40, 43, 4, -39 },
  { 13327, 39, 52, 43, 4, -51 },
  { 13581, 35, 40, 43, 4, -39 },
  { 13756, 37, 51, 43, 7, -51 },
  { 13992, 37, 54, 43, 3, -39 },
  { 14242, 35, 51, 43, 3, -51 },
  { 14466, 35, 51, 43, 1, -51 },
  { 14690, 37, 66, 43, -2, -51 },
  { 14996, 37, 51, 43, 5, -51 },
  { 15232, 35, 51, 43, 1, -51 },
  { 15456, 41, 39, 43, 0, -39 },
  { 15656, 35, 39, 43, 3, -39 },
  { 15827, 35, 40, 43, 4, -39 },
  { 16002, 39, 54, 43, 0, -39 },
  { 16266, 36, 54, 43, 4, -39 },
  { 16509, 33, 39, 43, 7, -39 },
  { 16670, 34, 40, 43, 4, -39 },
  { 16840, 28, 49, 43, 9, -48 },
  { 17012, 35, 39, 43, 5, -38 },
  { 17183, 38, 38, 43, 6, -38 },
  { 17364, 43, 38, 43, 3, -38 },
  { 17569, 42, 38, 43, 0, -38 },
  { 17769, 45, 53, 43, -1, -38 },
  { 18068, 38, 38, 43, 1, -38 },
  { 18249, 36, 66, 43, 7, -51 },
  { 18546, 6, 66, 43, 18, -51 },
  { 18596, 36, 66, 43, -1, -51 },
  { 18893, 36, 9, 43, 4, -28 },
};

const GFXfont LiberationMono_Italic71pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic71pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic71pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _LIBERATIONMONO_ITALIC71PT7B_H_
