#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/LiberationMono_Italic
// Headers: 67

#include "LiberationMono_Italic6pt7b.h"
#include "LiberationMono_Italic7pt7b.h"
#include "LiberationMono_Italic8pt7b.h"
#include "LiberationMono_Italic9pt7b.h"
#include "LiberationMono_Italic10pt7b.h"
#include "LiberationMono_Italic11pt7b.h"
#include "LiberationMono_Italic12pt7b.h"
#include "LiberationMono_Italic13pt7b.h"
#include "LiberationMono_Italic14pt7b.h"
#include "LiberationMono_Italic15pt7b.h"
#include "LiberationMono_Italic16pt7b.h"
#include "LiberationMono_Italic17pt7b.h"
#include "LiberationMono_Italic18pt7b.h"
#include "LiberationMono_Italic19pt7b.h"
#include "LiberationMono_Italic20pt7b.h"
#include "LiberationMono_Italic21pt7b.h"
#include "LiberationMono_Italic22pt7b.h"
#include "LiberationMono_Italic23pt7b.h"
#include "LiberationMono_Italic24pt7b.h"
#include "LiberationMono_Italic25pt7b.h"
#include "LiberationMono_Italic26pt7b.h"
#include "LiberationMono_Italic27pt7b.h"
#include "LiberationMono_Italic28pt7b.h"
#include "LiberationMono_Italic29pt7b.h"
#include "LiberationMono_Italic30pt7b.h"
#include "LiberationMono_Italic31pt7b.h"
#include "LiberationMono_Italic32pt7b.h"
#include "LiberationMono_Italic33pt7b.h"
#include "LiberationMono_Italic34pt7b.h"
#include "LiberationMono_Italic35pt7b.h"
#include "LiberationMono_Italic36pt7b.h"
#include "LiberationMono_Italic37pt7b.h"
#include "LiberationMono_Italic38pt7b.h"
#include "LiberationMono_Italic39pt7b.h"
#include "LiberationMono_Italic40pt7b.h"
#include "LiberationMono_Italic41pt7b.h"
#include "LiberationMono_Italic42pt7b.h"
#include "LiberationMono_Italic43pt7b.h"
#include "LiberationMono_Italic44pt7b.h"
#include "LiberationMono_Italic45pt7b.h"
#include "LiberationMono_Italic46pt7b.h"
#include "LiberationMono_Italic47pt7b.h"
#include "LiberationMono_Italic48pt7b.h"
#include "LiberationMono_Italic49pt7b.h"
#include "LiberationMono_Italic50pt7b.h"
#include "LiberationMono_Italic51pt7b.h"
#include "LiberationMono_Italic52pt7b.h"
#include "LiberationMono_Italic53pt7b.h"
#include "LiberationMono_Italic54pt7b.h"
#include "LiberationMono_Italic55pt7b.h"
#include "LiberationMono_Italic56pt7b.h"
#include "LiberationMono_Italic57pt7b.h"
#include "LiberationMono_Italic58pt7b.h"
#include "LiberationMono_Italic59pt7b.h"
#include "LiberationMono_Italic60pt7b.h"
#include "LiberationMono_Italic61pt7b.h"
#include "LiberationMono_Italic62pt7b.h"
#include "LiberationMono_Italic63pt7b.h"
#include "LiberationMono_Italic64pt7b.h"
#include "LiberationMono_Italic65pt7b.h"
#include "LiberationMono_Italic66pt7b.h"
#include "LiberationMono_Italic67pt7b.h"
#include "LiberationMono_Italic68pt7b.h"
#include "LiberationMono_Italic69pt7b.h"
#include "LiberationMono_Italic70pt7b.h"
#include "LiberationMono_Italic71pt7b.h"
#include "LiberationMono_Italic72pt7b.h"
