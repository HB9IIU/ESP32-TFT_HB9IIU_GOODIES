#ifndef _LIBERATIONMONO_ITALIC12PT7B_H_
#define _LIBERATIONMONO_ITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x82, 0x5A, 0xA5, 0x20, 0x12, 0x29, 0xF9, 0x22, 0x9F,
  0x92, 0x48, 0x08, 0x7D, 0xAA, 0x43, 0x82, 0xC4, 0xCA, 0x78, 0x40, 0x72,
  0x54, 0x94, 0x68, 0x1E, 0x2A, 0x52, 0x8C, 0x1C, 0x48, 0xA1, 0x85, 0x52,
  0xA2, 0x7E, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11,
  0x13, 0x24, 0x80, 0x2B, 0x76, 0x60, 0x20, 0x8F, 0xC8, 0x20, 0x22, 0x44,
  0xE0, 0x70, 0x02, 0x06, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x39,
  0x18, 0x69, 0x8E, 0x29, 0xBC, 0x09, 0xE0, 0x82, 0x08, 0x41, 0x3F, 0x1C,
  0x44, 0x08, 0x21, 0x84, 0x10, 0x7E, 0x39, 0x10, 0x8C, 0x08, 0x28, 0xBC,
  0x04, 0x18, 0x51, 0x24, 0xDF, 0x82, 0x04, 0x3E, 0x41, 0x83, 0xE0, 0x40,
  0x91, 0x3C, 0x39, 0x14, 0x2E, 0xCA, 0x28, 0x9C, 0xF8, 0x44, 0x44, 0x22,
  0x10, 0x39, 0x14, 0x9C, 0x8A, 0x28, 0xBC, 0x39, 0x38, 0x63, 0x78, 0x29,
  0xB8, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x44, 0x80, 0x0F, 0xC8, 0x3C,
  0x0C, 0xFC, 0x0F, 0xC0, 0x81, 0xE0, 0x5E, 0x80, 0x7B, 0x10, 0x42, 0x30,
  0x80, 0x10, 0x1C, 0x45, 0x7B, 0x3A, 0x79, 0x72, 0xDE, 0x81, 0x11, 0xC0,
  0x04, 0x0C, 0x1A, 0x12, 0x22, 0x3E, 0x42, 0x42, 0x3C, 0x45, 0x1B, 0xC4,
  0x48, 0xD1, 0x7C, 0x39, 0x18, 0x20, 0x82, 0x08, 0x9C, 0x3C, 0x4D, 0x8A,
  0x14, 0x68, 0x93, 0x7C, 0x3E, 0x41, 0x03, 0xE4, 0x08, 0x10, 0x7E, 0x7D,
  0x04, 0x3E, 0x82, 0x08, 0x20, 0x39, 0x18, 0x27, 0x8A, 0x28, 0x9C, 0x22,
  0x45, 0x0B, 0xE4, 0x48, 0x91, 0x62, 0x7C, 0x43, 0x08, 0x20, 0x82, 0x3C,
  0x1C, 0x20, 0x82, 0x08, 0x69, 0x38, 0x22, 0x24, 0x48, 0x70, 0x78, 0x48,
  0x4C, 0xC4, 0x42, 0x10, 0x8C, 0x42, 0x1F, 0x22, 0xCD, 0x6A, 0x94, 0x28,
  0xA1, 0x42, 0x22, 0x65, 0x4A, 0xA5, 0x49, 0x93, 0x46, 0x39, 0x38, 0x61,
  0x8E, 0x29, 0xBC, 0x3E, 0x45, 0x0B, 0xE4, 0x08, 0x10, 0x60, 0x39, 0x38,
  0x61, 0x8E, 0x29, 0xBC, 0x20, 0xE0, 0x3E, 0x45, 0x0B, 0xE4, 0x89, 0x13,
  0x62, 0x3C, 0x45, 0x01, 0xC0, 0xC0, 0xB1, 0x3C, 0xFE, 0x20, 0xC1, 0x02,
  0x04, 0x08, 0x10, 0x47, 0x18, 0x63, 0x8A, 0x28, 0xBC, 0x83, 0x0B, 0x12,
  0x45, 0x8A, 0x18, 0x30, 0x83, 0x06, 0x15, 0xAB, 0x5B, 0x36, 0x4C, 0x22,
  0x24, 0x1C, 0x18, 0x18, 0x28, 0x4C, 0x84, 0xC6, 0x89, 0x21, 0x83, 0x04,
  0x08, 0x10, 0x3E, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x7E, 0x3C, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x0F, 0x00, 0x88, 0x44, 0x42, 0x22, 0x10, 0x1C,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x47, 0x00, 0x11, 0x52, 0x98, 0x80,
  0xFE, 0x48, 0x3D, 0x90, 0x4F, 0x47, 0x37, 0x40, 0x20, 0x40, 0xF1, 0x24,
  0x68, 0x91, 0x26, 0x78, 0x79, 0x38, 0x20, 0x82, 0x2F, 0x00, 0x04, 0x17,
  0x73, 0x8A, 0x28, 0xA6, 0xE8, 0x79, 0x28, 0xFE, 0x82, 0x2F, 0x00, 0x1C,
  0x8F, 0xC8, 0x21, 0x04, 0x10, 0x40, 0x3A, 0xCD, 0x12, 0x24, 0x49, 0x9D,
  0x04, 0x78, 0x20, 0x83, 0xD9, 0x45, 0x14, 0x51, 0x44, 0x08, 0x03, 0x82,
  0x18, 0x41, 0x04, 0xFC, 0x04, 0x03, 0x82, 0x08, 0x20, 0x86, 0x10, 0x4E,
  0x00, 0x41, 0x04, 0xD4, 0x63, 0x89, 0x24, 0x88, 0x18, 0x20, 0x82, 0x18,
  0x41, 0x04, 0xFC, 0x76, 0xB5, 0x4A, 0x99, 0x52, 0xA5, 0x00, 0x3D, 0x94,
  0x51, 0x45, 0x14, 0x40, 0x7B, 0x28, 0xE2, 0x8A, 0x6F, 0x00, 0x3C, 0x4D,
  0x1A, 0x24, 0x49, 0x9E, 0x40, 0x80, 0x77, 0x38, 0xA2, 0x8A, 0x6E, 0x84,
  0x10, 0x5D, 0x84, 0x10, 0x42, 0x08, 0x00, 0x7A, 0x70, 0xE0, 0xC7, 0xC0,
  0x44, 0xFC, 0x88, 0x88, 0xE0, 0x46, 0x28, 0xA2, 0x8A, 0x6E, 0x80, 0x86,
  0x3C, 0x94, 0x51, 0x86, 0x00, 0x87, 0x0A, 0xD5, 0xAD, 0x93, 0x26, 0x00,
  0x22, 0x48, 0x60, 0x82, 0x89, 0x21, 0x00, 0x42, 0x8C, 0x91, 0x42, 0x86,
  0x0C, 0x10, 0xC0, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x00, 0x1C, 0x41,
  0x08, 0x23, 0x06, 0x08, 0x41, 0x07, 0x00, 0xFF, 0xE0, 0x38, 0x20, 0x82,
  0x08, 0x31, 0x04, 0x10, 0x8E, 0x00, 0xE4, 0x60,
};

const GFXglyph LiberationMono_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 5, 4, 7, 2, -9 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 7, 10, 7, 0, -9 },
  { 23, 8, 8, 7, 0, -8 },
  { 31, 7, 8, 7, 0, -8 },
  { 38, 1, 4, 7, 4, -9 },
  { 39, 4, 11, 7, 2, -9 },
  { 45, 4, 11, 7, 1, -9 },
  { 51, 4, 5, 7, 2, -9 },
  { 54, 6, 5, 7, 1, -7 },
  { 58, 4, 4, 7, 0, -2 },
  { 60, 3, 1, 7, 2, -3 },
  { 61, 2, 2, 7, 2, -2 },
  { 62, 8, 9, 7, 0, -9 },
  { 71, 6, 8, 7, 1, -8 },
  { 77, 6, 8, 7, 0, -8 },
  { 83, 7, 8, 7, 0, -8 },
  { 90, 6, 8, 7, 1, -8 },
  { 96, 7, 8, 7, 0, -8 },
  { 103, 7, 8, 7, 0, -8 },
  { 110, 6, 8, 7, 1, -8 },
  { 116, 5, 8, 7, 2, -8 },
  { 121, 6, 8, 7, 1, -8 },
  { 127, 6, 8, 7, 1, -8 },
  { 133, 3, 7, 7, 2, -7 },
  { 136, 4, 9, 7, 1, -7 },
  { 141, 6, 5, 7, 1, -7 },
  { 145, 6, 3, 7, 1, -6 },
  { 148, 6, 5, 7, 1, -7 },
  { 152, 6, 8, 7, 1, -8 },
  { 158, 7, 11, 7, 0, -9 },
  { 168, 8, 8, 7, -1, -8 },
  { 176, 7, 8, 7, 0, -8 },
  { 183, 6, 8, 7, 1, -8 },
  { 189, 7, 8, 7, 0, -8 },
  { 196, 7, 8, 7, 0, -8 },
  { 203, 6, 8, 7, 1, -8 },
  { 209, 6, 8, 7, 1, -8 },
  { 215, 7, 8, 7, 0, -8 },
  { 222, 6, 8, 7, 1, -8 },
  { 228, 6, 8, 7, 1, -8 },
  { 234, 8, 8, 7, 0, -8 },
  { 242, 5, 8, 7, 1, -8 },
  { 247, 7, 8, 7, 0, -8 },
  { 254, 7, 8, 7, 0, -8 },
  { 261, 6, 8, 7, 1, -8 },
  { 267, 7, 8, 7, 0, -8 },
  { 274, 6, 10, 7, 1, -8 },
  { 282, 7, 8, 7, 0, -8 },
  { 289, 7, 8, 7, 0, -8 },
  { 296, 7, 8, 7, 1, -8 },
  { 303, 6, 8, 7, 1, -8 },
  { 309, 7, 8, 7, 1, -8 },
  { 316, 7, 8, 7, 1, -8 },
  { 323, 8, 8, 7, 0, -8 },
  { 331, 7, 8, 7, 1, -8 },
  { 338, 7, 8, 7, 0, -8 },
  { 345, 6, 11, 7, 1, -9 },
  { 354, 4, 9, 7, 2, -9 },
  { 359, 6, 11, 7, 0, -9 },
  { 368, 5, 5, 7, 1, -8 },
  { 372, 7, 1, 7, -1, 1 },
  { 373, 3, 2, 7, 3, -10 },
  { 374, 6, 7, 7, 0, -7 },
  { 380, 7, 9, 7, 0, -9 },
  { 388, 6, 7, 7, 1, -7 },
  { 394, 6, 9, 7, 1, -9 },
  { 401, 6, 7, 7, 1, -7 },
  { 407, 6, 9, 7, 1, -9 },
  { 414, 7, 9, 7, 0, -7 },
  { 422, 6, 9, 7, 0, -9 },
  { 429, 6, 9, 7, 0, -9 },
  { 436, 6, 11, 7, 0, -9 },
  { 445, 6, 9, 7, 1, -9 },
  { 452, 6, 9, 7, 0, -9 },
  { 459, 7, 7, 7, 0, -7 },
  { 466, 6, 7, 7, 0, -7 },
  { 472, 6, 7, 7, 1, -7 },
  { 478, 7, 9, 7, 0, -7 },
  { 486, 6, 9, 7, 1, -7 },
  { 493, 6, 7, 7, 1, -7 },
  { 499, 5, 7, 7, 1, -7 },
  { 504, 4, 9, 7, 2, -9 },
  { 509, 6, 7, 7, 1, -7 },
  { 515, 6, 7, 7, 1, -7 },
  { 521, 7, 7, 7, 1, -7 },
  { 528, 7, 7, 7, 0, -7 },
  { 535, 7, 9, 7, 0, -7 },
  { 543, 7, 7, 7, 0, -7 },
  { 550, 6, 11, 7, 1, -9 },
  { 559, 1, 11, 7, 3, -9 },
  { 561, 6, 11, 7, 0, -9 },
  { 570, 6, 2, 7, 1, -6 },
};

const GFXfont LiberationMono_Italic12pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic12pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _LIBERATIONMONO_ITALIC12PT7B_H_
