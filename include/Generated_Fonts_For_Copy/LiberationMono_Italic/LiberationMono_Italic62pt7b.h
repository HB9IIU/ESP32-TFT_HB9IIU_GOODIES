#ifndef _LIBERATIONMONO_ITALIC62PT7B_H_
#define _LIBERATIONMONO_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF9, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC,
  0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x8F, 0x3F, 0xC0, 0x0F,
  0xC0, 0xE0, 0xFE, 0x01, 0xF8, 0x1E, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x1E, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x1E,
  0x03, 0x80, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00,
  0x01, 0xFF, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0x07, 0xF0,
  0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0xE0,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x81, 0x80,
  0x1E, 0x00, 0xF8, 0xFC, 0x01, 0xE0, 0x1F, 0x8F, 0xC0, 0x1E, 0x01, 0xF0,
  0xFC, 0x03, 0xC0, 0x1F, 0x0F, 0xC0, 0x3C, 0x03, 0xF0, 0x7E, 0x03, 0xC0,
  0x7E, 0x07, 0xF0, 0x3C, 0x0F, 0xC0, 0x3F, 0xE3, 0xC7, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x07,
  0x83, 0xE0, 0x00, 0x7C, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x01,
  0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0xF1, 0xFF, 0xF0, 0x00,
  0x00, 0xF1, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x3E, 0x00, 0x00, 0xF0,
  0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x03,
  0xC0, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x01, 0xE0, 0x7E, 0x00,
  0x00, 0x7C, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x18, 0x01, 0xFF, 0x80,
  0x07, 0x80, 0xFF, 0xF0, 0x03, 0xE0, 0x7E, 0x7C, 0x00, 0xF8, 0x3F, 0x1F,
  0x00, 0x7C, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x07, 0x83, 0xE0,
  0x3F, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x1F,
  0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x0F, 0xCF, 0x83, 0xE0, 0x01, 0xFF, 0xC0,
  0xF8, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x1F,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xF0, 0x1F,
  0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x03, 0x03, 0xC0, 0xDF, 0x0E, 0x1F, 0x7F, 0xBB, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x3C,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x07, 0x80, 0x60, 0x18, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xFB, 0xF9, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x3F, 0xC1, 0xFB, 0xE0, 0x7F,
  0x03, 0xF7, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0xBF, 0x03, 0xF8,
  0x3F, 0x7E, 0x07, 0xF0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFD, 0xF0, 0x3F, 0x81,
  0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE7,
  0xE0, 0x03, 0xFF, 0x1F, 0x80, 0x1F, 0xE0, 0x7C, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x0F, 0x9F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x70, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x00,
  0x1F, 0x0F, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x81,
  0xF7, 0xC0, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x7E, 0x1F,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0,
  0x7E, 0xF8, 0x1F, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF,
  0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0xFF,
  0x1E, 0xF0, 0x3C, 0x07, 0xFE, 0x73, 0xC0, 0xF0, 0x7C, 0x3B, 0xCF, 0x07,
  0x81, 0xE0, 0x6F, 0x3C, 0x1E, 0x0F, 0x01, 0xF8, 0xF0, 0xF0, 0x78, 0x07,
  0xE3, 0xC3, 0xC3, 0xC0, 0x1F, 0x0F, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x78,
  0x78, 0x01, 0xF0, 0xE1, 0xE1, 0xE0, 0x07, 0x83, 0x87, 0x8F, 0x00, 0x3E,
  0x1E, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0xF1, 0xF0, 0x03, 0xC1, 0xE3, 0xC7,
  0x80, 0x1F, 0x07, 0x0E, 0x1E, 0x00, 0x78, 0x3C, 0x78, 0xF8, 0x01, 0xE0,
  0xF1, 0xE3, 0xC0, 0x0F, 0x03, 0x87, 0x8F, 0x00, 0x3C, 0x1E, 0x1E, 0x3C,
  0x01, 0xF0, 0x78, 0x78, 0xF0, 0x07, 0x81, 0xC1, 0xC3, 0xC0, 0x3E, 0x0F,
  0x0F, 0x0F, 0x00, 0xF8, 0x38, 0x3C, 0x3C, 0x07, 0xC1, 0xE0, 0xF0, 0xF0,
  0x3F, 0x07, 0x03, 0xC3, 0xC1, 0xDC, 0x38, 0x0F, 0x0F, 0x8E, 0x71, 0xE0,
  0x3C, 0x3F, 0xF1, 0xFF, 0x00, 0xF0, 0x7F, 0x87, 0xF0, 0x01, 0xE0, 0xF8,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x07, 0xFC, 0x0F,
  0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFF, 0x0F, 0xC0,
  0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0x83, 0xF8, 0x00,
  0x03, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xE0,
  0x03, 0xFC, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF,
  0xFC, 0xFC, 0x01, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xCF,
  0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x9F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x7D, 0xE0, 0x07, 0xBE, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0x7C,
  0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xE7, 0xC0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF3, 0xE0, 0x1F, 0x1E, 0x0F,
  0x9F, 0x00, 0xF8, 0xF8, 0x78, 0xF8, 0x0F, 0x87, 0xC7, 0xC7, 0xC0, 0x7C,
  0x3E, 0x3C, 0x3E, 0x03, 0xE1, 0xF3, 0xC1, 0xE0, 0x1F, 0x0F, 0x9E, 0x1F,
  0x00, 0xF8, 0x3D, 0xE0, 0xF8, 0x0F, 0x81, 0xEF, 0x07, 0xC0, 0x7C, 0x0F,
  0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0x81, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x7C, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x7C,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0xF8, 0x00,
  0x7E, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0x7D, 0xF0, 0x01, 0xF0, 0x0F, 0xBE,
  0x00, 0x3E, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x7C, 0x7C, 0x01, 0xF8, 0x0F,
  0x8F, 0x80, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x3E, 0x3F, 0x00, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x07, 0xC3, 0xF0, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x00, 0x3E, 0x7E, 0x03, 0xE0, 0x07, 0xCF, 0xC0, 0x7C, 0x00, 0xF9,
  0xF0, 0x0F, 0x80, 0x1F, 0xBE, 0x01, 0xF0, 0x01, 0xF7, 0xC0, 0x7E, 0x00,
  0x3E, 0xF8, 0x0F, 0x80, 0x07, 0xDF, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x3E,
  0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x07, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x01, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x7B,
  0xC0, 0xF8, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x0F, 0x83, 0xEF, 0x07, 0xC0,
  0x1F, 0x07, 0x9E, 0x0F, 0x80, 0x3E, 0x1F, 0x3C, 0x1F, 0x00, 0x7C, 0x3C,
  0x78, 0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0x01, 0xF1, 0xE1, 0xF1, 0xF0,
  0x03, 0xE7, 0xC3, 0xE7, 0xC0, 0x07, 0xCF, 0x07, 0xCF, 0x80, 0x0F, 0x9E,
  0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x1E, 0xF8,
  0x00, 0x7B, 0xE0, 0x3D, 0xF0, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x0F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x87, 0xE0, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xFC, 0x1F, 0xC0, 0x1E, 0xFC, 0x1F, 0xC0, 0xF9,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0x87, 0xFC, 0x3F, 0xFC, 0x07,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xF0, 0x03, 0xF1, 0xFF,
  0xF8, 0x03, 0xF7, 0xFF, 0xFC, 0x03, 0xEF, 0x81, 0xFE, 0x03, 0xEE, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0xC0, 0x07, 0xE0, 0x7F, 0xC0, 0x0F,
  0xC0, 0x7D, 0xF0, 0x3F, 0xC0, 0x7C, 0xFF, 0xFF, 0x80, 0x7C, 0x7F, 0xFE,
  0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xCF,
  0x80, 0x1F, 0xFF, 0xF3, 0xE0, 0x0F, 0xF0, 0x3E, 0xF8, 0x03, 0xF0, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x77, 0xC0, 0x1F, 0xE0, 0x7D, 0xF0, 0x03,
  0xFF, 0xFE, 0x7C, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xFC, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x07, 0xC0, 0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x1F, 0xE0,
  0x7D, 0xF0, 0x0F, 0xC0, 0x1E, 0xF8, 0x0F, 0xC0, 0x07, 0xFC, 0x0F, 0xC0,
  0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xFE,
  0x03, 0xF8, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xDF, 0x00, 0x7F, 0xFF, 0xCF,
  0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x1F, 0x0F, 0xFF, 0x00, 0x3E, 0x3F,
  0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0x01, 0xF7, 0xC0, 0xFF, 0x03, 0xEE, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0x8F, 0xE0, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x03, 0xEF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x7F, 0x83,
  0xFE, 0x03, 0xCF, 0xFC, 0x7F, 0xE0, 0x3D, 0xFF, 0xCF, 0xFE, 0x03, 0xDC,
  0x7D, 0xC3, 0xF0, 0x7F, 0x07, 0xD8, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0x01,
  0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x01,
  0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xE1, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF,
  0xF0, 0x1F, 0x3F, 0xFF, 0xE0, 0x3E, 0xF8, 0x1F, 0xE0, 0x7D, 0xC0, 0x1F,
  0xC0, 0xFF, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x0F,
  0xFF, 0x00, 0x0F, 0xC7, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xFC, 0x00, 0xF9,
  0xE0, 0x7F, 0x80, 0x3E, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xFF,
  0xC0, 0x07, 0xC3, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0xFF,
  0x3F, 0x01, 0xFF, 0xFF, 0x3E, 0x03, 0xFC, 0x0F, 0xBE, 0x03, 0xF0, 0x03,
  0xFE, 0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x77,
  0xC0, 0x7F, 0x81, 0xF7, 0xC0, 0x3F, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xCF,
  0xC0, 0x0F, 0xFF, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x3E, 0x07, 0xFF, 0xC1, 0xF0, 0x7F, 0xFC, 0x0F, 0x87, 0xFF, 0xE0,
  0x7C, 0x7F, 0xFF, 0x03, 0xE7, 0xE0, 0x08, 0x3F, 0x7C, 0x00, 0x01, 0xFB,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC1, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x01, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0, 0x7D, 0xF0,
  0x1F, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFE, 0x0F, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x0F, 0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xFC, 0x03, 0xE0,
  0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFF, 0x01, 0xF0, 0x7E, 0x07, 0xF8,
  0x0F, 0x83, 0xF0, 0x79, 0xE0, 0xF8, 0x1F, 0x83, 0xCF, 0x07, 0xC0, 0xFC,
  0x3C, 0x78, 0x3E, 0x07, 0xE1, 0xE3, 0xC3, 0xE0, 0x3E, 0x1E, 0x1E, 0x1F,
  0x01, 0xF0, 0xF0, 0xF1, 0xF8, 0x0F, 0x8F, 0x87, 0x8F, 0x80, 0x7C, 0x78,
  0x3C, 0x7C, 0x03, 0xE7, 0x81, 0xE3, 0xE0, 0x1F, 0x3C, 0x0F, 0xBE, 0x00,
  0xFB, 0xC0, 0x3D, 0xF0, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x05, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xA0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
};

const GFXglyph LiberationMono_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 41, 37, 12, -41 },
  { 73, 23, 19, 37, 11, -45 },
  { 128, 37, 41, 37, 1, -41 },
  { 318, 36, 50, 37, 1, -45 },
  { 543, 41, 43, 37, -1, -42 },
  { 764, 34, 43, 37, 0, -42 },
  { 947, 10, 19, 37, 18, -45 },
  { 971, 24, 58, 37, 9, -45 },
  { 1145, 24, 58, 37, 4, -45 },
  { 1319, 22, 22, 37, 11, -45 },
  { 1380, 30, 30, 37, 4, -36 },
  { 1493, 17, 20, 37, 3, -9 },
  { 1536, 18, 5, 37, 10, -19 },
  { 1548, 9, 9, 37, 12, -9 },
  { 1559, 39, 46, 37, 0, -45 },
  { 1784, 31, 43, 37, 4, -42 },
  { 1951, 30, 41, 37, 2, -41 },
  { 2105, 34, 42, 37, 1, -42 },
  { 2284, 32, 43, 37, 3, -42 },
  { 2456, 32, 41, 37, 2, -41 },
  { 2620, 33, 42, 37, 3, -41 },
  { 2794, 31, 43, 37, 4, -42 },
  { 2961, 28, 41, 37, 9, -41 },
  { 3105, 32, 43, 37, 3, -42 },
  { 3277, 31, 43, 37, 4, -42 },
  { 3444, 13, 33, 37, 12, -33 },
  { 3498, 20, 44, 37, 5, -33 },
  { 3608, 30, 31, 37, 4, -36 },
  { 3725, 30, 20, 37, 4, -30 },
  { 3800, 30, 31, 37, 4, -36 },
  { 3917, 30, 42, 37, 5, -42 },
  { 4075, 38, 54, 37, 0, -45 },
  { 4332, 37, 41, 37, -3, -41 },
  { 4522, 33, 41, 37, 2, -41 },
  { 4692, 33, 43, 37, 4, -42 },
  { 4870, 34, 41, 37, 2, -41 },
  { 5045, 35, 41, 37, 2, -41 },
  { 5225, 35, 41, 37, 3, -41 },
  { 5405, 32, 43, 37, 4, -42 },
  { 5577, 35, 41, 37, 2, -41 },
  { 5757, 33, 41, 37, 3, -41 },
  { 5927, 31, 42, 37, 4, -41 },
  { 6090, 38, 41, 37, 2, -41 },
  { 6285, 27, 41, 37, 4, -41 },
  { 6424, 37, 41, 37, 1, -41 },
  { 6614, 35, 41, 37, 2, -41 },
  { 6794, 33, 43, 37, 3, -42 },
  { 6972, 35, 41, 37, 2, -41 },
  { 7152, 33, 54, 37, 3, -42 },
  { 7375, 35, 41, 37, 2, -41 },
  { 7555, 35, 43, 37, 1, -42 },
  { 7744, 34, 41, 37, 6, -41 },
  { 7919, 35, 42, 37, 3, -41 },
  { 8103, 37, 41, 37, 5, -41 },
  { 8293, 39, 41, 37, 3, -41 },
  { 8493, 42, 41, 37, -2, -41 },
  { 8709, 35, 41, 37, 6, -41 },
  { 8889, 39, 41, 37, -1, -41 },
  { 9089, 28, 58, 37, 7, -45 },
  { 9292, 21, 46, 37, 9, -45 },
  { 9413, 28, 58, 37, 2, -45 },
  { 9616, 30, 27, 37, 3, -41 },
  { 9718, 38, 3, 37, -5, 4 },
  { 9733, 12, 8, 37, 17, -44 },
  { 9745, 31, 35, 37, 2, -34 },
  { 9881, 32, 46, 37, 2, -45 },
  { 10065, 31, 35, 37, 3, -34 },
  { 10201, 34, 46, 37, 3, -45 },
  { 10397, 30, 35, 37, 4, -34 },
  { 10529, 32, 45, 37, 7, -45 },
  { 10709, 33, 47, 37, 2, -34 },
  { 10903, 31, 45, 37, 2, -45 },
  { 11078, 31, 45, 37, 1, -45 },
  { 11253, 33, 58, 37, -2, -45 },
  { 11493, 33, 45, 37, 4, -45 },
  { 11679, 30, 45, 37, 1, -45 },
  { 11848, 36, 34, 37, 0, -34 },
  { 12001, 31, 34, 37, 2, -34 },
  { 12133, 31, 35, 37, 3, -34 },
  { 12269, 34, 47, 37, 0, -34 },
  { 12469, 32, 47, 37, 3, -34 },
  { 12657, 29, 34, 37, 6, -34 },
  { 12781, 30, 35, 37, 3, -34 },
  { 12913, 25, 43, 37, 8, -42 },
  { 13048, 31, 34, 37, 4, -33 },
  { 13180, 33, 33, 37, 5, -33 },
  { 13317, 37, 33, 37, 3, -33 },
  { 13470, 37, 33, 37, 0, -33 },
  { 13623, 39, 46, 37, -1, -33 },
  { 13848, 33, 33, 37, 1, -33 },
  { 13985, 32, 58, 37, 6, -45 },
  { 14217, 5, 58, 37, 16, -45 },
  { 14254, 32, 58, 37, -1, -45 },
  { 14486, 31, 8, 37, 4, -25 },
};

const GFXfont LiberationMono_Italic62pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic62pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic62pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _LIBERATIONMONO_ITALIC62PT7B_H_
