#ifndef _LIBERATIONMONO_ITALIC18PT7B_H_
#define _LIBERATIONMONO_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x44, 0x00, 0xC8, 0x66, 0xCD, 0x12, 0x2C, 0xD9,
  0x80, 0x04, 0x40, 0x88, 0x22, 0x1F, 0xF1, 0x10, 0x22, 0x04, 0x47, 0xFE,
  0x22, 0x08, 0x41, 0x10, 0x22, 0x00, 0x03, 0x00, 0x40, 0x3F, 0x09, 0x23,
  0x26, 0x44, 0x0D, 0x80, 0xF8, 0x05, 0x80, 0x98, 0x13, 0x62, 0x66, 0x98,
  0x7E, 0x02, 0x00, 0x40, 0x38, 0x26, 0x44, 0x44, 0x84, 0xD0, 0x4B, 0x07,
  0x60, 0x05, 0xC0, 0xA6, 0x12, 0x62, 0x64, 0x46, 0x48, 0x38, 0x07, 0x82,
  0x21, 0x08, 0x46, 0x1E, 0x06, 0x06, 0x8D, 0x32, 0xC5, 0xB1, 0xCC, 0x71,
  0xE7, 0x6D, 0x2D, 0x80, 0x0C, 0x61, 0x0C, 0x61, 0x8C, 0x30, 0xC2, 0x08,
  0x20, 0x83, 0x0C, 0x10, 0x60, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0x40, 0x18, 0x21, 0x5B, 0xC3,
  0x0D, 0x12, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x31, 0x98, 0x8C, 0x40, 0xF8, 0x6D, 0x80, 0x00, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x0F, 0x18, 0xC8, 0x2C, 0x14, 0x0E, 0x6F, 0x77, 0x83,
  0xC1, 0x61, 0x91, 0x8F, 0x80, 0x03, 0x03, 0x8E, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x0C, 0x06, 0x02, 0x01, 0x0F, 0xF0, 0x0F, 0x86, 0x33, 0x04, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0xFE, 0x1F, 0x18,
  0xD8, 0x20, 0x30, 0x30, 0xE0, 0x0C, 0x02, 0x01, 0x61, 0xB0, 0x8F, 0x80,
  0x03, 0x81, 0x81, 0x41, 0x61, 0x31, 0x19, 0x09, 0x84, 0xFF, 0x83, 0x01,
  0x80, 0x80, 0x3F, 0x90, 0x08, 0x0C, 0x07, 0xE3, 0x18, 0x06, 0x03, 0x01,
  0x41, 0xB1, 0x8F, 0x80, 0x0F, 0x08, 0xC8, 0x0C, 0x05, 0xE3, 0x1B, 0x07,
  0x83, 0xC1, 0x61, 0x99, 0x87, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x1F, 0x18, 0xD8, 0x2C, 0x32, 0x10,
  0xF1, 0x8D, 0x82, 0xC1, 0x61, 0xB0, 0x8F, 0x80, 0x1F, 0x18, 0xD8, 0x6C,
  0x34, 0x1A, 0x0D, 0x8E, 0x7A, 0x03, 0x61, 0x31, 0x8F, 0x00, 0x33, 0x30,
  0x00, 0x06, 0x66, 0x18, 0xC6, 0x00, 0x00, 0x06, 0x33, 0x11, 0x88, 0x00,
  0x00, 0x83, 0x87, 0x0C, 0x08, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x08, 0x38,
  0x60, 0xC0, 0x80, 0x00, 0x3E, 0x63, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x20,
  0x00, 0x00, 0x60, 0x60, 0x07, 0x81, 0x08, 0x40, 0x93, 0xD2, 0x9A, 0xB3,
  0x54, 0x4A, 0x8B, 0xB2, 0x54, 0x4A, 0x9A, 0x4D, 0x8C, 0x00, 0x86, 0x0F,
  0x00, 0x01, 0x80, 0x50, 0x1A, 0x02, 0x40, 0xCC, 0x11, 0x86, 0x30, 0xFE,
  0x20, 0x4C, 0x09, 0x01, 0xE0, 0x30, 0x1F, 0x84, 0x33, 0x04, 0xC3, 0x30,
  0x8F, 0xC2, 0x09, 0x83, 0x60, 0xD8, 0x36, 0x19, 0xF8, 0x0F, 0x0C, 0x66,
  0x0D, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0xB0, 0x46, 0x20, 0xF0,
  0x1F, 0x04, 0x73, 0x0C, 0xC1, 0x30, 0x48, 0x12, 0x0D, 0x83, 0x60, 0x98,
  0x66, 0x31, 0xF0, 0x1F, 0xE2, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xC0, 0x3F, 0xC8, 0x02, 0x01,
  0x80, 0x60, 0x1F, 0xC4, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F,
  0x0C, 0x66, 0x0D, 0x80, 0x40, 0x31, 0xEC, 0x1B, 0x06, 0xC1, 0x30, 0x46,
  0x30, 0xF0, 0x10, 0x62, 0x08, 0xC1, 0x18, 0x63, 0x0C, 0x7F, 0x88, 0x33,
  0x04, 0x61, 0x8C, 0x31, 0x06, 0x20, 0xC0, 0x3F, 0x82, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x1F, 0xC0, 0x07, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0xC2, 0x63, 0x11, 0x8F, 0x00, 0x10,
  0x62, 0x18, 0xC6, 0x19, 0x83, 0x60, 0x78, 0x0F, 0x83, 0x30, 0x63, 0x0C,
  0x61, 0x06, 0x20, 0x60, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x60, 0x40, 0xC0, 0xFF, 0x38, 0x67, 0x1C, 0xA3, 0x94, 0xA2, 0x94, 0xDC,
  0x9B, 0xB2, 0x26, 0x40, 0x88, 0x11, 0x02, 0x60, 0xC0, 0x18, 0x63, 0x08,
  0xE1, 0x1E, 0x22, 0xCC, 0x49, 0x89, 0x33, 0x34, 0x62, 0x88, 0x51, 0x0E,
  0x21, 0xC0, 0x0F, 0x18, 0xD8, 0x6C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0x61, 0xB1, 0x8F, 0x80, 0x1F, 0x82, 0x18, 0xC1, 0x98, 0x33, 0x0C, 0x43,
  0x0F, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x18, 0xD8,
  0x6C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0x61, 0xB1, 0x8F, 0x81, 0x80,
  0xC0, 0x60, 0x1E, 0x1F, 0x82, 0x18, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x0F,
  0xC3, 0x30, 0x63, 0x0C, 0x61, 0x06, 0x20, 0xC0, 0x0F, 0x86, 0x33, 0x04,
  0xC0, 0x30, 0x07, 0xC0, 0x38, 0x03, 0x00, 0xF0, 0x26, 0x18, 0xF8, 0xFF,
  0x82, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0xD8, 0x36, 0x09, 0x82, 0x41, 0x90, 0x6C, 0x1B, 0x04,
  0xC1, 0x30, 0xCC, 0x61, 0xF0, 0x40, 0x68, 0x09, 0x83, 0x30, 0xC6, 0x18,
  0xC6, 0x08, 0x81, 0x30, 0x34, 0x07, 0x80, 0xE0, 0x0C, 0x00, 0xC0, 0x78,
  0x0F, 0x01, 0x60, 0x6C, 0xCD, 0x99, 0x35, 0x66, 0xAC, 0xA5, 0x14, 0xA3,
  0x1C, 0x63, 0x00, 0x18, 0x30, 0x63, 0x03, 0x10, 0x09, 0x00, 0x78, 0x01,
  0x80, 0x1C, 0x01, 0xA0, 0x19, 0x80, 0x84, 0x08, 0x30, 0xC0, 0x80, 0xC0,
  0xB0, 0x64, 0x31, 0x98, 0x24, 0x0E, 0x03, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x1F, 0xE0, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x00, 0x7F, 0xC0, 0x1F, 0x10, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xF8,
  0x83, 0x04, 0x10, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x1F, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0xF8, 0x06, 0x0A, 0x1A, 0x12, 0x23, 0x21, 0x41, 0xC1, 0xFF,
  0xE0, 0xCC, 0x80, 0x1E, 0x23, 0x61, 0x03, 0x3F, 0xC3, 0xC3, 0x86, 0xCA,
  0xF3, 0x30, 0x10, 0x08, 0x05, 0xE7, 0x1B, 0x0D, 0x86, 0x83, 0x41, 0x60,
  0xB0, 0xDC, 0xCB, 0xC0, 0x1F, 0x10, 0xD8, 0x68, 0x0C, 0x06, 0x03, 0x01,
  0x86, 0xC6, 0x3E, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x76, 0x23, 0x98, 0x64,
  0x13, 0x04, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0x7A, 0x00, 0x1F, 0x18, 0x98,
  0x68, 0x3F, 0xFE, 0x03, 0x01, 0x86, 0xC6, 0x3E, 0x00, 0x0F, 0x8C, 0x04,
  0x1F, 0xE3, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x00,
  0x1C, 0x91, 0xD8, 0x68, 0x3C, 0x16, 0x0B, 0x0D, 0x86, 0xC7, 0x3D, 0x00,
  0x90, 0xCC, 0x43, 0xC0, 0x30, 0x18, 0x08, 0x05, 0xE7, 0x1B, 0x0D, 0x86,
  0x82, 0x41, 0x61, 0xB0, 0xD8, 0x68, 0x20, 0x03, 0x01, 0x80, 0x03, 0xC0,
  0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x8F, 0xF8, 0x00, 0xC0,
  0x30, 0x00, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x78, 0x00, 0x10, 0x0C, 0x03, 0x00,
  0x86, 0x23, 0x09, 0x07, 0x81, 0xE0, 0x4C, 0x11, 0x04, 0x63, 0x18, 0xC3,
  0x00, 0x0F, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x8F, 0xF8, 0x2D, 0xCD, 0x96, 0x65, 0x91, 0x44, 0xD1, 0x34,
  0xCF, 0x32, 0xC8, 0xB2, 0x20, 0x6F, 0x38, 0xD8, 0x6C, 0x34, 0x12, 0x0B,
  0x0D, 0x86, 0xC3, 0x41, 0x00, 0x1F, 0x18, 0x98, 0x68, 0x3C, 0x1E, 0x0F,
  0x05, 0x86, 0xC6, 0x3E, 0x00, 0x37, 0x8E, 0x33, 0x0C, 0xC3, 0x20, 0xC8,
  0x26, 0x09, 0x86, 0x73, 0x17, 0x84, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1D,
  0x91, 0xD8, 0x68, 0x2C, 0x16, 0x1B, 0x0D, 0x86, 0xC7, 0x3D, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x6F, 0x70, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x1F, 0x10, 0x98, 0x6C, 0x03, 0xC0, 0x78, 0x0D, 0x06, 0xC2, 0x3E,
  0x00, 0x10, 0x63, 0xF9, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x03, 0xE0,
  0x61, 0xB0, 0xD8, 0x68, 0x24, 0x12, 0x0B, 0x0D, 0x86, 0xC7, 0x3D, 0x00,
  0x81, 0xE0, 0xB0, 0xD8, 0xCC, 0x62, 0x61, 0x20, 0xF0, 0x70, 0x38, 0x00,
  0xC0, 0x58, 0x1B, 0x03, 0x66, 0x49, 0x59, 0x2B, 0x29, 0x45, 0x28, 0xC7,
  0x18, 0xC0, 0x30, 0xC2, 0x10, 0x64, 0x05, 0x80, 0xE0, 0x1C, 0x06, 0x81,
  0x98, 0x61, 0x18, 0x30, 0x20, 0x64, 0x08, 0xC3, 0x18, 0x41, 0x18, 0x26,
  0x06, 0x80, 0xF0, 0x1C, 0x01, 0x80, 0x20, 0x08, 0x03, 0x01, 0xC0, 0x00,
  0x3F, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xE0, 0x07, 0x86, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0xC0, 0x30,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x3C, 0x00, 0xFF, 0xFF, 0x80,
  0x1E, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x04, 0x01, 0x83, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0xF0, 0x00, 0x70, 0x46, 0x41, 0xC0,
};

const GFXglyph LiberationMono_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 12, 11, 4, -12 },
  { 7, 7, 6, 11, 3, -13 },
  { 13, 11, 12, 11, 0, -12 },
  { 30, 11, 16, 11, 0, -14 },
  { 52, 12, 12, 11, 0, -12 },
  { 70, 10, 12, 11, 0, -12 },
  { 85, 3, 6, 11, 5, -13 },
  { 88, 6, 17, 11, 3, -13 },
  { 101, 7, 17, 11, 1, -13 },
  { 116, 7, 7, 11, 3, -13 },
  { 123, 9, 9, 11, 1, -11 },
  { 134, 5, 6, 11, 1, -3 },
  { 138, 5, 1, 11, 3, -5 },
  { 139, 3, 3, 11, 3, -3 },
  { 141, 11, 13, 11, 0, -13 },
  { 159, 9, 12, 11, 1, -12 },
  { 173, 9, 12, 11, 0, -12 },
  { 187, 10, 12, 11, 0, -12 },
  { 202, 9, 12, 11, 1, -12 },
  { 216, 9, 12, 11, 1, -12 },
  { 230, 9, 12, 11, 1, -12 },
  { 244, 9, 12, 11, 1, -12 },
  { 258, 8, 12, 11, 3, -12 },
  { 270, 9, 12, 11, 1, -12 },
  { 284, 9, 12, 11, 1, -12 },
  { 298, 4, 10, 11, 3, -10 },
  { 303, 5, 13, 11, 2, -10 },
  { 312, 9, 9, 11, 1, -11 },
  { 323, 9, 5, 11, 1, -9 },
  { 329, 9, 9, 11, 1, -11 },
  { 340, 8, 12, 11, 2, -12 },
  { 352, 11, 15, 11, 0, -13 },
  { 373, 11, 12, 11, -1, -12 },
  { 390, 10, 12, 11, 0, -12 },
  { 405, 10, 12, 11, 1, -12 },
  { 420, 10, 12, 11, 0, -12 },
  { 435, 11, 12, 11, 0, -12 },
  { 452, 10, 12, 11, 1, -12 },
  { 467, 10, 12, 11, 1, -12 },
  { 482, 11, 12, 11, 0, -12 },
  { 499, 9, 12, 11, 1, -12 },
  { 513, 9, 12, 11, 1, -12 },
  { 527, 11, 12, 11, 0, -12 },
  { 544, 8, 12, 11, 1, -12 },
  { 556, 11, 12, 11, 0, -12 },
  { 573, 11, 12, 11, 0, -12 },
  { 590, 9, 12, 11, 1, -12 },
  { 604, 11, 12, 11, 0, -12 },
  { 621, 9, 16, 11, 1, -12 },
  { 639, 11, 12, 11, 0, -12 },
  { 656, 10, 12, 11, 0, -12 },
  { 671, 10, 12, 11, 2, -12 },
  { 686, 10, 12, 11, 1, -12 },
  { 701, 11, 12, 11, 1, -12 },
  { 718, 11, 12, 11, 1, -12 },
  { 735, 13, 12, 11, -1, -12 },
  { 755, 10, 12, 11, 2, -12 },
  { 770, 11, 12, 11, 0, -12 },
  { 787, 8, 17, 11, 2, -13 },
  { 804, 6, 13, 11, 3, -13 },
  { 814, 8, 17, 11, 1, -13 },
  { 831, 8, 8, 11, 1, -12 },
  { 839, 11, 1, 11, -1, 1 },
  { 841, 3, 3, 11, 5, -14 },
  { 843, 8, 10, 11, 1, -10 },
  { 853, 9, 13, 11, 1, -13 },
  { 868, 9, 10, 11, 1, -10 },
  { 880, 10, 13, 11, 1, -13 },
  { 897, 9, 10, 11, 1, -10 },
  { 909, 9, 13, 11, 2, -13 },
  { 924, 9, 14, 11, 1, -10 },
  { 940, 9, 13, 11, 1, -13 },
  { 955, 9, 13, 11, 0, -13 },
  { 970, 10, 17, 11, -1, -13 },
  { 992, 10, 13, 11, 1, -13 },
  { 1009, 9, 13, 11, 0, -13 },
  { 1024, 10, 10, 11, 0, -10 },
  { 1037, 9, 10, 11, 1, -10 },
  { 1049, 9, 10, 11, 1, -10 },
  { 1061, 10, 14, 11, 0, -10 },
  { 1079, 9, 14, 11, 1, -10 },
  { 1095, 8, 10, 11, 2, -10 },
  { 1105, 9, 10, 11, 1, -10 },
  { 1117, 7, 12, 11, 2, -12 },
  { 1128, 9, 10, 11, 1, -10 },
  { 1140, 9, 10, 11, 2, -10 },
  { 1152, 11, 10, 11, 1, -10 },
  { 1166, 11, 10, 11, 0, -10 },
  { 1180, 11, 14, 11, 0, -10 },
  { 1200, 10, 10, 11, 0, -10 },
  { 1213, 9, 17, 11, 2, -13 },
  { 1233, 1, 17, 11, 5, -13 },
  { 1236, 9, 17, 11, 0, -13 },
  { 1256, 9, 3, 11, 1, -8 },
};

const GFXfont LiberationMono_Italic18pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic18pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic18pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _LIBERATIONMONO_ITALIC18PT7B_H_
