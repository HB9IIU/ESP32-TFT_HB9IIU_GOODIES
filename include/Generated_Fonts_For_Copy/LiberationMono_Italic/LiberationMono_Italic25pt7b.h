#ifndef _LIBERATIONMONO_ITALIC25PT7B_H_
#define _LIBERATIONMONO_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC6, 0x18, 0x00, 0x0E,
  0x30, 0x63, 0xF1, 0xB8, 0xD8, 0x6C, 0x36, 0x33, 0x19, 0x0C, 0x01, 0x84,
  0x02, 0x08, 0x0C, 0x30, 0x10, 0x40, 0x21, 0x87, 0xFF, 0xC1, 0x0C, 0x06,
  0x10, 0x08, 0x20, 0x10, 0xC3, 0xFF, 0xF0, 0x86, 0x03, 0x08, 0x04, 0x10,
  0x18, 0x60, 0x20, 0x80, 0x00, 0x60, 0x00, 0x80, 0x0F, 0xE0, 0x7F, 0xE1,
  0xCC, 0xE3, 0x18, 0xC6, 0x20, 0x0E, 0x40, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x08, 0xE0, 0x10, 0xDC, 0x63, 0x98, 0xC6, 0x39, 0x9C, 0x7F, 0xF0,
  0x3F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x1E, 0x03, 0x33, 0x06, 0x21, 0x0C,
  0x63, 0x18, 0x63, 0x30, 0x63, 0x60, 0x66, 0xC0, 0x3D, 0x80, 0x03, 0x3C,
  0x02, 0x44, 0x04, 0xC6, 0x0C, 0x86, 0x19, 0x84, 0x31, 0x8C, 0x60, 0x88,
  0xC0, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x61, 0x83, 0x06, 0x0C, 0x30, 0x33,
  0x80, 0x78, 0x07, 0x82, 0x36, 0x19, 0x8C, 0x6C, 0x33, 0x30, 0x78, 0xC1,
  0xE3, 0x87, 0x87, 0xFF, 0x8F, 0x8E, 0x77, 0x66, 0x66, 0x4C, 0x03, 0x83,
  0x83, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x83, 0x80, 0x04, 0x02, 0x11, 0x2F, 0xB3, 0xF0, 0xE0, 0xD8, 0xCC, 0x62,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xFF, 0xFF,
  0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x1E, 0x38, 0x61,
  0xC3, 0x0C, 0x18, 0x60, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x87,
  0x0E, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0x8C, 0x6C, 0xE3, 0x67, 0x3B, 0x01,
  0xB8, 0x0D, 0xC0, 0xE6, 0x06, 0x38, 0xE1, 0xFE, 0x03, 0xE0, 0x00, 0xC0,
  0x1C, 0x07, 0xC3, 0xEC, 0x39, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x1F, 0xF0, 0xE1, 0xC3, 0x03, 0x18, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF,
  0x1F, 0xFC, 0x07, 0xE0, 0x7F, 0xC7, 0x0E, 0x60, 0x30, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0xF8, 0x07, 0xC0, 0x03, 0x80, 0x0D, 0x80, 0x6E, 0x07, 0x78,
  0x71, 0xFF, 0x07, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x37,
  0x03, 0x30, 0x31, 0x83, 0x0C, 0x30, 0x63, 0x07, 0x10, 0x31, 0xFF, 0xEF,
  0xFF, 0x00, 0x60, 0x07, 0x00, 0x30, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x30,
  0x03, 0x00, 0x1B, 0xE0, 0xFF, 0x8E, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0D,
  0x80, 0xEE, 0x06, 0x70, 0x71, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0x1C,
  0x33, 0x00, 0x60, 0x06, 0x78, 0x7F, 0xEF, 0x0E, 0xE0, 0x6C, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0xCE, 0x1C, 0x7F, 0x83, 0xE0, 0x7F, 0xF7, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x03, 0xE0, 0x7F, 0xC7,
  0x0E, 0x70, 0x33, 0x01, 0x98, 0x1C, 0xE1, 0xC3, 0xFC, 0x1F, 0xE3, 0x83,
  0x98, 0x0D, 0xC0, 0x6C, 0x07, 0x70, 0x71, 0xFF, 0x07, 0xE0, 0x03, 0xE0,
  0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0xC0, 0xE7, 0x0F, 0x3F,
  0xF0, 0xF9, 0x80, 0x1C, 0x00, 0xCE, 0x0E, 0x30, 0xE1, 0xFE, 0x07, 0xC0,
  0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x70, 0x07, 0x07, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x18, 0x38, 0x30,
  0x60, 0x60, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0x03, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x60, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x0F, 0xC3, 0xFF, 0x78, 0x76, 0x03, 0xE0, 0x30, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0xF8, 0x06, 0x18, 0x10, 0x18, 0x60, 0x31, 0x80, 0x22, 0x3D, 0x4C,
  0xCE, 0x93, 0x19, 0x64, 0x32, 0xD8, 0x6D, 0x21, 0x9E, 0xC3, 0x2D, 0x84,
  0x5B, 0x19, 0xB6, 0x32, 0x6C, 0xE8, 0xCE, 0x60, 0x80, 0x01, 0x80, 0x81,
  0x86, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80,
  0x3B, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x7F,
  0xF1, 0xFF, 0xE3, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x60, 0x07, 0x1F, 0xE0,
  0xFF, 0xCE, 0x0E, 0x70, 0x33, 0x01, 0x98, 0x1C, 0xC1, 0xCF, 0xFC, 0x7F,
  0xE3, 0x03, 0x98, 0x0E, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0xFF, 0x9F, 0xF0,
  0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x30, 0x19, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0C, 0x60, 0x71, 0xC3,
  0x83, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0x8E, 0x1E, 0x70, 0x73, 0x01,
  0x98, 0x0C, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0xEE,
  0x0E, 0x70, 0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xFC, 0x7F, 0xF3, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFC,
  0x3F, 0xF1, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x06, 0x30, 0x19, 0xC0,
  0x07, 0x00, 0x18, 0x7E, 0x61, 0xFB, 0x80, 0xCE, 0x03, 0x38, 0x0C, 0x60,
  0x31, 0xC1, 0xC3, 0xFE, 0x07, 0xE0, 0x18, 0x1C, 0x60, 0x73, 0x81, 0x8E,
  0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x9F, 0xFC, 0x7F, 0xF1, 0x80, 0xC6,
  0x03, 0x18, 0x1C, 0xE0, 0x63, 0x81, 0x8C, 0x06, 0x30, 0x18, 0x1F, 0xF8,
  0xFF, 0xC0, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0x9F, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xCC, 0x1C, 0xC1, 0x8E, 0x38, 0xFF, 0x07, 0xC0,
  0x18, 0x0C, 0x30, 0x70, 0xE1, 0xC1, 0x87, 0x03, 0x1C, 0x06, 0x70, 0x0D,
  0xC0, 0x3F, 0x80, 0x7B, 0x00, 0xE7, 0x01, 0x87, 0x03, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x30, 0x1C, 0x60, 0x18, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x3F, 0xF7, 0xFE, 0x1C, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xB1,
  0xE3, 0xC6, 0xCD, 0x8C, 0xDB, 0x19, 0xE6, 0x33, 0xCC, 0x67, 0x31, 0x8C,
  0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x60, 0x18, 0x1C, 0x0C,
  0x70, 0x33, 0xC1, 0x8F, 0x86, 0x36, 0x18, 0xD8, 0x63, 0x61, 0x98, 0xCC,
  0x63, 0x31, 0x8C, 0xC6, 0x3B, 0x18, 0x6C, 0xC1, 0xE3, 0x07, 0x8C, 0x0E,
  0x30, 0x38, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0xB8, 0x0D,
  0x80, 0x6C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0xEE, 0x06, 0x38,
  0x71, 0xFF, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE3, 0x83, 0xCE, 0x07, 0x30,
  0x1C, 0xC0, 0x63, 0x03, 0x9C, 0x1C, 0x7F, 0xE1, 0xFF, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x7F, 0x87,
  0x0E, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0D, 0xC0, 0xEE, 0x06, 0x38, 0x71, 0xFF, 0x03, 0xE0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0xF0, 0x7F, 0xE3, 0x81,
  0xCE, 0x07, 0x30, 0x1C, 0xC0, 0x63, 0x03, 0x9F, 0xFC, 0x7F, 0xC1, 0x86,
  0x06, 0x18, 0x18, 0x70, 0xE0, 0xC3, 0x83, 0x8C, 0x06, 0x30, 0x1C, 0x03,
  0xF8, 0x1F, 0xF8, 0x38, 0x70, 0xC0, 0x71, 0x80, 0x03, 0x00, 0x07, 0x80,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x67, 0x00, 0xC6, 0x01, 0x8E,
  0x0E, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x0C, 0xE0,
  0x33, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0x67, 0x03, 0x98, 0x0E, 0x60,
  0x31, 0x80, 0xC6, 0x03, 0x38, 0x1C, 0xE0, 0x63, 0x83, 0x87, 0xFC, 0x0F,
  0xC0, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0C, 0x0E,
  0x1C, 0x18, 0x38, 0x60, 0x30, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03,
  0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x07, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0E, 0x60, 0x0C, 0x63, 0x8C, 0x63, 0x9C, 0x67, 0x98, 0x65,
  0x98, 0x6D, 0xB0, 0xED, 0xB0, 0xD9, 0xB0, 0xD9, 0xA0, 0xF1, 0xE0, 0xF1,
  0xE0, 0xE0, 0xC0, 0x0E, 0x03, 0x83, 0x03, 0x81, 0xC3, 0x80, 0x63, 0x80,
  0x31, 0x80, 0x0D, 0x80, 0x07, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xB0,
  0x01, 0x9C, 0x01, 0xC6, 0x01, 0xC3, 0x81, 0xC0, 0xC1, 0xC0, 0x70, 0xC0,
  0x18, 0x60, 0x0D, 0xC0, 0x67, 0x03, 0x0C, 0x18, 0x38, 0xE0, 0x67, 0x01,
  0xD8, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F,
  0xE1, 0xFC, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0xFC, 0x3F, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x03,
  0x03, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x61, 0xFC, 0x3F, 0x80, 0x01, 0xC0, 0x3C,
  0x02, 0xC0, 0x64, 0x0C, 0x60, 0xC6, 0x18, 0x61, 0x06, 0x30, 0x36, 0x03,
  0x60, 0x30, 0xFF, 0xFE, 0xE3, 0x84, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03,
  0x00, 0x70, 0xFE, 0x3F, 0xE7, 0x06, 0xE0, 0x6C, 0x0E, 0xC1, 0xEE, 0x3E,
  0xFE, 0xF7, 0x87, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x9E, 0x1F,
  0xF8, 0xF1, 0xC7, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0C, 0xC0, 0x66, 0x03,
  0x30, 0x39, 0x81, 0x9E, 0x1C, 0xDF, 0xC6, 0x78, 0x00, 0x07, 0xE0, 0xFF,
  0x86, 0x0C, 0x60, 0x77, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x1C, 0xE1, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x0F, 0x98, 0x7F, 0x63, 0x87, 0x8C, 0x0E, 0x70, 0x31,
  0x80, 0xC6, 0x03, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x18, 0x78,
  0x7F, 0x60, 0xF3, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x60, 0x67, 0x03,
  0xB0, 0x1D, 0xFF, 0xEF, 0xFE, 0xE0, 0x07, 0x00, 0x18, 0x18, 0xE1, 0xC7,
  0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x7F, 0x83, 0x00, 0x38, 0x0F, 0xFE, 0x7F,
  0xF0, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0x98, 0xFE,
  0xCE, 0x1E, 0x60, 0xE7, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x77,
  0x03, 0x38, 0x38, 0xC3, 0xC7, 0xF6, 0x1E, 0x70, 0x03, 0x18, 0x18, 0xE1,
  0xC3, 0xFC, 0x0F, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x19, 0xE3,
  0xFF, 0x3C, 0x33, 0x83, 0x30, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x76,
  0x06, 0x60, 0x6E, 0x06, 0xC0, 0x6C, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x7F, 0xFB, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x7F,
  0x83, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x03, 0x18,
  0x70, 0xC7, 0x06, 0x70, 0x67, 0x03, 0x60, 0x1F, 0x80, 0xEC, 0x06, 0x70,
  0x71, 0x83, 0x0E, 0x18, 0x30, 0xC1, 0xC6, 0x06, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x7F,
  0xFF, 0xFF, 0x80, 0x33, 0x1C, 0xDE, 0xF3, 0x9C, 0xCC, 0x73, 0x31, 0x8C,
  0xC6, 0x36, 0x18, 0xD8, 0xC3, 0x63, 0x19, 0x8C, 0x66, 0x31, 0xB8, 0xC6,
  0xC7, 0x1B, 0x18, 0xE0, 0x31, 0xE3, 0x7F, 0x3C, 0x33, 0x83, 0x30, 0x33,
  0x03, 0x70, 0x36, 0x03, 0x60, 0x76, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x6C,
  0x0E, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x60, 0x77, 0x03, 0xB0, 0x1D, 0x80,
  0xDC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x18, 0xE1, 0x87, 0xFC, 0x0F, 0x80,
  0x1C, 0xF0, 0x6F, 0xE1, 0xE1, 0x87, 0x07, 0x18, 0x1C, 0x60, 0x71, 0x81,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03, 0x1E, 0x1C, 0x6F, 0xE1, 0x9E,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x98,
  0xFE, 0xCE, 0x1E, 0x60, 0x67, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0xE0,
  0x67, 0x03, 0x38, 0x38, 0xC3, 0xC7, 0xFE, 0x1E, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x31, 0xF3, 0x3F, 0x36, 0x03, 0xC0, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0x07, 0xE1, 0xFF, 0x18, 0x33, 0x00, 0x30, 0x03, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xE0, 0x06, 0xC0, 0x6E, 0x0E, 0x7F, 0xC3, 0xF0, 0x08,
  0x06, 0x01, 0x83, 0xFF, 0xFF, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFC, 0x3F, 0x00, 0x70, 0x36, 0x03,
  0x60, 0x76, 0x06, 0x60, 0x6E, 0x06, 0xE0, 0x6C, 0x0E, 0xC0, 0xEC, 0x0C,
  0xC1, 0xCC, 0x3C, 0xFE, 0xC7, 0xCC, 0xE0, 0x1F, 0x01, 0xD8, 0x0C, 0xC0,
  0xC6, 0x0E, 0x38, 0x61, 0xC7, 0x06, 0x30, 0x33, 0x81, 0x98, 0x0D, 0x80,
  0x6C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0xC0, 0x1F, 0x80, 0x37, 0x00,
  0x6E, 0x31, 0x9C, 0xE3, 0x31, 0x66, 0x66, 0xD8, 0xC9, 0xB1, 0xB3, 0x63,
  0x47, 0x87, 0x8F, 0x0E, 0x0E, 0x1C, 0x18, 0x00, 0x18, 0x0C, 0x38, 0x30,
  0x30, 0xE0, 0x73, 0x80, 0x66, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0xC0, 0x19, 0x80, 0x63, 0x81, 0x83, 0x07, 0x07, 0x1C, 0x06, 0x00, 0x38,
  0x06, 0x70, 0x1C, 0x60, 0x30, 0xC0, 0xC1, 0x81, 0x83, 0x86, 0x03, 0x0C,
  0x06, 0x30, 0x0C, 0x60, 0x19, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xF0,
  0x3F, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x0F,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x0F, 0xC0, 0xF8, 0x00, 0x3C, 0x03, 0xF8, 0x50, 0xFF, 0x01, 0xE0,
};

const GFXglyph LiberationMono_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 16, 15, 5, -16 },
  { 13, 9, 8, 15, 5, -18 },
  { 22, 15, 16, 15, 0, -16 },
  { 52, 15, 20, 15, 0, -18 },
  { 90, 16, 16, 15, 0, -16 },
  { 122, 14, 16, 15, 0, -16 },
  { 150, 4, 8, 15, 7, -18 },
  { 154, 9, 23, 15, 4, -18 },
  { 180, 9, 23, 15, 2, -18 },
  { 206, 9, 9, 15, 4, -18 },
  { 217, 13, 12, 15, 1, -14 },
  { 237, 7, 8, 15, 1, -4 },
  { 244, 7, 2, 15, 4, -7 },
  { 246, 3, 4, 15, 5, -4 },
  { 248, 16, 18, 15, 0, -18 },
  { 284, 13, 16, 15, 1, -16 },
  { 310, 12, 16, 15, 1, -16 },
  { 334, 14, 16, 15, 0, -16 },
  { 362, 13, 16, 15, 1, -16 },
  { 388, 13, 16, 15, 1, -16 },
  { 414, 13, 16, 15, 1, -16 },
  { 440, 12, 16, 15, 2, -16 },
  { 464, 12, 16, 15, 3, -16 },
  { 488, 13, 16, 15, 1, -16 },
  { 514, 13, 16, 15, 1, -16 },
  { 540, 5, 14, 15, 5, -14 },
  { 549, 8, 18, 15, 2, -14 },
  { 567, 13, 13, 15, 1, -15 },
  { 589, 13, 8, 15, 1, -12 },
  { 602, 13, 13, 15, 1, -15 },
  { 624, 12, 16, 15, 2, -16 },
  { 648, 15, 21, 15, 0, -18 },
  { 688, 15, 16, 15, -1, -16 },
  { 718, 13, 16, 15, 1, -16 },
  { 744, 14, 16, 15, 1, -16 },
  { 772, 13, 16, 15, 1, -16 },
  { 798, 14, 16, 15, 1, -16 },
  { 826, 14, 16, 15, 1, -16 },
  { 854, 14, 16, 15, 1, -16 },
  { 882, 14, 16, 15, 1, -16 },
  { 910, 13, 16, 15, 1, -16 },
  { 936, 12, 16, 15, 2, -16 },
  { 960, 15, 16, 15, 1, -16 },
  { 990, 11, 16, 15, 2, -16 },
  { 1012, 15, 16, 15, 0, -16 },
  { 1042, 14, 16, 15, 1, -16 },
  { 1070, 13, 16, 15, 1, -16 },
  { 1096, 14, 16, 15, 1, -16 },
  { 1124, 13, 21, 15, 1, -16 },
  { 1159, 14, 16, 15, 1, -16 },
  { 1187, 15, 16, 15, 0, -16 },
  { 1217, 14, 16, 15, 2, -16 },
  { 1245, 14, 16, 15, 1, -16 },
  { 1273, 15, 16, 15, 2, -16 },
  { 1303, 16, 16, 15, 1, -16 },
  { 1335, 17, 16, 15, -1, -16 },
  { 1369, 14, 16, 15, 2, -16 },
  { 1397, 15, 16, 15, 0, -16 },
  { 1427, 11, 23, 15, 3, -18 },
  { 1459, 8, 18, 15, 4, -18 },
  { 1477, 11, 23, 15, 1, -18 },
  { 1509, 12, 11, 15, 1, -16 },
  { 1526, 15, 1, 15, -2, 2 },
  { 1528, 5, 3, 15, 7, -18 },
  { 1530, 12, 14, 15, 1, -14 },
  { 1551, 13, 18, 15, 1, -18 },
  { 1581, 13, 14, 15, 1, -14 },
  { 1604, 14, 18, 15, 1, -18 },
  { 1636, 13, 14, 15, 1, -14 },
  { 1659, 13, 18, 15, 3, -18 },
  { 1689, 13, 19, 15, 1, -14 },
  { 1720, 12, 18, 15, 1, -18 },
  { 1747, 13, 18, 15, 0, -18 },
  { 1777, 13, 23, 15, -1, -18 },
  { 1815, 13, 18, 15, 2, -18 },
  { 1845, 13, 18, 15, 0, -18 },
  { 1875, 14, 14, 15, 0, -14 },
  { 1900, 12, 14, 15, 1, -14 },
  { 1921, 13, 14, 15, 1, -14 },
  { 1944, 14, 19, 15, 0, -14 },
  { 1978, 13, 19, 15, 1, -14 },
  { 2009, 12, 14, 15, 2, -14 },
  { 2030, 12, 14, 15, 1, -14 },
  { 2051, 10, 17, 15, 3, -17 },
  { 2073, 12, 14, 15, 2, -14 },
  { 2094, 13, 14, 15, 2, -14 },
  { 2117, 15, 14, 15, 1, -14 },
  { 2144, 15, 14, 15, 0, -14 },
  { 2171, 15, 19, 15, 0, -14 },
  { 2207, 13, 14, 15, 1, -14 },
  { 2230, 12, 23, 15, 3, -18 },
  { 2265, 3, 23, 15, 6, -18 },
  { 2274, 12, 23, 15, 0, -18 },
  { 2309, 13, 4, 15, 1, -11 },
};

const GFXfont LiberationMono_Italic25pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic25pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic25pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _LIBERATIONMONO_ITALIC25PT7B_H_
