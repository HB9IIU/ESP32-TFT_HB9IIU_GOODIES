#ifndef _LIBERATIONMONO_ITALIC8PT7B_H_
#define _LIBERATIONMONO_ITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0x56, 0x80, 0x23, 0xD4, 0xCA, 0x00, 0x03, 0xD8, 0x6A, 0xB8,
  0x00, 0xED, 0x9C, 0xDB, 0x80, 0x77, 0x4B, 0xF0, 0x28, 0x29, 0x49, 0x22,
  0x44, 0x94, 0xA0, 0x0D, 0x80, 0x22, 0xF2, 0x48, 0x40, 0x80, 0x08, 0x84,
  0x44, 0x40, 0x7A, 0x6B, 0x26, 0x00, 0x72, 0x22, 0xF0, 0x78, 0x8C, 0x8F,
  0x00, 0x78, 0x8C, 0x27, 0x00, 0x13, 0x5F, 0x20, 0x73, 0x14, 0x27, 0x00,
  0xFC, 0xAA, 0xE0, 0x72, 0x44, 0x80, 0x7A, 0x9D, 0x27, 0x00, 0x75, 0x71,
  0x60, 0x90, 0x42, 0x80, 0x12, 0xC3, 0xF0, 0xF0, 0x86, 0x16, 0xF1, 0x60,
  0x80, 0x32, 0x7F, 0xBE, 0xEB, 0x80, 0x35, 0x5F, 0x90, 0x7A, 0x9D, 0x2F,
  0x00, 0x7A, 0x21, 0x07, 0x00, 0x72, 0x53, 0x2E, 0x00, 0x72, 0x1D, 0x0F,
  0x00, 0x72, 0x1C, 0x88, 0x00, 0x7A, 0x25, 0x27, 0x00, 0x4A, 0x5D, 0x29,
  0x00, 0x71, 0x08, 0x4F, 0x00, 0x24, 0x9C, 0x5B, 0x19, 0x29, 0x00, 0x92,
  0x4E, 0x4A, 0xEB, 0x29, 0x00, 0x4B, 0x5D, 0x69, 0x00, 0x7A, 0x63, 0x26,
  0x00, 0x7A, 0x5D, 0x08, 0x00, 0x7A, 0x63, 0x26, 0x10, 0x00, 0x7A, 0x5D,
  0x29, 0x00, 0x7A, 0x0C, 0x2F, 0x00, 0xF4, 0x44, 0x40, 0x4A, 0x65, 0x27,
  0x00, 0x9A, 0xAC, 0x40, 0x8D, 0x6B, 0xA9, 0x00, 0x49, 0x88, 0xA9, 0x00,
  0x9A, 0x44, 0x40, 0x38, 0x88, 0x8F, 0x00, 0x69, 0x29, 0x26, 0x91, 0x22,
  0x40, 0x31, 0x12, 0x22, 0x2C, 0x35, 0x50, 0xF8, 0x80, 0x77, 0x9F, 0x44,
  0x75, 0x9F, 0x78, 0x87, 0x09, 0x55, 0x29, 0x38, 0x7F, 0x87, 0x34, 0xE8,
  0x88, 0x72, 0xA4, 0xE1, 0x30, 0x44, 0x75, 0x99, 0x10, 0x22, 0x2F, 0x10,
  0x32, 0x22, 0x2C, 0x08, 0xAC, 0xCA, 0x32, 0x22, 0x2F, 0x7D, 0x6D, 0x60,
  0x75, 0x99, 0x79, 0x97, 0x75, 0x9F, 0x88, 0x74, 0xA4, 0xE1, 0x00, 0xE8,
  0x88, 0x76, 0x17, 0x4E, 0x4E, 0x9A, 0xAE, 0x9A, 0xCC, 0x8D, 0x75, 0x20,
  0x51, 0x19, 0x20, 0x4A, 0x98, 0x44, 0x40, 0x32, 0x4F, 0x34, 0x44, 0x88,
  0x84, 0xFF, 0x62, 0x22, 0x22, 0x4C, 0xF0,
};

const GFXglyph LiberationMono_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 5, 5, 2, -5 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 5, 7, 5, 0, -6 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 4, 5, 5, 0, -5 },
  { 20, 2, 3, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -6 },
  { 24, 3, 8, 5, 1, -6 },
  { 27, 3, 3, 5, 1, -6 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 3, 2, 5, 0, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 5, 6, 5, 0, -6 },
  { 38, 5, 5, 5, 0, -5 },
  { 42, 4, 5, 5, 0, -5 },
  { 45, 5, 5, 5, 0, -5 },
  { 49, 5, 5, 5, 0, -5 },
  { 53, 4, 5, 5, 0, -5 },
  { 56, 5, 5, 5, 0, -5 },
  { 60, 4, 5, 5, 1, -5 },
  { 63, 4, 5, 5, 1, -5 },
  { 66, 5, 5, 5, 0, -5 },
  { 70, 4, 5, 5, 0, -5 },
  { 73, 1, 4, 5, 2, -4 },
  { 74, 2, 5, 5, 1, -4 },
  { 76, 4, 4, 5, 0, -5 },
  { 78, 4, 3, 5, 0, -4 },
  { 80, 4, 4, 5, 0, -5 },
  { 82, 4, 5, 5, 1, -5 },
  { 85, 5, 7, 5, 0, -6 },
  { 90, 4, 5, 5, 0, -5 },
  { 93, 5, 5, 5, 0, -5 },
  { 97, 5, 5, 5, 0, -5 },
  { 101, 5, 5, 5, 0, -5 },
  { 105, 5, 5, 5, 0, -5 },
  { 109, 5, 5, 5, 0, -5 },
  { 113, 5, 5, 5, 0, -5 },
  { 117, 5, 5, 5, 0, -5 },
  { 121, 5, 5, 5, 0, -5 },
  { 125, 3, 5, 5, 1, -5 },
  { 127, 5, 5, 5, 0, -5 },
  { 131, 3, 5, 5, 1, -5 },
  { 133, 5, 5, 5, 0, -5 },
  { 137, 5, 5, 5, 0, -5 },
  { 141, 5, 5, 5, 0, -5 },
  { 145, 5, 5, 5, 0, -5 },
  { 149, 5, 7, 5, 0, -5 },
  { 154, 5, 5, 5, 0, -5 },
  { 158, 5, 5, 5, 0, -5 },
  { 162, 4, 5, 5, 1, -5 },
  { 165, 5, 5, 5, 0, -5 },
  { 169, 4, 5, 5, 1, -5 },
  { 172, 5, 5, 5, 0, -5 },
  { 176, 5, 5, 5, 0, -5 },
  { 180, 4, 5, 5, 1, -5 },
  { 183, 5, 5, 5, 0, -5 },
  { 187, 3, 8, 5, 1, -6 },
  { 190, 3, 6, 5, 1, -6 },
  { 193, 4, 8, 5, 0, -6 },
  { 197, 4, 3, 5, 0, -5 },
  { 199, 5, 1, 5, -1, 0 },
  { 200, 2, 1, 5, 2, -6 },
  { 201, 4, 4, 5, 0, -4 },
  { 203, 4, 6, 5, 0, -6 },
  { 206, 4, 4, 5, 0, -4 },
  { 208, 5, 6, 5, 0, -6 },
  { 212, 4, 4, 5, 0, -4 },
  { 214, 4, 6, 5, 1, -6 },
  { 217, 5, 6, 5, 0, -4 },
  { 221, 4, 6, 5, 0, -6 },
  { 224, 4, 6, 5, 0, -6 },
  { 227, 4, 8, 5, 0, -6 },
  { 231, 4, 6, 5, 1, -6 },
  { 234, 4, 6, 5, 0, -6 },
  { 237, 5, 4, 5, 0, -4 },
  { 240, 4, 4, 5, 0, -4 },
  { 242, 4, 4, 5, 0, -4 },
  { 244, 4, 6, 5, 0, -4 },
  { 247, 5, 6, 5, 0, -4 },
  { 251, 4, 4, 5, 1, -4 },
  { 253, 4, 4, 5, 0, -4 },
  { 255, 3, 5, 5, 1, -5 },
  { 257, 4, 4, 5, 1, -4 },
  { 259, 4, 4, 5, 1, -4 },
  { 261, 5, 4, 5, 0, -4 },
  { 264, 5, 4, 5, 0, -4 },
  { 267, 5, 6, 5, 0, -4 },
  { 271, 4, 4, 5, 0, -4 },
  { 273, 4, 8, 5, 1, -6 },
  { 277, 1, 8, 5, 2, -6 },
  { 278, 4, 8, 5, 0, -6 },
  { 282, 5, 1, 5, 0, -3 },
};

const GFXfont LiberationMono_Italic8pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic8pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _LIBERATIONMONO_ITALIC8PT7B_H_
