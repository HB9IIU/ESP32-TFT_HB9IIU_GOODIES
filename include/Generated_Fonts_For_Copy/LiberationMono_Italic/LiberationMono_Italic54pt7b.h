#ifndef _LIBERATIONMONO_ITALIC54PT7B_H_
#define _LIBERATIONMONO_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF3, 0xF0, 0x3F,
  0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x38, 0xFE, 0x03, 0xF0, 0x70,
  0x7E, 0x07, 0xC0, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x03, 0xE0, 0x70, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x07, 0xF3, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC3, 0xF8, 0x00,
  0x03, 0x83, 0xF0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0x87, 0x00, 0xE0, 0x1E, 0x3E, 0x01,
  0xC0, 0x3C, 0x7C, 0x07, 0x80, 0xF8, 0xFC, 0x0F, 0x03, 0xE0, 0xFC, 0x1C,
  0x0F, 0xC1, 0xFE, 0x38, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x03, 0xFF,
  0xC0, 0x03, 0xC0, 0x3C, 0x3E, 0x00, 0x38, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x0E, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x1E, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0x3C, 0x1C, 0x00, 0x1E, 0x03, 0xC3, 0xC0, 0x01,
  0xE0, 0x78, 0x78, 0x00, 0x1F, 0x0F, 0x0F, 0x00, 0x00, 0xFF, 0xF1, 0xE0,
  0x00, 0x07, 0xFC, 0x3C, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00,
  0x00, 0x3C, 0x7F, 0xE0, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x00, 0xF1, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0x78,
  0x3C, 0x07, 0x80, 0x07, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x78, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x3C, 0x00,
  0x7C, 0x3C, 0x03, 0x80, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x00,
  0x07, 0x83, 0xF0, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0xFF, 0x80,
  0x1E, 0x0F, 0xBE, 0x00, 0xF0, 0xF9, 0xF0, 0x0F, 0x0F, 0x87, 0x80, 0x78,
  0xF8, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x78, 0x07, 0xC3, 0xC3, 0xC0,
  0x1E, 0x1E, 0x3E, 0x00, 0xF9, 0xE1, 0xF0, 0x03, 0xEF, 0x0F, 0x00, 0x1F,
  0xF0, 0x7C, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xF1, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0xF0, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0xC1, 0xE0, 0xDE, 0x38, 0x7F, 0xF7, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xF0, 0x07, 0x8E,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0E, 0x03, 0x80, 0x40, 0x40, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xE3, 0xE1, 0xFC, 0x3E, 0x7C, 0x1F,
  0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E,
  0x7C, 0x3F, 0x83, 0xC7, 0x83, 0xF0, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x7C, 0x00,
  0xFF, 0xCF, 0x00, 0x1F, 0xF3, 0xE0, 0x07, 0xF8, 0x7C, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0xF8,
  0x01, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x3E,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x81,
  0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x81, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0x1F,
  0xFE, 0x01, 0xE7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xE1,
  0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x80, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x01, 0xFC, 0x7C, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xE1, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFF, 0xEF, 0x81, 0xFF, 0xF9, 0xE0, 0x1F, 0xFC, 0x3C, 0x00,
  0xFE, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x07, 0xE3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x1F, 0x00, 0xE0, 0x70, 0x3F, 0xCE, 0x70, 0x78,
  0x3F, 0xE7, 0x38, 0x38, 0x3E, 0x3B, 0x9C, 0x3C, 0x3C, 0x0F, 0x8E, 0x1C,
  0x3C, 0x07, 0xC7, 0x1E, 0x1C, 0x03, 0xC3, 0x8E, 0x1E, 0x01, 0xE3, 0xC7,
  0x1E, 0x00, 0xE1, 0xC7, 0x8F, 0x00, 0xF0, 0xE3, 0x87, 0x00, 0x78, 0x71,
  0xC7, 0x80, 0x38, 0x39, 0xE3, 0x80, 0x3C, 0x38, 0xF3, 0xC0, 0x1C, 0x1C,
  0x71, 0xE0, 0x0E, 0x0E, 0x38, 0xF0, 0x0F, 0x0E, 0x1C, 0x70, 0x07, 0x07,
  0x0E, 0x38, 0x07, 0x87, 0x8F, 0x1C, 0x07, 0x83, 0x87, 0x8E, 0x03, 0xC3,
  0xC3, 0xC7, 0x03, 0xE3, 0xC1, 0xE3, 0xC7, 0x73, 0xC0, 0xF1, 0xFF, 0x3F,
  0xC0, 0x78, 0x7F, 0x1F, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x08, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x30, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x81, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xF0, 0x1F, 0xF0,
  0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0xF0, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7C, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xFF,
  0xF8, 0xF8, 0x07, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0x7E, 0x01, 0xFF, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xE0,
  0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0xC0, 0x3F, 0x80, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1E,
  0x3F, 0x00, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xBC, 0x03, 0xDE, 0x07, 0xBC,
  0x03, 0xFE, 0x07, 0xBC, 0x07, 0xBE, 0x07, 0xBE, 0x07, 0xBC, 0x07, 0xBE,
  0x0F, 0x3C, 0x0F, 0x9E, 0x0F, 0x3C, 0x0F, 0x1E, 0x1E, 0x7C, 0x0F, 0x1E,
  0x3C, 0x7C, 0x0F, 0x1E, 0x3C, 0x78, 0x0F, 0x1E, 0x78, 0x78, 0x1F, 0x0F,
  0x78, 0x78, 0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F,
  0xE0, 0xF0, 0x1E, 0x0F, 0xE0, 0xF0, 0x3E, 0x0F, 0xC0, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xF8,
  0x00, 0x7C, 0x07, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xC0,
  0x03, 0xC0, 0x7F, 0xC0, 0x07, 0x80, 0xF7, 0x80, 0x1F, 0x01, 0xEF, 0x00,
  0x3E, 0x03, 0xDF, 0x00, 0x7C, 0x07, 0xBE, 0x00, 0xF0, 0x1F, 0x3C, 0x01,
  0xE0, 0x3E, 0x78, 0x07, 0xC0, 0x78, 0xF8, 0x0F, 0x80, 0xF1, 0xF0, 0x1F,
  0x01, 0xE1, 0xE0, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x87, 0xC0, 0xF0,
  0x1F, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x0F, 0x81,
  0xF0, 0x3E, 0x1E, 0x03, 0xE0, 0x7C, 0x3C, 0x07, 0xC0, 0x78, 0xF8, 0x0F,
  0x00, 0xF9, 0xF0, 0x1E, 0x01, 0xF3, 0xE0, 0x7C, 0x01, 0xE7, 0x80, 0xF8,
  0x03, 0xCF, 0x01, 0xF0, 0x07, 0xDE, 0x03, 0xC0, 0x0F, 0xBC, 0x07, 0x80,
  0x0F, 0xF8, 0x0F, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x7C, 0x00,
  0x7F, 0x80, 0xF0, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0xFE, 0x03, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xC0, 0x7C,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFE,
  0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x03, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0xC1, 0xE0, 0x1F, 0x01, 0xF0, 0x78, 0x0F, 0xC0, 0x78, 0x1E,
  0x03, 0xF0, 0x3E, 0x07, 0x81, 0xFC, 0x0F, 0x81, 0xE0, 0x7F, 0x03, 0xC0,
  0x78, 0x3F, 0xC1, 0xF0, 0x3E, 0x0F, 0xF0, 0x78, 0x0F, 0x87, 0xBC, 0x1E,
  0x03, 0xE1, 0xEF, 0x0F, 0x80, 0xF8, 0x71, 0xC3, 0xC0, 0x3E, 0x3C, 0x70,
  0xF0, 0x0F, 0x8E, 0x1C, 0x7C, 0x03, 0xE7, 0x87, 0x1E, 0x00, 0xF9, 0xE1,
  0xE7, 0x80, 0x3C, 0xF0, 0x79, 0xE0, 0x0F, 0x3C, 0x1E, 0xF0, 0x03, 0xCE,
  0x07, 0xBC, 0x00, 0xF7, 0x81, 0xEF, 0x00, 0x3D, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F,
  0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF8, 0xF8,
  0x01, 0xFE, 0x3F, 0x00, 0xEF, 0x8F, 0xE0, 0xF3, 0xE3, 0xFF, 0xF8, 0xFF,
  0x7F, 0xFC, 0x3F, 0xCF, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x1F, 0xC0, 0x0F, 0x1F, 0xFC, 0x03,
  0xE7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xC1, 0xFE, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x0F, 0xE0, 0x07, 0xE1, 0xFE, 0x01, 0xF8, 0x3D, 0xE0, 0x7E, 0x07,
  0xBF, 0xFF, 0xC1, 0xF3, 0xFF, 0xE0, 0x3E, 0x3F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x3F,
  0xF8, 0xF8, 0x03, 0xFF, 0xE7, 0xC0, 0x3F, 0xFF, 0xBE, 0x03, 0xF8, 0x3D,
  0xF0, 0x3F, 0x00, 0x7F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x0F, 0x78, 0x07, 0xFF, 0xF3, 0xC0,
  0x1F, 0xFF, 0x3E, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x60, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0x87, 0x80, 0x3F, 0xFE, 0x3C, 0x03, 0xFF, 0xFB, 0xE0,
  0x3F, 0x83, 0xDF, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0x81, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x1E, 0xF8, 0x0F, 0xFF, 0xE7, 0xC0, 0x3F,
  0xFE, 0x3C, 0x00, 0xFF, 0xE3, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0xC0,
  0x0F, 0x1F, 0xFE, 0x03, 0xE7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x0F, 0xFC,
  0x1F, 0xC1, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3C, 0x0F, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3C, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00,
  0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0xF8, 0x0F, 0x3F, 0xC7, 0xF8, 0x1E, 0xFF, 0x9F, 0xF8, 0x3D, 0xFF, 0x3F,
  0xF0, 0x7F, 0x1E, 0xE3, 0xE0, 0xFC, 0x3F, 0x87, 0xC3, 0xF0, 0x7E, 0x07,
  0x87, 0xC0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C,
  0x3C, 0x07, 0x80, 0xF8, 0xF8, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x03, 0xC3,
  0xE0, 0x7C, 0x07, 0x87, 0x80, 0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0x3E, 0x1E,
  0x03, 0xC0, 0x78, 0x7C, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x01, 0xE1, 0xE0,
  0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x1E, 0x1F, 0x01,
  0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0x78, 0x7C, 0x0F, 0x81, 0xF0, 0xF0, 0x1F,
  0x03, 0xE1, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x0F, 0x80, 0xF0,
  0x1E, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x7F,
  0xF0, 0x1F, 0x3F, 0xFF, 0x03, 0xEF, 0xFF, 0xE0, 0x7B, 0xE0, 0xFE, 0x0F,
  0xF0, 0x0F, 0xC3, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x8F, 0xFF,
  0x00, 0x7C, 0xFF, 0xFC, 0x03, 0xEF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0x80,
  0xF7, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x7F, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xC0, 0x3D, 0xFF, 0xFE, 0x03, 0xE7,
  0xFF, 0xE0, 0x1F, 0x1F, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xFC, 0x3C, 0x07, 0xFF, 0xCF, 0x81, 0xFF, 0xFD, 0xF0,
  0x7F, 0x07, 0xBE, 0x1F, 0x80, 0x3F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0xC1, 0xFC, 0x1E, 0xF0, 0x3F, 0xFF, 0x9E, 0x03, 0xFF, 0xE7, 0xC0,
  0x3F, 0xF8, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xC1, 0xFF, 0xC3,
  0xE1, 0xFF, 0xE1, 0xF1, 0xFF, 0xF0, 0xF9, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0x3E, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0xC1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0x7C, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x03, 0xFC, 0x3F, 0x03, 0xDF, 0x0F, 0xFF,
  0xF7, 0x81, 0xFF, 0xF1, 0xE0, 0x7F, 0xF8, 0x78, 0x07, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x80, 0xF0, 0xF8, 0x1F,
  0x81, 0xF0, 0xF8, 0x3F, 0x81, 0xE0, 0xF8, 0x3B, 0x81, 0xE0, 0xF0, 0x7B,
  0xC3, 0xE0, 0xF0, 0x73, 0xC3, 0xC0, 0xF0, 0xF3, 0xC7, 0xC0, 0xF0, 0xE3,
  0xC7, 0xC0, 0xF1, 0xE3, 0xC7, 0x80, 0xF1, 0xC1, 0xCF, 0x80, 0xF3, 0xC1,
  0xCF, 0x80, 0xF3, 0x81, 0xCF, 0x00, 0xF7, 0x81, 0xCF, 0x00, 0xF7, 0x01,
  0xDE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0x7F, 0xFF, 0xC0,
  0xE7, 0xFF, 0xFF, 0xFE, 0xF0, 0x3F, 0xFF, 0xE8, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0x00,
};

const GFXglyph LiberationMono_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 36, 32, 11, -36 },
  { 55, 20, 17, 32, 10, -39 },
  { 98, 32, 36, 32, 1, -36 },
  { 242, 31, 43, 32, 1, -39 },
  { 409, 36, 38, 32, -1, -37 },
  { 580, 29, 38, 32, 0, -37 },
  { 718, 8, 17, 32, 16, -39 },
  { 735, 20, 50, 32, 8, -39 },
  { 860, 20, 50, 32, 4, -39 },
  { 985, 19, 19, 32, 10, -39 },
  { 1031, 26, 26, 32, 3, -31 },
  { 1116, 15, 17, 32, 2, -8 },
  { 1148, 16, 4, 32, 8, -16 },
  { 1156, 8, 8, 32, 10, -8 },
  { 1164, 34, 40, 32, 0, -39 },
  { 1334, 28, 38, 32, 3, -37 },
  { 1467, 27, 36, 32, 1, -36 },
  { 1589, 30, 37, 32, 1, -37 },
  { 1728, 29, 38, 32, 2, -37 },
  { 1866, 27, 36, 32, 2, -36 },
  { 1988, 29, 37, 32, 2, -36 },
  { 2123, 27, 38, 32, 4, -37 },
  { 2252, 24, 36, 32, 8, -36 },
  { 2360, 29, 38, 32, 2, -37 },
  { 2498, 27, 38, 32, 3, -37 },
  { 2627, 12, 29, 32, 10, -29 },
  { 2671, 17, 38, 32, 5, -29 },
  { 2752, 26, 27, 32, 3, -31 },
  { 2840, 26, 17, 32, 3, -26 },
  { 2896, 26, 27, 32, 3, -31 },
  { 2984, 26, 37, 32, 5, -37 },
  { 3105, 33, 45, 32, 0, -39 },
  { 3291, 33, 36, 32, -3, -36 },
  { 3440, 30, 36, 32, 1, -36 },
  { 3575, 29, 38, 32, 3, -37 },
  { 3713, 30, 36, 32, 1, -36 },
  { 3848, 32, 36, 32, 1, -36 },
  { 3992, 31, 36, 32, 2, -36 },
  { 4132, 29, 38, 32, 3, -37 },
  { 4270, 31, 36, 32, 1, -36 },
  { 4410, 28, 36, 32, 3, -36 },
  { 4536, 26, 37, 32, 4, -36 },
  { 4657, 33, 36, 32, 1, -36 },
  { 4806, 24, 36, 32, 3, -36 },
  { 4914, 32, 36, 32, 1, -36 },
  { 5058, 31, 36, 32, 1, -36 },
  { 5198, 28, 38, 32, 3, -37 },
  { 5331, 31, 36, 32, 1, -36 },
  { 5471, 28, 48, 32, 3, -37 },
  { 5639, 31, 36, 32, 1, -36 },
  { 5779, 30, 38, 32, 1, -37 },
  { 5922, 30, 36, 32, 5, -36 },
  { 6057, 30, 37, 32, 3, -36 },
  { 6196, 32, 36, 32, 4, -36 },
  { 6340, 34, 36, 32, 3, -36 },
  { 6493, 37, 36, 32, -2, -36 },
  { 6660, 31, 36, 32, 5, -36 },
  { 6800, 34, 36, 32, -1, -36 },
  { 6953, 24, 50, 32, 6, -39 },
  { 7103, 19, 40, 32, 8, -39 },
  { 7198, 24, 50, 32, 2, -39 },
  { 7348, 25, 24, 32, 3, -36 },
  { 7423, 33, 3, 32, -4, 3 },
  { 7436, 10, 7, 32, 15, -39 },
  { 7445, 26, 31, 32, 2, -30 },
  { 7546, 27, 40, 32, 2, -39 },
  { 7681, 27, 31, 32, 3, -30 },
  { 7786, 29, 40, 32, 3, -39 },
  { 7931, 26, 31, 32, 3, -30 },
  { 8032, 28, 39, 32, 6, -39 },
  { 8169, 29, 41, 32, 2, -30 },
  { 8318, 27, 39, 32, 2, -39 },
  { 8450, 27, 39, 32, 1, -39 },
  { 8582, 29, 50, 32, -2, -39 },
  { 8764, 29, 39, 32, 3, -39 },
  { 8906, 26, 39, 32, 1, -39 },
  { 9033, 31, 30, 32, 0, -30 },
  { 9150, 27, 30, 32, 2, -30 },
  { 9252, 26, 31, 32, 3, -30 },
  { 9353, 29, 41, 32, 0, -30 },
  { 9502, 27, 41, 32, 3, -30 },
  { 9641, 25, 30, 32, 5, -30 },
  { 9735, 26, 31, 32, 3, -30 },
  { 9836, 21, 37, 32, 7, -36 },
  { 9934, 26, 30, 32, 4, -29 },
  { 10032, 28, 29, 32, 5, -29 },
  { 10134, 32, 29, 32, 3, -29 },
  { 10250, 32, 29, 32, 0, -29 },
  { 10366, 33, 40, 32, 0, -29 },
  { 10531, 29, 29, 32, 1, -29 },
  { 10637, 27, 50, 32, 6, -39 },
  { 10806, 4, 50, 32, 14, -39 },
  { 10831, 28, 50, 32, -1, -39 },
  { 11006, 28, 7, 32, 3, -22 },
};

const GFXfont LiberationMono_Italic54pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic54pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic54pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _LIBERATIONMONO_ITALIC54PT7B_H_
