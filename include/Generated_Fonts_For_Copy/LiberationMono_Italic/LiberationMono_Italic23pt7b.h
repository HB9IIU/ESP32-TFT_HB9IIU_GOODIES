#ifndef _LIBERATIONMONO_ITALIC23PT7B_H_
#define _LIBERATIONMONO_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x18, 0x8C, 0x63, 0x18, 0x00, 0x63, 0x00, 0x73,
  0xB1, 0x98, 0xCC, 0x64, 0x36, 0x33, 0x18, 0x01, 0x08, 0x08, 0x60, 0x21,
  0x01, 0x04, 0x3F, 0xFC, 0x30, 0x80, 0x86, 0x02, 0x10, 0x18, 0x43, 0xFF,
  0xC3, 0x08, 0x08, 0x60, 0x21, 0x01, 0x84, 0x04, 0x20, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x7F, 0x03, 0xFE, 0x1C, 0x98, 0x66, 0x33, 0x18, 0x06, 0x40,
  0x1F, 0x80, 0x1F, 0xC0, 0x37, 0x00, 0xC6, 0x02, 0x1B, 0x08, 0xC6, 0x27,
  0x1F, 0xF8, 0x3F, 0x80, 0x10, 0x00, 0x40, 0x00, 0x1E, 0x04, 0x64, 0x11,
  0x8C, 0x63, 0x19, 0x86, 0x26, 0x0C, 0xD8, 0x19, 0xE0, 0x1D, 0xBC, 0x06,
  0x88, 0x0B, 0x10, 0x26, 0x20, 0x88, 0x43, 0x11, 0x8C, 0x32, 0x30, 0x38,
  0x00, 0x03, 0xE0, 0x7F, 0x0C, 0x30, 0xC2, 0x0C, 0x60, 0xF8, 0x1E, 0x03,
  0x61, 0x66, 0x3C, 0x32, 0xC3, 0x6C, 0x1C, 0xE1, 0xCF, 0xFF, 0x3C, 0x70,
  0x7F, 0xED, 0xA0, 0x03, 0x81, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0xC0, 0x0C, 0x08, 0x49, 0x3E, 0x18, 0x3C, 0x6C, 0x44, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x1C, 0x63, 0x0C, 0x61, 0x0C, 0x00, 0xFF, 0xF0, 0x76,
  0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xFE,
  0x18, 0x73, 0x03, 0x30, 0x36, 0x03, 0x67, 0x36, 0x73, 0x66, 0x6C, 0x06,
  0xC0, 0x6E, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x01, 0x80, 0x70, 0x3E,
  0x1E, 0xC3, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x7F, 0xC7, 0x0E, 0x30, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0x38, 0x73, 0x03,
  0x00, 0x30, 0x0E, 0x07, 0x80, 0xFC, 0x00, 0xE0, 0x06, 0xC0, 0x6C, 0x0E,
  0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xB0, 0x6C,
  0x19, 0x86, 0x31, 0x86, 0x60, 0xD8, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03,
  0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0x18, 0x03, 0x00, 0x30, 0x03, 0xF8, 0x7F,
  0xE7, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x6C, 0x0E, 0xE1, 0xC7, 0xF8, 0x3E,
  0x00, 0x07, 0xC3, 0xFC, 0xE1, 0x98, 0x06, 0x00, 0xDF, 0x37, 0xF7, 0x0E,
  0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xEE, 0x38, 0xFE, 0x0F, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0xC1, 0xFF, 0x38, 0x73,
  0x03, 0x30, 0x33, 0x06, 0x1F, 0xC1, 0xFC, 0x70, 0xE6, 0x06, 0xC0, 0x6C,
  0x0E, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03,
  0x30, 0x36, 0x03, 0x60, 0x77, 0x0F, 0x3F, 0xE1, 0xE6, 0x00, 0xEC, 0x0C,
  0x61, 0x87, 0xF0, 0x3E, 0x00, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xCE, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xC3, 0x86, 0x18, 0x20, 0xC0, 0x00, 0x20, 0x3C, 0x3F, 0x1F, 0x0F, 0x81,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x1E, 0x00, 0x40, 0x78, 0x7E, 0x3E, 0x1F, 0x03, 0x00, 0x00, 0x0F,
  0x87, 0xFD, 0xC3, 0xB0, 0x3C, 0x06, 0x01, 0x80, 0x70, 0x18, 0x0E, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xF0, 0x18, 0x60,
  0xC0, 0x86, 0x03, 0x11, 0xD4, 0xC9, 0xD2, 0x46, 0x5B, 0x19, 0x48, 0x6D,
  0x61, 0x35, 0x8C, 0xB6, 0x32, 0xD0, 0x9B, 0x46, 0x4D, 0x2A, 0x37, 0x30,
  0xC0, 0x01, 0x01, 0x06, 0x1C, 0x07, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x0C, 0x30, 0x7F,
  0xE3, 0xFF, 0x8C, 0x06, 0x70, 0x19, 0x80, 0x6C, 0x01, 0xC0, 0x3F, 0xC3,
  0xFF, 0x30, 0x73, 0x03, 0x30, 0x33, 0x06, 0x7F, 0xC7, 0xFC, 0x60, 0x66,
  0x07, 0x60, 0x7C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0x00, 0x07, 0xE0, 0x7F,
  0x87, 0x0C, 0x60, 0x67, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x19, 0xC0, 0xC7, 0x1C, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0x83,
  0xFE, 0x30, 0xF3, 0x03, 0x30, 0x33, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36,
  0x06, 0x60, 0x6C, 0x0C, 0xC3, 0xCF, 0xF8, 0xFE, 0x00, 0x3F, 0xF9, 0xFF,
  0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xFF, 0x8F, 0xFC, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0xCE, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0x8F, 0xFC, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0x1C, 0x33, 0x03, 0x70, 0x06, 0x00, 0x63, 0xF6, 0x3E, 0xE0,
  0x6E, 0x06, 0xE0, 0x6E, 0x06, 0x70, 0xE7, 0xFC, 0x1F, 0x00, 0x38, 0x39,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x39, 0xFF, 0x8F, 0xFC, 0x60,
  0x63, 0x03, 0x18, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x00, 0x1F,
  0xF1, 0xFF, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xE0,
  0xFC, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x33,
  0x06, 0x61, 0x8C, 0x71, 0xFC, 0x1F, 0x00, 0x38, 0x18, 0xC1, 0xC3, 0x0E,
  0x0C, 0x70, 0x33, 0x80, 0xDC, 0x06, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0x8E,
  0x06, 0x18, 0x30, 0x70, 0xC0, 0xC3, 0x03, 0x8C, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xFF, 0x9F, 0xF0, 0x1C, 0x1C, 0x70, 0x71, 0x43,
  0xC5, 0x8A, 0x36, 0x78, 0xDB, 0x63, 0x6D, 0x8D, 0xE6, 0x23, 0x11, 0x8C,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x8C, 0x06, 0x00, 0x38, 0x19,
  0xC0, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x13, 0x19, 0x98, 0x8C, 0xCC, 0x66,
  0x63, 0x1B, 0x10, 0xD9, 0x86, 0x8C, 0x14, 0x60, 0xE3, 0x07, 0x00, 0x07,
  0xC1, 0xFE, 0x18, 0x73, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0,
  0x7C, 0x06, 0xC0, 0x6E, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x3F, 0xE1,
  0xFF, 0x8C, 0x0C, 0x60, 0x73, 0x03, 0x18, 0x19, 0x81, 0xCF, 0xFC, 0x7F,
  0x83, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07,
  0xC1, 0xFE, 0x18, 0x73, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0,
  0x7C, 0x06, 0xC0, 0x6E, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0xC0, 0x3C, 0x3F, 0xE1, 0xFF, 0x8C, 0x0E, 0x60, 0x73,
  0x03, 0x18, 0x39, 0xFF, 0x8F, 0xF0, 0x63, 0x03, 0x1C, 0x18, 0x61, 0x83,
  0x8C, 0x0C, 0x60, 0x63, 0x03, 0x80, 0x03, 0xF0, 0x7F, 0xC7, 0x06, 0x30,
  0x31, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x70, 0x01, 0x80, 0x0D,
  0xC0, 0x66, 0x07, 0x3F, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x19, 0x80, 0xCC,
  0x0C, 0x60, 0x67, 0x03, 0x30, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0x67, 0x03,
  0x30, 0x19, 0x81, 0x8E, 0x1C, 0x3F, 0xC0, 0xFC, 0x00, 0xC0, 0x1E, 0x01,
  0xF8, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x73, 0x81,
  0x98, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x63, 0x11, 0xCC, 0x63,
  0x98, 0xCF, 0x31, 0x92, 0xC3, 0x65, 0x86, 0x8A, 0x0F, 0x1C, 0x1C, 0x38,
  0x38, 0x60, 0x00, 0x0C, 0x06, 0x0E, 0x0C, 0x06, 0x18, 0x07, 0x38, 0x03,
  0x30, 0x03, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x0C,
  0x60, 0x1C, 0x70, 0x38, 0x30, 0x30, 0x30, 0x60, 0x18, 0xE0, 0x3B, 0x01,
  0x9C, 0x18, 0x61, 0x83, 0x18, 0x0D, 0x80, 0x78, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xE0, 0xFC, 0x00, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0xFC, 0x3F, 0x00, 0x03, 0x80, 0x70, 0x1A, 0x06, 0x60, 0x8C,
  0x31, 0x8C, 0x11, 0x83, 0x60, 0x68, 0x0C, 0xFF, 0xFC, 0x61, 0x86, 0x0F,
  0x83, 0xF8, 0xE3, 0x98, 0x30, 0x06, 0x3F, 0x9F, 0xF3, 0x06, 0xC0, 0xD8,
  0x3B, 0x0F, 0x7E, 0x77, 0x8E, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x33,
  0xC3, 0x7E, 0x38, 0x63, 0x07, 0x70, 0x76, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x6E, 0x0C, 0xF1, 0xCD, 0xF8, 0xDF, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x67,
  0x07, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0E, 0x0E, 0x61, 0xC7,
  0xF8, 0x3E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xF3, 0x0F,
  0xD8, 0xE3, 0xCE, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x81, 0xCC, 0x0C,
  0x60, 0x63, 0x8F, 0x0F, 0xD8, 0x3C, 0xC0, 0x07, 0xC3, 0xFC, 0xE1, 0xB8,
  0x36, 0x06, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x1C, 0x19, 0x87, 0x3F, 0xC3,
  0xE0, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x7F, 0xEF, 0xFE, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x06, 0x60, 0x66, 0x06,
  0x60, 0x6E, 0x06, 0xC0, 0xCE, 0x0C, 0xE3, 0xC7, 0xEC, 0x3C, 0xC0, 0x18,
  0xC1, 0x8E, 0x38, 0xFF, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x3C, 0x6F, 0xCE, 0x19, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C,
  0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0xFE, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x83, 0x08, 0x60, 0xC6, 0x06, 0x60, 0x3E, 0x01, 0xF0, 0x08, 0xC0, 0x46,
  0x06, 0x30, 0x30, 0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x07, 0xFF, 0xFF, 0xE0, 0x37,
  0x39, 0xFB, 0xCE, 0xE6, 0x63, 0x33, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x62,
  0x63, 0x33, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x63, 0x00, 0x33, 0xC6, 0xFC,
  0xE1, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xCC, 0x1B, 0x03,
  0x60, 0x6C, 0x0C, 0x07, 0xC1, 0xFE, 0x38, 0x67, 0x07, 0x60, 0x76, 0x06,
  0xE0, 0x6C, 0x06, 0xC0, 0x6E, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x19,
  0xE0, 0xDF, 0x87, 0x0C, 0x30, 0x73, 0x83, 0x98, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x31, 0x83, 0x1E, 0x38, 0xDF, 0x86, 0xF8, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x6C, 0x0E, 0xC0, 0xCC, 0x0C, 0xE3, 0xC7, 0xEC, 0x3C,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x33, 0xE6, 0xFC, 0xF0,
  0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x00, 0x0F, 0xC3, 0xFC, 0xC1, 0x98, 0x03, 0x00, 0x7C, 0x07, 0xE0,
  0x0E, 0x00, 0xC0, 0x1B, 0x03, 0x3F, 0xC3, 0xF0, 0x18, 0x0C, 0x0C, 0x1F,
  0xFF, 0xF9, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x07, 0x03,
  0xF8, 0xFC, 0x60, 0x6C, 0x0D, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xB0, 0x36,
  0x06, 0xC1, 0x98, 0x33, 0x0E, 0x7E, 0xC7, 0x98, 0xC0, 0x3C, 0x06, 0xE0,
  0x66, 0x0C, 0x61, 0xC6, 0x18, 0x63, 0x87, 0x30, 0x36, 0x03, 0x60, 0x3C,
  0x03, 0xC0, 0x38, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC7,
  0x33, 0x1C, 0xCC, 0xF3, 0x32, 0xD8, 0xDB, 0x63, 0x45, 0x0F, 0x1C, 0x38,
  0x70, 0xE1, 0x80, 0x18, 0x18, 0x60, 0xC0, 0xC6, 0x03, 0x38, 0x06, 0xC0,
  0x1E, 0x00, 0x30, 0x01, 0xE0, 0x0D, 0x80, 0x63, 0x03, 0x0C, 0x18, 0x18,
  0xC0, 0x60, 0x30, 0x0C, 0xC0, 0x63, 0x81, 0x86, 0x0C, 0x18, 0x30, 0x61,
  0x81, 0x86, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xF0, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x70,
  0x0F, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0xF0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x0F, 0xC1, 0xF0, 0x00, 0x3C, 0x07, 0xF1, 0xC7, 0xF0, 0x1E,
};

const GFXglyph LiberationMono_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 15, 14, 5, -15 },
  { 11, 9, 7, 14, 4, -17 },
  { 19, 14, 15, 14, 0, -15 },
  { 46, 14, 19, 14, 0, -17 },
  { 80, 15, 15, 14, 0, -15 },
  { 109, 12, 15, 14, 0, -15 },
  { 132, 3, 7, 14, 7, -17 },
  { 135, 9, 22, 14, 3, -17 },
  { 160, 8, 22, 14, 2, -17 },
  { 182, 8, 8, 14, 4, -17 },
  { 190, 11, 12, 14, 1, -14 },
  { 207, 6, 7, 14, 1, -3 },
  { 213, 6, 2, 14, 4, -7 },
  { 215, 4, 3, 14, 4, -3 },
  { 217, 15, 17, 14, 0, -17 },
  { 249, 12, 15, 14, 1, -15 },
  { 272, 11, 15, 14, 1, -15 },
  { 293, 13, 15, 14, 0, -15 },
  { 318, 12, 15, 14, 1, -15 },
  { 341, 11, 15, 14, 1, -15 },
  { 362, 12, 15, 14, 1, -15 },
  { 385, 11, 15, 14, 2, -15 },
  { 406, 11, 15, 14, 3, -15 },
  { 427, 12, 15, 14, 1, -15 },
  { 450, 12, 15, 14, 1, -15 },
  { 473, 5, 13, 14, 4, -13 },
  { 482, 7, 17, 14, 2, -13 },
  { 497, 11, 11, 14, 1, -13 },
  { 513, 11, 7, 14, 1, -11 },
  { 523, 11, 11, 14, 1, -13 },
  { 539, 11, 15, 14, 2, -15 },
  { 560, 14, 20, 14, 0, -17 },
  { 595, 14, 15, 14, -1, -15 },
  { 622, 12, 15, 14, 1, -15 },
  { 645, 13, 15, 14, 1, -15 },
  { 670, 12, 15, 14, 1, -15 },
  { 693, 13, 15, 14, 1, -15 },
  { 718, 13, 15, 14, 1, -15 },
  { 743, 12, 15, 14, 1, -15 },
  { 766, 13, 15, 14, 1, -15 },
  { 791, 12, 15, 14, 1, -15 },
  { 814, 11, 15, 14, 2, -15 },
  { 835, 14, 15, 14, 1, -15 },
  { 862, 11, 15, 14, 1, -15 },
  { 883, 14, 15, 14, 0, -15 },
  { 910, 13, 15, 14, 1, -15 },
  { 935, 12, 15, 14, 1, -15 },
  { 958, 13, 15, 14, 1, -15 },
  { 983, 12, 20, 14, 1, -15 },
  { 1013, 13, 15, 14, 1, -15 },
  { 1038, 13, 15, 14, 0, -15 },
  { 1063, 13, 15, 14, 2, -15 },
  { 1088, 13, 15, 14, 1, -15 },
  { 1113, 13, 15, 14, 2, -15 },
  { 1138, 15, 15, 14, 1, -15 },
  { 1167, 16, 15, 14, -1, -15 },
  { 1197, 13, 15, 14, 2, -15 },
  { 1222, 14, 15, 14, 0, -15 },
  { 1249, 11, 22, 14, 2, -17 },
  { 1280, 8, 17, 14, 3, -17 },
  { 1297, 10, 22, 14, 1, -17 },
  { 1325, 11, 10, 14, 1, -15 },
  { 1339, 14, 1, 14, -2, 1 },
  { 1341, 5, 3, 14, 6, -17 },
  { 1343, 11, 13, 14, 1, -13 },
  { 1361, 12, 17, 14, 1, -17 },
  { 1387, 12, 13, 14, 1, -13 },
  { 1407, 13, 17, 14, 1, -17 },
  { 1435, 11, 13, 14, 1, -13 },
  { 1453, 12, 17, 14, 2, -17 },
  { 1479, 12, 18, 14, 1, -13 },
  { 1506, 11, 17, 14, 1, -17 },
  { 1530, 12, 17, 14, 0, -17 },
  { 1556, 12, 22, 14, -1, -17 },
  { 1589, 13, 17, 14, 1, -17 },
  { 1617, 12, 17, 14, 0, -17 },
  { 1643, 13, 13, 14, 0, -13 },
  { 1665, 11, 13, 14, 1, -13 },
  { 1683, 12, 13, 14, 1, -13 },
  { 1703, 13, 18, 14, 0, -13 },
  { 1733, 12, 18, 14, 1, -13 },
  { 1760, 11, 13, 14, 2, -13 },
  { 1778, 11, 13, 14, 1, -13 },
  { 1796, 9, 16, 14, 3, -16 },
  { 1814, 11, 13, 14, 2, -13 },
  { 1832, 12, 13, 14, 2, -13 },
  { 1852, 14, 13, 14, 1, -13 },
  { 1875, 14, 13, 14, 0, -13 },
  { 1898, 14, 18, 14, 0, -13 },
  { 1930, 13, 13, 14, 0, -13 },
  { 1952, 12, 22, 14, 2, -17 },
  { 1985, 2, 22, 14, 6, -17 },
  { 1991, 11, 22, 14, 0, -17 },
  { 2022, 12, 4, 14, 1, -10 },
};

const GFXfont LiberationMono_Italic23pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic23pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic23pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _LIBERATIONMONO_ITALIC23PT7B_H_
