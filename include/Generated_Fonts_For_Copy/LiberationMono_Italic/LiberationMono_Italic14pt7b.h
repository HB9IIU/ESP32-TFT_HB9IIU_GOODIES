#ifndef _LIBERATIONMONO_ITALIC14PT7B_H_
#define _LIBERATIONMONO_ITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x24, 0x90, 0x80, 0xDC, 0xA5, 0x20, 0x09, 0x12, 0x7F, 0x22,
  0x24, 0xFF, 0x48, 0x48, 0x48, 0x04, 0x1F, 0x25, 0x28, 0x28, 0x1C, 0x0B,
  0x09, 0xD2, 0x7C, 0x10, 0x70, 0xA4, 0x94, 0x8E, 0x80, 0x80, 0xB8, 0xA4,
  0x92, 0x8E, 0x00, 0x1E, 0x12, 0x22, 0x1C, 0x72, 0xD2, 0x8C, 0x8C, 0x76,
  0x7E, 0x08, 0x88, 0xC4, 0x23, 0x10, 0x84, 0x30, 0x86, 0x00, 0x10, 0xC2,
  0x10, 0x84, 0x21, 0x10, 0x88, 0xC4, 0x00, 0x25, 0xBC, 0xCA, 0x00, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x6B, 0x40, 0xF0, 0xE0, 0x01, 0x01,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x00, 0x3C, 0xCD,
  0x0E, 0x19, 0x70, 0xA1, 0x44, 0x70, 0x04, 0x18, 0xD0, 0x60, 0x81, 0x02,
  0x04, 0xFE, 0x1E, 0x23, 0x01, 0x02, 0x04, 0x18, 0x30, 0x40, 0xFE, 0x3C,
  0x8C, 0x08, 0x23, 0x80, 0x81, 0x46, 0xF8, 0x02, 0x06, 0x0A, 0x12, 0x26,
  0x44, 0x7F, 0x04, 0x04, 0x7E, 0x81, 0x03, 0xEC, 0x40, 0x81, 0x46, 0xF0,
  0x1C, 0x45, 0x07, 0xEC, 0x50, 0xA1, 0x66, 0x78, 0xFC, 0x10, 0x84, 0x20,
  0x84, 0x10, 0x80, 0x3C, 0xCD, 0x0A, 0x23, 0x98, 0xA1, 0x46, 0xF8, 0x3C,
  0xCD, 0x0E, 0x3C, 0x6F, 0x81, 0x44, 0xF0, 0x68, 0x01, 0xA0, 0x18, 0x80,
  0x00, 0x19, 0x88, 0x80, 0x06, 0x31, 0x84, 0x06, 0x03, 0x01, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x80, 0xC0, 0x70, 0x11, 0xCC, 0x20, 0x00, 0x3C, 0x8F,
  0x08, 0x30, 0xC2, 0x08, 0x00, 0x60, 0x0F, 0x08, 0x88, 0x29, 0xD5, 0x2D,
  0x2A, 0x95, 0x54, 0xB6, 0x40, 0x31, 0x0F, 0x00, 0x06, 0x03, 0x02, 0x81,
  0x21, 0x11, 0xF8, 0x84, 0x82, 0x41, 0x80, 0x3E, 0x23, 0x21, 0x62, 0x7C,
  0x43, 0x43, 0x42, 0xFC, 0x3C, 0xC5, 0x06, 0x08, 0x10, 0x20, 0x62, 0x78,
  0x3E, 0x23, 0x21, 0x61, 0x61, 0x43, 0x42, 0x44, 0xF8, 0x3F, 0x20, 0x20,
  0x60, 0x7E, 0x40, 0x40, 0x40, 0xFE, 0x7E, 0x81, 0x02, 0x07, 0xD8, 0x20,
  0x40, 0x80, 0x3C, 0xC5, 0x06, 0x09, 0xF0, 0xA1, 0x62, 0x78, 0x21, 0x21,
  0x21, 0x63, 0x7E, 0x42, 0x42, 0x42, 0xC6, 0x7E, 0x30, 0x40, 0x81, 0x02,
  0x0C, 0x10, 0xF8, 0x1E, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x44, 0xF0, 0x21,
  0x11, 0x09, 0x0F, 0x07, 0x83, 0x61, 0x10, 0x8C, 0xC2, 0x00, 0x21, 0x86,
  0x10, 0x41, 0x0C, 0x30, 0xFC, 0x31, 0x19, 0x9D, 0x4B, 0xA5, 0x92, 0x11,
  0x09, 0x84, 0x82, 0x00, 0x31, 0x31, 0x31, 0x7B, 0x4A, 0x4A, 0x4E, 0x46,
  0xC6, 0x3C, 0xCD, 0x0C, 0x18, 0x30, 0xE1, 0x46, 0x70, 0x3F, 0x21, 0x21,
  0x63, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x3C, 0xCD, 0x0C, 0x18, 0x30, 0xE1,
  0x46, 0x70, 0x40, 0xC0, 0xE0, 0x3F, 0x21, 0x21, 0x63, 0x7E, 0x4C, 0x44,
  0x46, 0xC2, 0x1F, 0x21, 0x20, 0x30, 0x1E, 0x03, 0xC2, 0xC2, 0x7C, 0xFF,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x42, 0x85, 0x0E, 0x38,
  0x70, 0xA1, 0x46, 0xF8, 0xC1, 0xC3, 0x42, 0x44, 0x4C, 0x48, 0x78, 0x30,
  0x20, 0x81, 0x81, 0x83, 0x92, 0xB2, 0xAC, 0xCC, 0xCC, 0x88, 0x21, 0x99,
  0x85, 0x83, 0x80, 0x80, 0xE0, 0x90, 0x8C, 0x82, 0x00, 0x43, 0x42, 0x64,
  0x28, 0x30, 0x10, 0x30, 0x20, 0x20, 0x3F, 0x81, 0x81, 0x81, 0x81, 0x80,
  0x80, 0x80, 0x80, 0xFE, 0x00, 0x3C, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC2,
  0x08, 0x20, 0xE0, 0x82, 0x10, 0xC2, 0x10, 0xC2, 0x10, 0xC0, 0x3C, 0x30,
  0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0xE0, 0x18, 0x62, 0x51, 0x46,
  0x10, 0xFF, 0x00, 0xC8, 0x1E, 0x44, 0x09, 0xF4, 0x69, 0x9D, 0x80, 0x30,
  0x20, 0x20, 0x2E, 0x33, 0x63, 0x42, 0x42, 0x66, 0x7C, 0x3C, 0x8F, 0x04,
  0x08, 0x11, 0x9E, 0x00, 0x02, 0x04, 0x09, 0xD4, 0x78, 0xA1, 0x42, 0x8D,
  0xF8, 0x3C, 0x8B, 0x1F, 0xF8, 0x11, 0x9E, 0x00, 0x0F, 0x10, 0x10, 0x7E,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x3A, 0x8F, 0x14, 0x28, 0x51, 0xBF,
  0x04, 0x89, 0xE0, 0x60, 0x81, 0x02, 0xE6, 0x58, 0xB1, 0x42, 0x85, 0x18,
  0x04, 0x00, 0x01, 0xE0, 0xC1, 0x02, 0x04, 0x19, 0xFC, 0x06, 0x00, 0x01,
  0xE0, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x8E, 0x00, 0x20, 0x41, 0x82,
  0x34, 0x8A, 0x1C, 0x6C, 0x89, 0x18, 0x1C, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x19, 0xFC, 0x5B, 0x6D, 0x49, 0x49, 0x5A, 0x92, 0x92, 0x5C, 0xCB,
  0x16, 0x28, 0x50, 0xA3, 0x00, 0x3C, 0x8F, 0x1C, 0x38, 0x51, 0x9E, 0x00,
  0x2E, 0x33, 0x63, 0x62, 0x42, 0x66, 0x7C, 0xC0, 0x80, 0x80, 0x3A, 0x8B,
  0x14, 0x28, 0x51, 0xBF, 0x04, 0x08, 0x10, 0x6E, 0xE1, 0x82, 0x04, 0x08,
  0x30, 0x00, 0x3D, 0x14, 0x0E, 0x06, 0x1F, 0x80, 0x22, 0x3E, 0x84, 0x62,
  0x10, 0xF0, 0x42, 0x8F, 0x14, 0x28, 0x51, 0xBF, 0x00, 0xC2, 0x46, 0x44,
  0x48, 0x48, 0x70, 0x20, 0x81, 0x82, 0x92, 0xB6, 0xCC, 0xCC, 0x88, 0x23,
  0x32, 0x14, 0x18, 0x3C, 0x64, 0xC6, 0x61, 0x10, 0x88, 0x84, 0x82, 0x40,
  0xC0, 0x40, 0x20, 0x20, 0x60, 0x00, 0x3F, 0x02, 0x0C, 0x18, 0x30, 0x40,
  0xFE, 0x0E, 0x18, 0x10, 0x10, 0x10, 0x30, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x38, 0xFF, 0xF8, 0x38, 0x08, 0x10, 0x60, 0x81, 0x81, 0x84, 0x18,
  0x20, 0x40, 0x8E, 0x00, 0xF0, 0x3C,
};

const GFXglyph LiberationMono_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 3, -9 },
  { 5, 5, 4, 8, 3, -10 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 8, 11, 8, 0, -10 },
  { 28, 9, 9, 8, 0, -9 },
  { 39, 8, 9, 8, 0, -9 },
  { 48, 2, 4, 8, 4, -10 },
  { 49, 5, 13, 8, 2, -10 },
  { 58, 5, 13, 8, 1, -10 },
  { 67, 5, 5, 8, 3, -10 },
  { 71, 7, 7, 8, 1, -8 },
  { 78, 3, 4, 8, 1, -2 },
  { 80, 4, 1, 8, 2, -4 },
  { 81, 2, 2, 8, 3, -2 },
  { 82, 9, 10, 8, 0, -10 },
  { 94, 7, 9, 8, 1, -9 },
  { 102, 7, 9, 8, 0, -9 },
  { 110, 8, 9, 8, 0, -9 },
  { 119, 7, 9, 8, 1, -9 },
  { 127, 8, 9, 8, 0, -9 },
  { 136, 7, 9, 8, 1, -9 },
  { 144, 7, 9, 8, 1, -9 },
  { 152, 6, 9, 8, 2, -9 },
  { 159, 7, 9, 8, 1, -9 },
  { 167, 7, 9, 8, 1, -9 },
  { 175, 3, 7, 8, 3, -7 },
  { 178, 5, 9, 8, 1, -7 },
  { 184, 7, 7, 8, 1, -8 },
  { 191, 7, 4, 8, 1, -6 },
  { 195, 7, 7, 8, 1, -8 },
  { 202, 7, 9, 8, 1, -9 },
  { 210, 9, 12, 8, 0, -10 },
  { 224, 9, 9, 8, -1, -9 },
  { 235, 8, 9, 8, 0, -9 },
  { 244, 7, 9, 8, 1, -9 },
  { 252, 8, 9, 8, 0, -9 },
  { 261, 8, 9, 8, 0, -9 },
  { 270, 7, 9, 8, 1, -9 },
  { 278, 7, 9, 8, 1, -9 },
  { 286, 8, 9, 8, 0, -9 },
  { 295, 7, 9, 8, 1, -9 },
  { 303, 7, 9, 8, 1, -9 },
  { 311, 9, 9, 8, 0, -9 },
  { 322, 6, 9, 8, 1, -9 },
  { 329, 9, 9, 8, 0, -9 },
  { 340, 8, 9, 8, 0, -9 },
  { 349, 7, 9, 8, 1, -9 },
  { 357, 8, 9, 8, 0, -9 },
  { 366, 7, 12, 8, 1, -9 },
  { 377, 8, 9, 8, 0, -9 },
  { 386, 8, 9, 8, 0, -9 },
  { 395, 8, 9, 8, 1, -9 },
  { 404, 7, 9, 8, 1, -9 },
  { 412, 8, 9, 8, 1, -9 },
  { 421, 8, 9, 8, 1, -9 },
  { 430, 9, 9, 8, 0, -9 },
  { 441, 8, 9, 8, 1, -9 },
  { 450, 9, 9, 8, 0, -9 },
  { 461, 6, 13, 8, 2, -10 },
  { 471, 5, 10, 8, 2, -10 },
  { 478, 6, 13, 8, 1, -10 },
  { 488, 6, 6, 8, 1, -9 },
  { 493, 9, 1, 8, -1, 1 },
  { 495, 3, 2, 8, 4, -10 },
  { 496, 7, 7, 8, 0, -7 },
  { 503, 8, 10, 8, 0, -10 },
  { 513, 7, 7, 8, 1, -7 },
  { 520, 7, 10, 8, 1, -10 },
  { 529, 7, 7, 8, 1, -7 },
  { 536, 8, 10, 8, 1, -10 },
  { 546, 7, 10, 8, 1, -7 },
  { 555, 7, 10, 8, 1, -10 },
  { 564, 7, 10, 8, 0, -10 },
  { 573, 7, 13, 8, 0, -10 },
  { 585, 7, 10, 8, 1, -10 },
  { 594, 7, 10, 8, 0, -10 },
  { 603, 8, 7, 8, 0, -7 },
  { 610, 7, 7, 8, 1, -7 },
  { 617, 7, 7, 8, 1, -7 },
  { 624, 8, 10, 8, 0, -7 },
  { 634, 7, 10, 8, 1, -7 },
  { 643, 7, 7, 8, 1, -7 },
  { 650, 6, 7, 8, 1, -7 },
  { 656, 5, 9, 8, 2, -9 },
  { 662, 7, 7, 8, 1, -7 },
  { 669, 8, 7, 8, 1, -7 },
  { 676, 8, 7, 8, 1, -7 },
  { 683, 8, 7, 8, 0, -7 },
  { 690, 9, 10, 8, 0, -7 },
  { 702, 8, 7, 8, 0, -7 },
  { 709, 8, 13, 8, 1, -10 },
  { 722, 1, 13, 8, 4, -10 },
  { 724, 7, 13, 8, 0, -10 },
  { 736, 7, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_Italic14pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic14pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _LIBERATIONMONO_ITALIC14PT7B_H_
