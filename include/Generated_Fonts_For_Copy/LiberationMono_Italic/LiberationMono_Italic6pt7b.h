#ifndef _LIBERATIONMONO_ITALIC6PT7B_H_
#define _LIBERATIONMONO_ITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0xF0, 0x0F, 0xE8, 0x74, 0x7E, 0xCE, 0x5F, 0x6B, 0x70, 0x80,
  0x6A, 0x80, 0x24, 0xA4, 0xF0, 0x08, 0x60, 0xC0, 0x80, 0x22, 0x48, 0x76,
  0xF0, 0x25, 0x20, 0x65, 0x60, 0x64, 0xF0, 0x2F, 0x90, 0x58, 0xF0, 0x5E,
  0xF0, 0x6A, 0x40, 0x6E, 0xF0, 0x75, 0xF0, 0x20, 0x20, 0x09, 0x00, 0x48,
  0x0D, 0x80, 0xDA, 0x7F, 0xAE, 0xC0, 0x2D, 0xD0, 0x7E, 0xF0, 0x68, 0x8E,
  0x76, 0xF0, 0x7C, 0x8C, 0x74, 0x88, 0x68, 0xAE, 0x0D, 0xAA, 0x69, 0x20,
  0x24, 0xF0, 0x2C, 0xAA, 0x4A, 0x60, 0x56, 0xA8, 0x45, 0xEA, 0x76, 0xF0,
  0x69, 0xE8, 0x76, 0xD4, 0x69, 0xEA, 0x74, 0x2E, 0xF2, 0x40, 0x19, 0xAE,
  0x16, 0x64, 0x99, 0xEA, 0x06, 0x4A, 0x3A, 0x40, 0x72, 0x4E, 0xAA, 0x80,
  0xA5, 0x24, 0xA4, 0x2E, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x4E, 0xF0, 0x53,
  0x80, 0x1E, 0xAE, 0x7F, 0x80, 0xD2, 0x40, 0xF6, 0xF0, 0x4E, 0xD0, 0x05,
  0x20, 0x04, 0xA4, 0x46, 0x4A, 0x25, 0x20, 0xFF, 0x00, 0x76, 0x80, 0x77,
  0x80, 0x77, 0xC0, 0xF7, 0x90, 0xE8, 0x4F, 0x80, 0xAA, 0xB7, 0x80, 0xDA,
  0x00, 0x9E, 0xA0, 0x64, 0xA0, 0x96, 0x40, 0x2B, 0x00, 0x52, 0x48, 0x70,
  0x24, 0xA4, 0x40,
};

const GFXglyph LiberationMono_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 4, 4, 0, -4 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 2, 4, 2, -4 },
  { 12, 2, 5, 4, 1, -4 },
  { 14, 3, 5, 4, 0, -4 },
  { 16, 2, 2, 4, 1, -4 },
  { 17, 3, 2, 4, 0, -3 },
  { 18, 2, 2, 4, 0, -1 },
  { 19, 2, 1, 4, 1, -2 },
  { 20, 1, 1, 4, 1, -1 },
  { 21, 4, 4, 4, 0, -4 },
  { 23, 3, 4, 4, 0, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 1, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 1, 3, 4, 1, -3 },
  { 44, 1, 4, 4, 1, -3 },
  { 45, 3, 4, 4, 0, -4 },
  { 47, 3, 2, 4, 0, -3 },
  { 48, 3, 4, 4, 0, -4 },
  { 50, 2, 4, 4, 1, -4 },
  { 51, 4, 5, 4, 0, -4 },
  { 54, 3, 4, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 4, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 3, 5, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 4, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 1, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 3, 4, 4, 1, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 2, 5, 4, 1, -4 },
  { 108, 2, 4, 4, 1, -4 },
  { 109, 3, 5, 4, 0, -4 },
  { 111, 3, 3, 4, 0, -4 },
  { 113, 3, 1, 4, 0, 0 },
  { 114, 1, 1, 4, 2, -4 },
  { 115, 3, 3, 4, 0, -3 },
  { 117, 3, 4, 4, 0, -4 },
  { 119, 3, 3, 4, 0, -3 },
  { 121, 4, 4, 4, 0, -4 },
  { 123, 3, 3, 4, 0, -3 },
  { 125, 3, 4, 4, 1, -4 },
  { 127, 3, 4, 4, 0, -3 },
  { 129, 3, 4, 4, 0, -4 },
  { 131, 3, 4, 4, 0, -4 },
  { 133, 3, 5, 4, 0, -4 },
  { 135, 4, 4, 4, 0, -4 },
  { 137, 3, 4, 4, 0, -4 },
  { 139, 3, 3, 4, 0, -3 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 4, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -3 },
  { 149, 2, 3, 4, 1, -3 },
  { 150, 3, 3, 4, 0, -3 },
  { 152, 2, 4, 4, 1, -4 },
  { 153, 3, 3, 4, 0, -3 },
  { 155, 3, 3, 4, 1, -3 },
  { 157, 4, 3, 4, 0, -3 },
  { 159, 4, 3, 4, 0, -3 },
  { 161, 4, 4, 4, 0, -3 },
  { 163, 3, 3, 4, 0, -3 },
  { 165, 3, 5, 4, 1, -4 },
  { 167, 1, 5, 4, 1, -4 },
  { 168, 3, 5, 4, 0, -4 },
  { 170, 3, 1, 4, 0, -2 },
};

const GFXfont LiberationMono_Italic6pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic6pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _LIBERATIONMONO_ITALIC6PT7B_H_
