#ifndef _LIBERATIONMONO_ITALIC15PT7B_H_
#define _LIBERATIONMONO_ITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB6, 0x92, 0x18, 0xCE, 0xE7, 0x29, 0x00, 0x08, 0x84, 0x84,
  0x4F, 0xF1, 0x21, 0x13, 0xFC, 0x88, 0x48, 0x24, 0x00, 0x04, 0x0F, 0x89,
  0x64, 0x92, 0x40, 0xF0, 0x2C, 0x12, 0xC9, 0x65, 0x9F, 0x02, 0x00, 0x38,
  0x92, 0x44, 0xA1, 0x78, 0x74, 0x02, 0xC1, 0x48, 0x92, 0x4D, 0x21, 0xC0,
  0x0E, 0x13, 0x12, 0x14, 0x38, 0x51, 0xCA, 0x8A, 0xC4, 0x7B, 0x69, 0x2C,
  0x08, 0x43, 0x08, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x80, 0x18,
  0x20, 0x83, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x0C, 0x61, 0x00, 0x25, 0x5C,
  0xC9, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x26, 0xC8, 0xF8,
  0xF0, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x10, 0x0C, 0x00, 0x1E, 0x45, 0x0E, 0x1D, 0xB2, 0x60, 0xC2, 0xCC, 0xF0,
  0x06, 0x0E, 0x34, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0xFF, 0x0F, 0x08,
  0x88, 0x40, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x7F, 0x00, 0x1E, 0x62,
  0x42, 0x06, 0x18, 0x06, 0x06, 0x86, 0xC4, 0x78, 0x03, 0x07, 0x0F, 0x0A,
  0x12, 0x22, 0x42, 0x7F, 0x04, 0x04, 0x3E, 0x60, 0x40, 0x7C, 0xC6, 0x02,
  0x02, 0x86, 0x8C, 0x78, 0x1E, 0x22, 0x40, 0x5C, 0xE6, 0xC2, 0x82, 0x86,
  0xCC, 0x78, 0xFE, 0x08, 0x30, 0xC1, 0x04, 0x08, 0x20, 0x41, 0x80, 0x3E,
  0xC5, 0x0A, 0x33, 0x88, 0xE1, 0xC3, 0x84, 0xF0, 0x1C, 0xC5, 0x0A, 0x1C,
  0x28, 0xDE, 0x82, 0x8D, 0xE0, 0x6C, 0x00, 0x36, 0x18, 0xC0, 0x00, 0x00,
  0xC4, 0x42, 0x00, 0x02, 0x39, 0x84, 0x06, 0x03, 0x80, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x80, 0xE0, 0x30, 0x10, 0xCE, 0x20, 0x00, 0x3E, 0x62, 0xC3,
  0x02, 0x06, 0x0C, 0x10, 0x30, 0x00, 0x20, 0x0F, 0x08, 0xC8, 0x25, 0xB5,
  0x2A, 0x96, 0x8B, 0x4A, 0xAD, 0x5B, 0x20, 0x08, 0xC7, 0x80, 0x03, 0x02,
  0x83, 0x41, 0x21, 0x90, 0x88, 0xFE, 0x43, 0x40, 0xA0, 0x40, 0x3F, 0x10,
  0xC8, 0x44, 0x67, 0xC3, 0x19, 0x04, 0x82, 0x43, 0x3E, 0x00, 0x1E, 0x23,
  0x43, 0xC0, 0xC0, 0x80, 0x80, 0x82, 0xC4, 0x78, 0x3E, 0x11, 0x88, 0x64,
  0x36, 0x1B, 0x09, 0x04, 0x86, 0x46, 0x3C, 0x00, 0x3F, 0x90, 0x08, 0x04,
  0x07, 0xF3, 0x01, 0x00, 0x80, 0x40, 0x3F, 0x80, 0x7F, 0x60, 0x40, 0x40,
  0x7E, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x1E, 0x62, 0x43, 0xC0, 0xCE, 0x82,
  0x86, 0x86, 0xC6, 0x78, 0x31, 0x90, 0xC8, 0x44, 0x27, 0xF3, 0x19, 0x0C,
  0x86, 0x42, 0x21, 0x00, 0x3F, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0xFC, 0x0E, 0x04, 0x18, 0x30, 0x60, 0x81, 0x46, 0xC8, 0xE0, 0x31,
  0x88, 0xC2, 0x60, 0xB0, 0x78, 0x1F, 0x06, 0x41, 0x18, 0x42, 0x10, 0xC0,
  0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0xF8, 0x31, 0x98, 0xCC,
  0xAF, 0xB4, 0xD2, 0x49, 0x04, 0x82, 0xC3, 0x41, 0x00, 0x30, 0x98, 0xCE,
  0x45, 0x26, 0x93, 0x49, 0x3C, 0x8E, 0x46, 0x23, 0x00, 0x1E, 0x62, 0x43,
  0xC3, 0xC3, 0x82, 0x82, 0x86, 0xCC, 0x78, 0x3F, 0x10, 0xC8, 0x64, 0x27,
  0xE2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1E, 0x62, 0x43, 0xC3, 0xC3,
  0x82, 0x82, 0x86, 0xCC, 0x78, 0x30, 0x10, 0x1C, 0x3F, 0x10, 0xC8, 0x64,
  0x27, 0xE3, 0x21, 0x10, 0x8C, 0x42, 0x21, 0x80, 0x1F, 0x18, 0xC8, 0x64,
  0x03, 0xC0, 0x38, 0x05, 0x82, 0x42, 0x3E, 0x00, 0x7F, 0x04, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x00, 0x41, 0x43, 0x43, 0x42,
  0xC2, 0xC2, 0x86, 0x86, 0x84, 0x78, 0xC1, 0xE0, 0x90, 0xC8, 0x44, 0x63,
  0x21, 0xA0, 0x50, 0x30, 0x18, 0x00, 0x80, 0xC0, 0xE0, 0x53, 0x29, 0xB5,
  0x52, 0xA9, 0x9C, 0xCC, 0x66, 0x00, 0x10, 0x43, 0x10, 0x24, 0x07, 0x80,
  0x60, 0x1C, 0x02, 0x80, 0x98, 0x21, 0x08, 0x30, 0x41, 0x21, 0x98, 0x84,
  0x83, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x00, 0x3F, 0x80, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x7F, 0x80, 0x3C, 0x82, 0x08, 0x61,
  0x84, 0x10, 0x43, 0x0C, 0x20, 0x83, 0xC0, 0xC2, 0x10, 0xC2, 0x10, 0xC2,
  0x10, 0x42, 0x3C, 0x10, 0x43, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x13,
  0xC0, 0x08, 0x28, 0x91, 0x24, 0x48, 0xE0, 0x80, 0xFF, 0x80, 0x44, 0x3C,
  0x8C, 0x1B, 0xEC, 0x51, 0xA5, 0x73, 0x20, 0xC1, 0x82, 0xF6, 0x28, 0x70,
  0xE1, 0xC7, 0x8A, 0xE0, 0x3C, 0xC7, 0x04, 0x08, 0x10, 0x31, 0x3C, 0x01,
  0x03, 0x03, 0x3A, 0x46, 0xC6, 0x86, 0x86, 0x84, 0x8C, 0xF4, 0x3C, 0xC7,
  0x0F, 0xF8, 0x10, 0x31, 0x3C, 0x1E, 0x60, 0x87, 0xF6, 0x0C, 0x10, 0x20,
  0x41, 0x83, 0x00, 0x3A, 0xCF, 0x1E, 0x38, 0x70, 0xA3, 0x7A, 0x0D, 0x13,
  0xC0, 0x20, 0xC1, 0x82, 0xF6, 0x68, 0x71, 0xE3, 0x85, 0x0A, 0x10, 0x06,
  0x06, 0x00, 0x3C, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0xFF, 0x02, 0x04,
  0x01, 0xF0, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x41, 0x9E, 0x00, 0x20,
  0x20, 0x20, 0x62, 0x64, 0x48, 0x50, 0x70, 0xC8, 0xCC, 0x84, 0x1E, 0x04,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x7B, 0x36, 0xD2,
  0x69, 0x24, 0x96, 0x4B, 0x65, 0x26, 0x5E, 0xCD, 0x0E, 0x3C, 0x70, 0xA1,
  0x42, 0x3C, 0xCF, 0x0C, 0x18, 0x30, 0xF3, 0x3C, 0x2F, 0x31, 0x21, 0x21,
  0x61, 0x63, 0x62, 0x5C, 0xC0, 0xC0, 0x80, 0x3A, 0x8F, 0x1C, 0x38, 0x70,
  0xA3, 0x7A, 0x0C, 0x18, 0x20, 0x2E, 0x61, 0x83, 0x04, 0x08, 0x10, 0x60,
  0x3C, 0x85, 0x03, 0xC1, 0xC0, 0xA1, 0x7C, 0x20, 0x8F, 0xD0, 0x41, 0x04,
  0x30, 0xC1, 0xE0, 0x42, 0x85, 0x0E, 0x3C, 0x70, 0xA3, 0x7A, 0xC3, 0x42,
  0x46, 0x44, 0x6C, 0x68, 0x30, 0x30, 0x81, 0x40, 0xA6, 0xD5, 0x4A, 0xA6,
  0x73, 0x31, 0x18, 0x21, 0x19, 0x05, 0x81, 0x81, 0xC1, 0xA1, 0x99, 0x84,
  0x60, 0x90, 0x88, 0x44, 0x43, 0x60, 0xA0, 0x60, 0x30, 0x10, 0x10, 0x30,
  0x00, 0x3F, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xFE, 0x0E, 0x20, 0xC1,
  0x82, 0x0C, 0x20, 0x20, 0x60, 0x81, 0x02, 0x04, 0x0E, 0x00, 0xFF, 0xFC,
  0x3C, 0x08, 0x10, 0x20, 0xC1, 0x80, 0x86, 0x08, 0x30, 0x60, 0x81, 0x1C,
  0x00, 0xF0, 0x0E,
};

const GFXglyph LiberationMono_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 5, 5, 9, 3, -11 },
  { 9, 9, 10, 9, 0, -10 },
  { 21, 9, 12, 9, 0, -11 },
  { 35, 10, 10, 9, 0, -10 },
  { 48, 8, 10, 9, 0, -10 },
  { 58, 3, 5, 9, 4, -11 },
  { 60, 6, 14, 9, 2, -11 },
  { 71, 6, 14, 9, 1, -11 },
  { 82, 5, 5, 9, 3, -11 },
  { 86, 7, 7, 9, 1, -9 },
  { 93, 4, 4, 9, 1, -2 },
  { 95, 5, 1, 9, 2, -4 },
  { 96, 2, 2, 9, 3, -2 },
  { 97, 10, 11, 9, 0, -11 },
  { 111, 7, 10, 9, 1, -10 },
  { 120, 8, 10, 9, 0, -10 },
  { 130, 9, 10, 9, 0, -10 },
  { 142, 8, 10, 9, 1, -10 },
  { 152, 8, 10, 9, 0, -10 },
  { 162, 8, 10, 9, 1, -10 },
  { 172, 8, 10, 9, 1, -10 },
  { 182, 7, 10, 9, 2, -10 },
  { 191, 7, 10, 9, 1, -10 },
  { 200, 7, 10, 9, 1, -10 },
  { 209, 3, 8, 9, 3, -8 },
  { 212, 5, 10, 9, 1, -8 },
  { 219, 7, 7, 9, 1, -9 },
  { 226, 7, 4, 9, 1, -7 },
  { 230, 7, 7, 9, 1, -9 },
  { 237, 8, 10, 9, 1, -10 },
  { 247, 9, 13, 9, 0, -11 },
  { 262, 9, 10, 9, -1, -10 },
  { 274, 9, 10, 9, 0, -10 },
  { 286, 8, 10, 9, 1, -10 },
  { 296, 9, 10, 9, 0, -10 },
  { 308, 9, 10, 9, 0, -10 },
  { 320, 8, 10, 9, 1, -10 },
  { 330, 8, 10, 9, 1, -10 },
  { 340, 9, 10, 9, 0, -10 },
  { 352, 8, 10, 9, 1, -10 },
  { 362, 7, 10, 9, 1, -10 },
  { 371, 10, 10, 9, 0, -10 },
  { 384, 7, 10, 9, 1, -10 },
  { 393, 9, 10, 9, 0, -10 },
  { 405, 9, 10, 9, 0, -10 },
  { 417, 8, 10, 9, 1, -10 },
  { 427, 9, 10, 9, 0, -10 },
  { 439, 8, 13, 9, 1, -10 },
  { 452, 9, 10, 9, 0, -10 },
  { 464, 9, 10, 9, 0, -10 },
  { 476, 9, 10, 9, 1, -10 },
  { 488, 8, 10, 9, 1, -10 },
  { 498, 9, 10, 9, 1, -10 },
  { 510, 9, 10, 9, 1, -10 },
  { 522, 11, 10, 9, -1, -10 },
  { 536, 9, 10, 9, 1, -10 },
  { 548, 9, 10, 9, 0, -10 },
  { 560, 6, 14, 9, 2, -11 },
  { 571, 5, 11, 9, 2, -11 },
  { 578, 6, 14, 9, 1, -11 },
  { 589, 7, 7, 9, 1, -10 },
  { 596, 9, 1, 9, -1, 1 },
  { 598, 3, 2, 9, 4, -11 },
  { 599, 7, 8, 9, 1, -8 },
  { 606, 7, 11, 9, 1, -11 },
  { 616, 7, 8, 9, 1, -8 },
  { 623, 8, 11, 9, 1, -11 },
  { 634, 7, 8, 9, 1, -8 },
  { 641, 7, 11, 9, 2, -11 },
  { 651, 7, 11, 9, 1, -8 },
  { 661, 7, 11, 9, 1, -11 },
  { 671, 8, 11, 9, 0, -11 },
  { 682, 7, 14, 9, 0, -11 },
  { 695, 8, 11, 9, 1, -11 },
  { 706, 8, 11, 9, 0, -11 },
  { 717, 9, 8, 9, 0, -8 },
  { 726, 7, 8, 9, 1, -8 },
  { 733, 7, 8, 9, 1, -8 },
  { 740, 8, 11, 9, 0, -8 },
  { 751, 7, 11, 9, 1, -8 },
  { 761, 7, 8, 9, 1, -8 },
  { 768, 7, 8, 9, 1, -8 },
  { 775, 6, 10, 9, 2, -10 },
  { 783, 7, 8, 9, 1, -8 },
  { 790, 8, 8, 9, 1, -8 },
  { 798, 9, 8, 9, 1, -8 },
  { 807, 9, 8, 9, 0, -8 },
  { 816, 9, 11, 9, 0, -8 },
  { 829, 8, 8, 9, 0, -8 },
  { 837, 7, 14, 9, 2, -11 },
  { 850, 1, 14, 9, 4, -11 },
  { 852, 7, 14, 9, 0, -11 },
  { 865, 8, 2, 9, 1, -6 },
};

const GFXfont LiberationMono_Italic15pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic15pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic15pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _LIBERATIONMONO_ITALIC15PT7B_H_
