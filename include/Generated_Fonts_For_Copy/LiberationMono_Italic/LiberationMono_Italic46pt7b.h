#ifndef _LIBERATIONMONO_ITALIC46PT7B_H_
#define _LIBERATIONMONO_ITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE0, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x0E, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x80, 0x60, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x60,
  0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60,
  0x1C, 0x00, 0x1C, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x18, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x07,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x3E, 0x39, 0xF8, 0x1F, 0x0E, 0x1F, 0x0F, 0x83, 0x83,
  0xC3, 0xC0, 0xE0, 0xF0, 0xF0, 0x30, 0x38, 0x3C, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xE1, 0xC0, 0x00, 0x7E, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0xF8,
  0x00, 0x0C, 0x1F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70,
  0x3C, 0x70, 0x1C, 0x0F, 0x3C, 0x07, 0x03, 0xCF, 0x03, 0x80, 0xF3, 0xE0,
  0xE0, 0x78, 0xF8, 0x38, 0x3C, 0x1F, 0x8E, 0x3F, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C,
  0x0F, 0xF8, 0x00, 0xE0, 0x78, 0xF0, 0x07, 0x03, 0xC1, 0xC0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x38, 0x1C, 0x0F, 0x01, 0xE0, 0x70, 0x78, 0x07, 0x01,
  0xC3, 0xC0, 0x1C, 0x0F, 0x0E, 0x00, 0x70, 0x38, 0x70, 0x01, 0xC0, 0xE3,
  0x80, 0x07, 0x07, 0x9C, 0x00, 0x1E, 0x3C, 0xE0, 0x00, 0x3F, 0xE7, 0x00,
  0x00, 0x7E, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x0F, 0x3F, 0xE0,
  0x00, 0x39, 0xC3, 0xC0, 0x01, 0xCE, 0x0F, 0x00, 0x0E, 0x38, 0x1C, 0x00,
  0x71, 0xE0, 0x70, 0x03, 0x87, 0x01, 0xC0, 0x1C, 0x1C, 0x0F, 0x00, 0xE0,
  0x70, 0x38, 0x07, 0x81, 0xC0, 0xE0, 0x3C, 0x07, 0x03, 0x81, 0xE0, 0x1C,
  0x1C, 0x07, 0x00, 0x78, 0xE0, 0x38, 0x00, 0xFF, 0x01, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0x83, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x30, 0x1F, 0xE0, 0x1E,
  0x1F, 0xF0, 0x0E, 0x1E, 0x3C, 0x0F, 0x1E, 0x1E, 0x07, 0x1E, 0x07, 0x87,
  0x8F, 0x03, 0xC3, 0x8F, 0x00, 0xF3, 0xC7, 0x80, 0x7F, 0xC3, 0xC0, 0x1F,
  0xC1, 0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xF8, 0x1F, 0x07,
  0xFF, 0x2F, 0xFF, 0xEF, 0xF3, 0xFF, 0xC3, 0xF0, 0x7F, 0x00, 0x78, 0x7D,
  0xF7, 0xDE, 0x79, 0xE7, 0xBC, 0xF3, 0xCF, 0x38, 0xE3, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x02, 0x0C, 0x13, 0xC6, 0x39, 0xFF, 0x7E, 0x7F, 0xFC,
  0x07, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xDE, 0x01, 0xC7, 0x03, 0xC3,
  0xC1, 0xC0, 0xC0, 0x20, 0x40, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xF7, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x78,
  0x03, 0xC1, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x87, 0xC1,
  0xEF, 0x0F, 0x83, 0xFE, 0x1F, 0x0F, 0x78, 0x3E, 0x1E, 0xF0, 0xFC, 0x3D,
  0xE1, 0xF8, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x0F, 0x81, 0xF0, 0x3E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x3C, 0x01, 0xF8, 0x78, 0x07, 0x81,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x38, 0x7C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x78,
  0x01, 0xC0, 0x78, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x3F, 0x80, 0x1E, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC1, 0xF8,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x3C, 0x03, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE1, 0xFC, 0x03, 0xCF, 0xFE, 0x0F, 0x3F,
  0xFE, 0x1E, 0xE0, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x79, 0xF0, 0x00,
  0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x3C, 0x07,
  0xC0, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F,
  0x81, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F,
  0x1F, 0x00, 0xFE, 0x3F, 0x07, 0xBC, 0x3F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0,
  0x1F, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xF0, 0x7C, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x3E,
  0x00, 0x7C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x03, 0x81, 0xE3, 0x70, 0x70, 0x7F, 0x77, 0x07, 0x0E,
  0x36, 0x70, 0xE1, 0xC3, 0xE7, 0x0E, 0x38, 0x1E, 0x71, 0xC7, 0x01, 0xC7,
  0x1C, 0x70, 0x1C, 0x73, 0x8E, 0x03, 0xC7, 0x38, 0xE0, 0x38, 0x73, 0x9C,
  0x03, 0x86, 0x31, 0xC0, 0x70, 0xE7, 0x3C, 0x07, 0x0E, 0x73, 0x80, 0x70,
  0xC7, 0x38, 0x0E, 0x1C, 0x63, 0x80, 0xE1, 0xCE, 0x38, 0x1E, 0x18, 0xE3,
  0x81, 0xC3, 0x8E, 0x38, 0x3C, 0x30, 0xE3, 0x87, 0xC6, 0x0E, 0x38, 0xDC,
  0xE0, 0xE3, 0xF9, 0xFC, 0x0E, 0x1F, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x10, 0x07, 0x80, 0x03, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xBC,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF0, 0x7C,
  0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0x87, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0,
  0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x7F, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0C, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x30, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1E,
  0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x08, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF0, 0x1F, 0xFC, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x03, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x0F,
  0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xDF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01,
  0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0,
  0x78, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xE0,
  0x3B, 0x83, 0xFC, 0x0F, 0xF0, 0x7B, 0x81, 0xDE, 0x0E, 0x70, 0x7B, 0xC1,
  0xCF, 0x0E, 0x70, 0x79, 0xE3, 0x8E, 0x0F, 0x3C, 0xF3, 0xC1, 0xE7, 0x9C,
  0x78, 0x38, 0x77, 0x8F, 0x07, 0x0E, 0xE1, 0xC1, 0xE1, 0xFC, 0x38, 0x3C,
  0x3F, 0x0F, 0x07, 0x87, 0xC1, 0xE0, 0xE0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x00, 0x03,
  0xE0, 0x01, 0xC0, 0xFC, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x1F, 0xC0, 0x0F,
  0x07, 0xF0, 0x03, 0xC1, 0xFE, 0x00, 0xE0, 0x7F, 0x80, 0x78, 0x1D, 0xE0,
  0x1E, 0x0F, 0x38, 0x07, 0x83, 0xCF, 0x01, 0xE0, 0xF3, 0xC0, 0x70, 0x3C,
  0xF0, 0x3C, 0x0F, 0x1E, 0x0F, 0x03, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x38, 0x38, 0x1E, 0x0F, 0x1E, 0x07, 0x83, 0xC7, 0x81, 0xC0, 0xF1,
  0xE0, 0xF0, 0x1C, 0x78, 0x3C, 0x07, 0x9C, 0x0F, 0x01, 0xEF, 0x03, 0xC0,
  0x7B, 0xC0, 0xE0, 0x0F, 0xF0, 0x78, 0x03, 0xFC, 0x1E, 0x00, 0xFE, 0x07,
  0x80, 0x3F, 0x81, 0xE0, 0x07, 0xE0, 0x70, 0x01, 0xF8, 0x3C, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7E,
  0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0xC1,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7E,
  0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0xC1,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x7F, 0x07, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x7E,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xC0, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x0C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3C,
  0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0xF8, 0x1E,
  0x1E, 0x07, 0xC1, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x83, 0xF0, 0x78, 0x3C,
  0x3F, 0x83, 0x81, 0xE1, 0xDC, 0x3C, 0x0F, 0x0E, 0xE1, 0xE0, 0x78, 0xE7,
  0x0E, 0x03, 0xC7, 0x38, 0xF0, 0x1E, 0x71, 0xC7, 0x80, 0xF3, 0x8E, 0x38,
  0x07, 0x38, 0x73, 0xC0, 0x39, 0xC3, 0x9E, 0x01, 0xDE, 0x1C, 0xE0, 0x0E,
  0xE0, 0xEF, 0x00, 0x77, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80,
  0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0x3C, 0x00, 0x39, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xE0,
  0x1C, 0x0F, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x00,
  0x78, 0x70, 0x03, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF1,
  0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFC, 0x03, 0xC7, 0xC0, 0x0F,
  0x1E, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C,
  0x01, 0xF8, 0xF0, 0x0F, 0xE3, 0xE0, 0xF7, 0x8F, 0xFF, 0x9F, 0xDF, 0xF8,
  0x7F, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x87, 0xE0, 0x1E, 0x3F, 0xF0, 0x3D, 0xFF, 0xF0,
  0x7F, 0x83, 0xE0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0x87, 0xE0, 0x1E, 0x1E, 0xE0, 0xFC, 0x3D, 0xFF, 0xF0, 0x79, 0xFF, 0x80,
  0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xF0, 0x7E, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF8, 0x03,
  0xE1, 0xF0, 0x3F, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0xFE, 0x1E, 0x01, 0xFF, 0x8F, 0x01, 0xFF, 0xEF, 0x01, 0xF0,
  0x3F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0xEF, 0x01, 0xFF, 0xE7,
  0x80, 0x7F, 0xE7, 0x80, 0x1F, 0xC3, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0x7E, 0x1F, 0x00, 0x78, 0x78, 0x01,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0C,
  0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE1, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0x01,
  0xFF, 0x8F, 0x03, 0xFF, 0xCF, 0x07, 0xC1, 0xFE, 0x0F, 0x80, 0x7E, 0x0F,
  0x00, 0x7E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x07, 0xF0, 0x7E,
  0x0E, 0xF0, 0x3F, 0xFC, 0xF0, 0x1F, 0xF9, 0xF0, 0x0F, 0xE1, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x87, 0xE0, 0x1E, 0x3F, 0xF0, 0x3C, 0xFF,
  0xF0, 0x7B, 0x83, 0xE0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x80, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x1E,
  0x0F, 0x81, 0xEF, 0xE3, 0xF8, 0x3D, 0xFC, 0xFF, 0x07, 0x63, 0xF1, 0xE0,
  0xF8, 0x7C, 0x1E, 0x1E, 0x0F, 0x83, 0x83, 0xC1, 0xE0, 0x70, 0xF0, 0x3C,
  0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0E,
  0x07, 0x81, 0xC3, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0x81,
  0xE1, 0xE0, 0xF0, 0x3C, 0x38, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xE1, 0xE0,
  0x78, 0x3C, 0x3C, 0x0E, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0xE0, 0x78, 0x1E,
  0x3C, 0x0F, 0x03, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x38, 0x1E, 0x00, 0x0F,
  0x07, 0xE0, 0x1E, 0x3F, 0xF0, 0x3C, 0xFF, 0xF0, 0x7B, 0x83, 0xE0, 0xFC,
  0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0x7E, 0x1F, 0x00,
  0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xC1, 0xF8, 0x01,
  0xE3, 0xFF, 0x00, 0xF7, 0xFF, 0xC0, 0x7B, 0x83, 0xE0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF8,
  0x07, 0x80, 0xEE, 0x0F, 0xC0, 0xF7, 0xFF, 0xC0, 0x79, 0xFF, 0xC0, 0x3C,
  0x3F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x1E, 0x07, 0xFE, 0x3C, 0x1F, 0xFE, 0xF0, 0x7C, 0x1F, 0xE1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x8F, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0,
  0x03, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x3F, 0x0F, 0x80, 0xFE, 0x1F, 0x83,
  0xBC, 0x1F, 0xFE, 0xF8, 0x1F, 0xF9, 0xE0, 0x1F, 0xC3, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFC, 0x3C, 0x3F, 0xF0, 0xF3, 0xFF, 0x83,
  0xDF, 0xFE, 0x0F, 0x78, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3E, 0x03, 0xE0,
  0x78, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0xC0, 0x01, 0xE3, 0x80, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x08, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x83,
  0xBC, 0x1F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0, 0x1F, 0xC1, 0xC0, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE3, 0xC1, 0xF0, 0x3C, 0x78, 0x3E, 0x07, 0x0E, 0x0F, 0xC1, 0xE1, 0xC1,
  0xF8, 0x3C, 0x38, 0x73, 0x87, 0x07, 0x0E, 0x71, 0xE1, 0xE3, 0xCE, 0x3C,
  0x3C, 0x71, 0xCF, 0x07, 0x9E, 0x39, 0xE0, 0xF3, 0x87, 0x3C, 0x1E, 0xF0,
  0xE7, 0x03, 0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xB8, 0x0F, 0xE0, 0x77, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3E,
  0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x00,
};

const GFXglyph LiberationMono_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 30, 28, 9, -30 },
  { 43, 17, 14, 28, 8, -33 },
  { 73, 27, 30, 28, 1, -30 },
  { 175, 26, 37, 28, 1, -33 },
  { 296, 30, 30, 28, -1, -30 },
  { 409, 25, 30, 28, 0, -30 },
  { 503, 6, 14, 28, 14, -33 },
  { 514, 17, 43, 28, 7, -33 },
  { 606, 18, 43, 28, 3, -33 },
  { 703, 17, 16, 28, 8, -33 },
  { 737, 22, 23, 28, 3, -27 },
  { 801, 13, 15, 28, 2, -7 },
  { 826, 13, 4, 28, 7, -13 },
  { 833, 6, 7, 28, 9, -7 },
  { 839, 29, 33, 28, 0, -33 },
  { 959, 23, 30, 28, 3, -30 },
  { 1046, 23, 30, 28, 1, -30 },
  { 1133, 25, 30, 28, 1, -30 },
  { 1227, 24, 30, 28, 2, -30 },
  { 1317, 24, 30, 28, 1, -30 },
  { 1407, 24, 30, 28, 2, -30 },
  { 1497, 23, 30, 28, 3, -30 },
  { 1584, 22, 30, 28, 6, -30 },
  { 1667, 24, 30, 28, 2, -30 },
  { 1757, 23, 30, 28, 3, -30 },
  { 1844, 10, 25, 28, 9, -25 },
  { 1876, 15, 33, 28, 4, -25 },
  { 1938, 22, 24, 28, 3, -27 },
  { 2004, 22, 15, 28, 3, -23 },
  { 2046, 22, 24, 28, 3, -27 },
  { 2112, 22, 30, 28, 4, -30 },
  { 2195, 28, 39, 28, 0, -33 },
  { 2332, 27, 30, 28, -2, -30 },
  { 2434, 25, 30, 28, 1, -30 },
  { 2528, 24, 30, 28, 3, -30 },
  { 2618, 25, 30, 28, 1, -30 },
  { 2712, 27, 30, 28, 1, -30 },
  { 2814, 26, 30, 28, 2, -30 },
  { 2912, 24, 30, 28, 3, -30 },
  { 3002, 26, 30, 28, 1, -30 },
  { 3100, 25, 30, 28, 2, -30 },
  { 3194, 23, 30, 28, 3, -30 },
  { 3281, 28, 30, 28, 1, -30 },
  { 3386, 20, 30, 28, 3, -30 },
  { 3461, 27, 30, 28, 1, -30 },
  { 3563, 26, 30, 28, 1, -30 },
  { 3661, 25, 30, 28, 2, -30 },
  { 3755, 26, 30, 28, 1, -30 },
  { 3853, 25, 40, 28, 2, -30 },
  { 3978, 26, 30, 28, 1, -30 },
  { 4076, 26, 30, 28, 1, -30 },
  { 4174, 24, 30, 28, 5, -30 },
  { 4264, 26, 30, 28, 2, -30 },
  { 4362, 27, 30, 28, 4, -30 },
  { 4464, 29, 30, 28, 2, -30 },
  { 4573, 31, 30, 28, -2, -30 },
  { 4690, 26, 30, 28, 4, -30 },
  { 4788, 29, 30, 28, -1, -30 },
  { 4897, 21, 43, 28, 5, -33 },
  { 5010, 16, 33, 28, 7, -33 },
  { 5076, 20, 43, 28, 2, -33 },
  { 5184, 21, 20, 28, 3, -30 },
  { 5237, 28, 2, 28, -3, 3 },
  { 5244, 9, 6, 28, 13, -33 },
  { 5251, 22, 25, 28, 2, -25 },
  { 5320, 23, 33, 28, 2, -33 },
  { 5415, 22, 25, 28, 3, -25 },
  { 5484, 25, 33, 28, 3, -33 },
  { 5588, 22, 25, 28, 3, -25 },
  { 5657, 24, 33, 28, 5, -33 },
  { 5756, 24, 35, 28, 2, -25 },
  { 5861, 23, 33, 28, 2, -33 },
  { 5956, 23, 33, 28, 1, -33 },
  { 6051, 24, 43, 28, -1, -33 },
  { 6180, 24, 33, 28, 3, -33 },
  { 6279, 22, 33, 28, 1, -33 },
  { 6370, 27, 25, 28, 0, -25 },
  { 6455, 23, 25, 28, 2, -25 },
  { 6527, 22, 25, 28, 3, -25 },
  { 6596, 25, 35, 28, 0, -25 },
  { 6706, 23, 35, 28, 3, -25 },
  { 6807, 22, 25, 28, 4, -25 },
  { 6876, 23, 25, 28, 2, -25 },
  { 6948, 18, 31, 28, 6, -31 },
  { 7018, 23, 25, 28, 3, -25 },
  { 7090, 24, 25, 28, 4, -25 },
  { 7165, 27, 25, 28, 2, -25 },
  { 7250, 27, 25, 28, 0, -25 },
  { 7335, 28, 35, 28, 0, -25 },
  { 7458, 25, 25, 28, 1, -25 },
  { 7537, 23, 43, 28, 5, -33 },
  { 7661, 4, 43, 28, 12, -33 },
  { 7683, 23, 43, 28, 0, -33 },
  { 7807, 23, 6, 28, 3, -18 },
};

const GFXfont LiberationMono_Italic46pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic46pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic46pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _LIBERATIONMONO_ITALIC46PT7B_H_
