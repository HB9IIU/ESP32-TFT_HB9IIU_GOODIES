#ifndef _LIBERATIONMONO_ITALIC22PT7B_H_
#define _LIBERATIONMONO_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x21, 0x00, 0x06, 0x30, 0x63, 0x63,
  0x67, 0xC6, 0xC6, 0xC6, 0xC6, 0x03, 0x18, 0x10, 0x81, 0x84, 0x08, 0x43,
  0xFF, 0x84, 0x20, 0x21, 0x02, 0x10, 0xFF, 0xF1, 0x0C, 0x08, 0x40, 0x42,
  0x04, 0x20, 0x21, 0x00, 0x00, 0x80, 0x04, 0x01, 0xF8, 0x3B, 0x61, 0x99,
  0x98, 0x8C, 0xC4, 0x03, 0x20, 0x0F, 0x80, 0x17, 0x00, 0x8C, 0x04, 0x6C,
  0x23, 0x33, 0x19, 0x99, 0x87, 0xF0, 0x04, 0x00, 0x20, 0x00, 0x1E, 0x0C,
  0x88, 0x66, 0x23, 0x18, 0x98, 0x46, 0xC1, 0x96, 0x03, 0x90, 0x00, 0xBC,
  0x05, 0x98, 0x24, 0x61, 0x11, 0x8C, 0xC4, 0x61, 0x33, 0x07, 0x80, 0x03,
  0xC0, 0x46, 0x0C, 0x20, 0x86, 0x08, 0xC0, 0xF8, 0x1C, 0x03, 0x43, 0x66,
  0x2C, 0x66, 0xC3, 0xCC, 0x18, 0xC3, 0xC7, 0xC7, 0x76, 0x66, 0x64, 0x40,
  0x03, 0x03, 0x03, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00,
  0x0C, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x08, 0x08, 0xDB,
  0x7C, 0x38, 0x28, 0x6C, 0x48, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41,
  0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1C, 0xE3, 0x1C,
  0x61, 0x0C, 0x00, 0x7E, 0x6F, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x07, 0xC3,
  0x0C, 0xC1, 0x98, 0x36, 0x06, 0xC0, 0xD9, 0x9A, 0x33, 0xCE, 0x78, 0x0B,
  0x03, 0x20, 0x46, 0x10, 0x7C, 0x00, 0x01, 0x81, 0xE3, 0x98, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x3F, 0xF0,
  0x03, 0xE0, 0xC3, 0x18, 0x31, 0x83, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x07, 0xFE, 0x07, 0xC3, 0x0C,
  0xC1, 0x98, 0x30, 0x06, 0x01, 0x83, 0xC0, 0x0E, 0x00, 0xC0, 0x1B, 0x03,
  0x60, 0x66, 0x18, 0x7C, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0x60, 0xCC,
  0x31, 0x8C, 0x63, 0x0C, 0xC1, 0x9F, 0xFC, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x1F, 0xE1, 0x00, 0x30, 0x03, 0x00, 0x2F, 0x87, 0x0C, 0x60, 0xE0,
  0x06, 0x00, 0x60, 0x0C, 0xC0, 0xCC, 0x08, 0x63, 0x83, 0xE0, 0x0F, 0x83,
  0x18, 0xC3, 0x30, 0x06, 0x01, 0x9E, 0x3C, 0x66, 0x06, 0xC0, 0xD8, 0x1B,
  0x06, 0x60, 0xCE, 0x30, 0xF8, 0x00, 0xFF, 0xC0, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x00,
  0x07, 0xC3, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x61, 0x83, 0xC1, 0x86, 0x60,
  0xD8, 0x1B, 0x03, 0x60, 0x6E, 0x18, 0x7C, 0x00, 0x07, 0xC3, 0x1C, 0xC1,
  0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x07, 0x31, 0x63, 0xD8, 0x03, 0x60,
  0xC6, 0x30, 0x78, 0x00, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x19, 0xC0,
  0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE1, 0x87, 0x0C,
  0x10, 0x60, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x38,
  0x18, 0x0C, 0x02, 0x00, 0x00, 0x0F, 0x86, 0x19, 0x81, 0xE0, 0x7C, 0x0C,
  0x03, 0x81, 0xC0, 0x70, 0x18, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0xE0, 0x30, 0x83, 0x06, 0x30, 0x11, 0x3A, 0x93, 0x34, 0x91,
  0xAD, 0x09, 0x48, 0x4A, 0xC6, 0x74, 0x27, 0xA3, 0x2D, 0x1B, 0x69, 0x93,
  0x77, 0x18, 0x00, 0x40, 0x43, 0x0C, 0x0F, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x58, 0x06, 0xC0, 0x26, 0x03, 0x18, 0x30, 0xC1, 0x06, 0x1F, 0xF0, 0x81,
  0x8C, 0x04, 0xC0, 0x36, 0x01, 0xE0, 0x0C, 0x3F, 0xC3, 0x06, 0x30, 0x73,
  0x06, 0x30, 0x66, 0x0C, 0x7F, 0x06, 0x0C, 0x60, 0x66, 0x06, 0xC0, 0x6C,
  0x0C, 0xC1, 0xCF, 0xF0, 0x07, 0xC1, 0x86, 0x30, 0x33, 0x03, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x04, 0xC0, 0x46, 0x0C, 0x61, 0x83,
  0xE0, 0x3F, 0x83, 0x0E, 0x30, 0x63, 0x07, 0x30, 0x36, 0x03, 0x60, 0x66,
  0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x18, 0xC3, 0x0F, 0xC0, 0x3F, 0xF3,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x7F, 0xC6, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0x1F, 0xF3, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x7F, 0xE6, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x33, 0x03, 0x60, 0x06,
  0x00, 0x63, 0xEE, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xC6, 0x0C, 0x61, 0xC3,
  0xF0, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x66, 0x06, 0x7F, 0xE6,
  0x0E, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0x1F, 0xF0,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xF8, 0x03, 0xE0, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x31, 0x86, 0x30, 0xC6,
  0x30, 0x7C, 0x00, 0x30, 0x31, 0x83, 0x0C, 0x30, 0x63, 0x03, 0x70, 0x37,
  0x01, 0xF8, 0x0F, 0xC0, 0x67, 0x03, 0x18, 0x30, 0x61, 0x83, 0x8C, 0x0C,
  0x60, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xF0, 0x1C, 0x18, 0x70, 0xE1,
  0xC7, 0x8D, 0x1E, 0x36, 0xD8, 0xDA, 0x43, 0x7B, 0x09, 0xCC, 0x62, 0x31,
  0x80, 0xC6, 0x02, 0x10, 0x18, 0x40, 0x63, 0x01, 0x80, 0x38, 0x33, 0x83,
  0x3C, 0x32, 0xC2, 0x2C, 0x66, 0x46, 0x66, 0x66, 0x66, 0x66, 0x44, 0x2C,
  0xC3, 0xCC, 0x3C, 0xC3, 0xCC, 0x18, 0x07, 0xC1, 0x86, 0x30, 0x63, 0x07,
  0x60, 0x76, 0x07, 0xE0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCE, 0x08,
  0x61, 0x83, 0xE0, 0x3F, 0xC3, 0x07, 0x30, 0x33, 0x03, 0x30, 0x36, 0x06,
  0x60, 0xC7, 0xF8, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x07, 0xC1, 0x86, 0x30, 0x63, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x6C, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0xCE, 0x08, 0x61, 0x83, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x3F, 0xE3, 0x07, 0x30, 0x33, 0x03, 0x20,
  0x66, 0x0E, 0x7F, 0x86, 0x30, 0x63, 0x04, 0x38, 0xC1, 0x8C, 0x18, 0xC0,
  0xCC, 0x0C, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x30, 0x33, 0x80, 0x0E, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xB8, 0x0C, 0xC0, 0xC7, 0x0C, 0x1F,
  0xC0, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x33,
  0x03, 0x30, 0x33, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6C,
  0x0C, 0xC0, 0xCC, 0x0C, 0x61, 0x83, 0xE0, 0xC0, 0x36, 0x01, 0xB0, 0x19,
  0xC0, 0xC6, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x60, 0x63, 0x01, 0xB0, 0x0D,
  0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x0D, 0x80, 0x66, 0x01, 0x90,
  0x06, 0x46, 0x33, 0x18, 0xCC, 0xF3, 0x32, 0xD8, 0xDB, 0x63, 0x4D, 0x0D,
  0x3C, 0x3C, 0xF0, 0xE3, 0x83, 0x86, 0x00, 0x0C, 0x0E, 0x18, 0x18, 0x18,
  0x60, 0x31, 0x80, 0x36, 0x00, 0x78, 0x00, 0x60, 0x01, 0xC0, 0x06, 0xC0,
  0x19, 0x80, 0x71, 0x80, 0xC3, 0x03, 0x03, 0x0C, 0x06, 0x00, 0xC0, 0x36,
  0x06, 0x60, 0xC3, 0x1C, 0x31, 0x81, 0xB0, 0x1E, 0x01, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x0F, 0xC3, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xFC, 0x00, 0xC0,
  0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x03, 0x0F, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0xFC, 0x00, 0x03, 0x00, 0xF0, 0x16, 0x06, 0x41,
  0x88, 0x21, 0x8C, 0x31, 0x06, 0x60, 0x48, 0x08, 0xFF, 0xFC, 0xE6, 0x30,
  0x0F, 0x86, 0x18, 0xC3, 0x00, 0x60, 0x0C, 0x3F, 0x98, 0x36, 0x0E, 0xC1,
  0x98, 0x73, 0x1E, 0x3C, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x7C,
  0x71, 0xCC, 0x19, 0x83, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x66, 0x0D, 0xC1,
  0x38, 0x66, 0xF0, 0x0F, 0xC3, 0x1C, 0xC1, 0xB0, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x19, 0x86, 0x1F, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x0F, 0x63, 0x0E, 0x30, 0xE6, 0x06, 0x60, 0xE6, 0x0C, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0x63, 0x87, 0xD8, 0x0F, 0x83, 0x18, 0xC1,
  0xB0, 0x36, 0x06, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x1C, 0x19, 0x86, 0x1F,
  0x00, 0x03, 0xF0, 0xE0, 0x0C, 0x00, 0x80, 0xFF, 0xC1, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x0F, 0x67, 0x1C, 0xC3, 0xB0, 0x76, 0x06, 0xC1, 0xB0, 0x36, 0x06,
  0xC0, 0xD8, 0x39, 0x8A, 0x1E, 0xC0, 0x18, 0x03, 0x30, 0xC6, 0x18, 0x7C,
  0x00, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x7C, 0x71, 0xCC, 0x19, 0x83,
  0x60, 0x6C, 0x19, 0x83, 0x30, 0x64, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x83, 0xFF, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0xFC, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x63, 0x0C, 0x31, 0x83, 0x60, 0x3C, 0x03, 0xE0, 0x66, 0x06, 0x30, 0x63,
  0x06, 0x18, 0x61, 0x84, 0x1C, 0x07, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x87, 0xFF, 0x37, 0x71, 0xDC, 0xCC, 0xC6, 0x46, 0x36, 0x33, 0x31,
  0x99, 0x88, 0xCC, 0xC6, 0x46, 0x36, 0x31, 0x31, 0x99, 0x88, 0xC0, 0x37,
  0xC7, 0x1C, 0xC1, 0xB8, 0x36, 0x06, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xD8,
  0x1B, 0x06, 0x60, 0xC0, 0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x36, 0x07, 0xC0,
  0xF0, 0x1E, 0x06, 0xC0, 0xD8, 0x11, 0x86, 0x1F, 0x00, 0x1B, 0xE1, 0xC7,
  0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x67, 0x04,
  0x70, 0xC6, 0xF0, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F,
  0x66, 0x1C, 0xC3, 0xB0, 0x76, 0x0E, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xD8,
  0x39, 0x8E, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x33,
  0xCD, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x98, 0x03, 0x80, 0x7E, 0x01, 0xE0,
  0x06, 0x00, 0xD8, 0x1B, 0x86, 0x1F, 0x00, 0x10, 0x08, 0x0C, 0x1F, 0xE3,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x01, 0xF8,
  0x30, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x06, 0xC1, 0x98, 0x33, 0x06, 0x60,
  0xD8, 0x39, 0x8A, 0x3E, 0xC0, 0xC0, 0x6C, 0x06, 0xC0, 0xC6, 0x1C, 0x61,
  0x86, 0x30, 0x63, 0x06, 0x60, 0x36, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xC0,
  0x1E, 0x00, 0xF0, 0x0D, 0x8C, 0x6C, 0xE2, 0x65, 0x33, 0x6D, 0x9A, 0x68,
  0xF3, 0xC7, 0x1E, 0x38, 0xE1, 0x83, 0x00, 0x18, 0x38, 0xC1, 0x83, 0x18,
  0x19, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xB0, 0x19, 0x81, 0x86, 0x18,
  0x31, 0x80, 0xC0, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x06, 0x0C, 0x18, 0x60,
  0x63, 0x01, 0x8C, 0x02, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x07, 0xFC, 0x01, 0xE0, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x03, 0x80, 0x18, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x0F, 0x00, 0x78, 0x0C, 0x62, 0x01, 0xC0,
};

const GFXglyph LiberationMono_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 14, 13, 4, -14 },
  { 10, 8, 7, 13, 4, -16 },
  { 17, 13, 14, 13, 0, -14 },
  { 40, 13, 18, 13, 0, -16 },
  { 70, 14, 14, 13, 0, -14 },
  { 95, 12, 14, 13, 0, -14 },
  { 116, 4, 7, 13, 6, -16 },
  { 120, 9, 21, 13, 3, -16 },
  { 144, 8, 21, 13, 2, -16 },
  { 165, 8, 8, 13, 4, -16 },
  { 173, 11, 11, 13, 1, -13 },
  { 189, 6, 7, 13, 1, -3 },
  { 195, 7, 1, 13, 3, -6 },
  { 196, 3, 3, 13, 4, -3 },
  { 198, 14, 16, 13, 0, -16 },
  { 226, 11, 14, 13, 1, -14 },
  { 246, 10, 14, 13, 1, -14 },
  { 264, 12, 14, 13, 0, -14 },
  { 285, 11, 14, 13, 1, -14 },
  { 305, 11, 14, 13, 1, -14 },
  { 325, 12, 14, 13, 1, -14 },
  { 346, 11, 14, 13, 2, -14 },
  { 366, 10, 14, 13, 3, -14 },
  { 384, 11, 14, 13, 1, -14 },
  { 404, 11, 14, 13, 1, -14 },
  { 424, 5, 12, 13, 4, -12 },
  { 432, 7, 16, 13, 2, -12 },
  { 446, 11, 11, 13, 1, -13 },
  { 462, 11, 5, 13, 1, -10 },
  { 469, 11, 11, 13, 1, -13 },
  { 485, 11, 14, 13, 2, -14 },
  { 505, 13, 19, 13, 0, -16 },
  { 536, 13, 14, 13, -1, -14 },
  { 559, 12, 14, 13, 1, -14 },
  { 580, 12, 14, 13, 1, -14 },
  { 601, 12, 14, 13, 1, -14 },
  { 622, 12, 14, 13, 1, -14 },
  { 643, 12, 14, 13, 1, -14 },
  { 664, 12, 14, 13, 1, -14 },
  { 685, 12, 14, 13, 1, -14 },
  { 706, 12, 14, 13, 1, -14 },
  { 727, 11, 14, 13, 1, -14 },
  { 747, 13, 14, 13, 1, -14 },
  { 770, 10, 14, 13, 1, -14 },
  { 788, 14, 14, 13, 0, -14 },
  { 813, 12, 14, 13, 1, -14 },
  { 834, 12, 14, 13, 1, -14 },
  { 855, 12, 14, 13, 1, -14 },
  { 876, 12, 19, 13, 1, -14 },
  { 905, 12, 14, 13, 1, -14 },
  { 926, 13, 14, 13, 0, -14 },
  { 949, 12, 14, 13, 2, -14 },
  { 970, 12, 14, 13, 1, -14 },
  { 991, 13, 14, 13, 2, -14 },
  { 1014, 14, 14, 13, 1, -14 },
  { 1039, 15, 14, 13, -1, -14 },
  { 1066, 12, 14, 13, 2, -14 },
  { 1087, 14, 14, 13, 0, -14 },
  { 1112, 10, 21, 13, 2, -16 },
  { 1139, 8, 16, 13, 3, -16 },
  { 1155, 10, 21, 13, 1, -16 },
  { 1182, 11, 10, 13, 1, -14 },
  { 1196, 14, 1, 13, -2, 1 },
  { 1198, 4, 3, 13, 6, -16 },
  { 1200, 11, 12, 13, 1, -12 },
  { 1217, 11, 16, 13, 1, -16 },
  { 1239, 11, 12, 13, 1, -12 },
  { 1256, 12, 16, 13, 1, -16 },
  { 1280, 11, 12, 13, 1, -12 },
  { 1297, 12, 16, 13, 2, -16 },
  { 1321, 11, 17, 13, 1, -12 },
  { 1345, 11, 16, 13, 1, -16 },
  { 1367, 11, 16, 13, 0, -16 },
  { 1389, 12, 21, 13, -1, -16 },
  { 1421, 12, 16, 13, 1, -16 },
  { 1445, 11, 16, 13, 0, -16 },
  { 1467, 13, 12, 13, 0, -12 },
  { 1487, 11, 12, 13, 1, -12 },
  { 1504, 11, 12, 13, 1, -12 },
  { 1521, 12, 17, 13, 0, -12 },
  { 1547, 11, 17, 13, 1, -12 },
  { 1571, 10, 12, 13, 2, -12 },
  { 1586, 11, 12, 13, 1, -12 },
  { 1603, 9, 15, 13, 3, -15 },
  { 1620, 11, 12, 13, 1, -12 },
  { 1637, 12, 12, 13, 2, -12 },
  { 1655, 13, 12, 13, 1, -12 },
  { 1675, 13, 12, 13, 0, -12 },
  { 1695, 14, 17, 13, 0, -12 },
  { 1725, 12, 12, 13, 0, -12 },
  { 1743, 11, 21, 13, 2, -16 },
  { 1772, 1, 21, 13, 6, -16 },
  { 1775, 11, 21, 13, 0, -16 },
  { 1804, 12, 3, 13, 1, -9 },
};

const GFXfont LiberationMono_Italic22pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic22pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic22pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _LIBERATIONMONO_ITALIC22PT7B_H_
