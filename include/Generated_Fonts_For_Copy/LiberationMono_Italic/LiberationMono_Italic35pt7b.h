#ifndef _LIBERATIONMONO_ITALIC35PT7B_H_
#define _LIBERATIONMONO_ITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xE0,
  0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xE7, 0x87, 0x38, 0x39, 0xC1, 0xCE,
  0x0C, 0x70, 0xE3, 0x07, 0x38, 0x38, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x20, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xF1, 0x9E, 0x0E, 0x18,
  0xE1, 0xC3, 0x8F, 0x1C, 0x30, 0x61, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC3,
  0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x63, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0xCE, 0x0C, 0x1C, 0xE0, 0xC1, 0xCE,
  0x0C, 0x1C, 0xF0, 0xC3, 0x87, 0x9C, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x0E, 0x0F,
  0xE0, 0x18, 0x38, 0xC0, 0x60, 0xE1, 0xC1, 0x81, 0x83, 0x86, 0x03, 0x06,
  0x1C, 0x06, 0x0C, 0x70, 0x1C, 0x19, 0xC0, 0x38, 0x77, 0x00, 0x31, 0xDC,
  0x00, 0x7F, 0x30, 0x00, 0x7C, 0xCF, 0x80, 0x03, 0x3F, 0x80, 0x0C, 0xE3,
  0x00, 0x3B, 0x87, 0x00, 0xE6, 0x0E, 0x03, 0x8C, 0x18, 0x0E, 0x38, 0x30,
  0x38, 0x70, 0xE0, 0x60, 0xE1, 0xC1, 0x81, 0xC7, 0x06, 0x01, 0xFC, 0x18,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0x8F, 0x00, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x1C, 0x78, 0x03, 0xBE,
  0x00, 0x7F, 0x00, 0x1F, 0x03, 0x07, 0xE0, 0x73, 0xDC, 0x1C, 0x71, 0xC3,
  0x9C, 0x38, 0xE7, 0x03, 0x9C, 0xE0, 0x7F, 0x1C, 0x07, 0xC3, 0x80, 0x78,
  0x70, 0x1F, 0x0F, 0x07, 0xF8, 0xFF, 0xCF, 0xC7, 0xE0, 0x78, 0x39, 0xE7,
  0x9E, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00, 0xC0, 0xC6, 0x37, 0xB7, 0xBF,
  0xF8, 0x3E, 0x01, 0xE0, 0x1B, 0x81, 0xCC, 0x1C, 0x70, 0x41, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07, 0xC1, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x00, 0x7F,
  0xCF, 0xF9, 0xFF, 0x00, 0x7F, 0xBD, 0xEF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x78,
  0x38, 0x0E, 0x1C, 0x03, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0xF7, 0x1E, 0x39, 0xC7, 0x8E, 0xE1, 0xE3, 0xB8, 0x78,
  0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1,
  0xC0, 0x70, 0x78, 0x78, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x1F, 0x80, 0x3F, 0x81, 0xF9, 0xC0, 0xE0, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x03, 0x80, 0xF0, 0xE0, 0x0E, 0x1C, 0x01,
  0xC7, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xF0, 0x78,
  0x78, 0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3,
  0xC0, 0x78, 0x78, 0x3C, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0xFC, 0x03, 0xFF,
  0xE0, 0x7C, 0x3E, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07,
  0x07, 0xC3, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x81, 0xC3, 0xC1, 0xC0, 0xF1, 0xC0, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x71, 0xF0, 0x3B, 0xFE, 0x3B, 0x07, 0x9F, 0x01, 0xCF, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07,
  0x1E, 0x07, 0x87, 0x87, 0x81, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0xF0, 0x78, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x3C, 0xF0,
  0x0E, 0x1C, 0x07, 0x07, 0x83, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3C, 0x1E,
  0x1E, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0xE3, 0x80, 0x78, 0xF8, 0x3C, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0x9E, 0x00, 0xE3, 0x80, 0x78,
  0xE0, 0x3E, 0x3C, 0x1B, 0x87, 0xFD, 0xE0, 0xFC, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x8E, 0x01, 0xC3, 0xC0, 0xE0, 0x70, 0x70, 0x1F, 0xF8,
  0x01, 0xF8, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x3C, 0x78, 0xF1, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x18, 0x06, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x07,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00,
  0xF7, 0x00, 0x3B, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x3C,
  0x3C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x83, 0x80, 0x0C, 0x38, 0x73, 0x61,
  0x8F, 0xDB, 0x1C, 0xE2, 0xD8, 0xCE, 0x1C, 0xCE, 0x60, 0xE6, 0x67, 0x06,
  0x33, 0x30, 0x31, 0xBB, 0x83, 0x8D, 0x98, 0x18, 0xCC, 0xC0, 0xC6, 0x66,
  0x0E, 0x37, 0x70, 0x63, 0x3B, 0x87, 0x19, 0x9C, 0x79, 0x8C, 0xE6, 0xDC,
  0x73, 0xE7, 0xC3, 0x8E, 0x3C, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x10, 0x1C, 0x01, 0xC0, 0x78, 0x38, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0,
  0x07, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x78, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x70, 0x00, 0xF3, 0x80, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x38, 0x0F, 0x87, 0x00, 0xF0, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x80, 0x78, 0x70, 0x07, 0x8E, 0x00,
  0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x03,
  0xCF, 0x00, 0xF1, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1E, 0x1E, 0x07, 0x01, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0xCE, 0x00,
  0x23, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x1E, 0x00, 0xF3, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0xC3, 0xC0, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x38, 0x3E, 0x07, 0x01,
  0xE0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x73, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x3C,
  0x38, 0x0F, 0x0F, 0x07, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x1E, 0x07, 0x01,
  0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x63, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC1, 0xFE, 0x78, 0x3F, 0xCF, 0x00, 0x39, 0xE0, 0x0F,
  0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C,
  0x38, 0x07, 0x87, 0xC3, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x00,
  0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0,
  0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87,
  0x80, 0x38, 0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x70,
  0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x70, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x70, 0x0F,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x70, 0x07, 0x83, 0x80, 0x78,
  0x1C, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x03, 0x8F,
  0x00, 0x1C, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F,
  0x81, 0xF0, 0xFC, 0x1B, 0x87, 0xE1, 0xD8, 0x37, 0x0D, 0xC3, 0x98, 0xEE,
  0x1C, 0xE6, 0x70, 0xE7, 0x73, 0x87, 0x3F, 0x18, 0x31, 0xF1, 0xC3, 0x87,
  0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01,
  0xC3, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0xF8, 0x07, 0x0F, 0x80, 0xE0,
  0xF8, 0x0E, 0x0D, 0x80, 0xE1, 0xDC, 0x0E, 0x1D, 0xC0, 0xE1, 0xDC, 0x1C,
  0x1C, 0xE1, 0xC1, 0xCE, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x71,
  0x83, 0x87, 0x38, 0x38, 0x73, 0x87, 0x07, 0x38, 0x70, 0x3B, 0x87, 0x03,
  0xB8, 0x70, 0x3B, 0x07, 0x01, 0xF0, 0xE0, 0x1F, 0x0E, 0x01, 0xF0, 0xE0,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x0E, 0x1C,
  0x03, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B,
  0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x70, 0x78,
  0x78, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0E,
  0x03, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38,
  0x0E, 0x1C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE3, 0xC0,
  0x70, 0x78, 0x78, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x01, 0xE0, 0xE0, 0x0F, 0x0E, 0x00,
  0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0,
  0x78, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x38, 0x78, 0x03, 0x83, 0x80, 0x38,
  0x3C, 0x07, 0x81, 0xC0, 0x70, 0x1E, 0x07, 0x01, 0xE0, 0x70, 0x0E, 0x07,
  0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x78, 0xE0, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0xF8, 0x1E, 0x0F, 0x87, 0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x03, 0x87, 0x81, 0xE0,
  0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x78, 0x0E, 0x0F,
  0x03, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x77, 0x80, 0x07,
  0xBC, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x80,
  0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xF1, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x01,
  0xCF, 0x00, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x87, 0x87, 0x0E,
  0x1F, 0x1C, 0x38, 0xFC, 0x70, 0xE3, 0x73, 0x83, 0x9D, 0xCE, 0x0E, 0x67,
  0x38, 0x3B, 0x9D, 0xC0, 0xEC, 0x37, 0x03, 0xB0, 0xDC, 0x0F, 0x83, 0x60,
  0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x1E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x39, 0xC0, 0x00,
  0x77, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE3, 0x80, 0x07, 0x87,
  0x00, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x1C,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF7, 0x00, 0x1E,
  0x78, 0x01, 0xC3, 0x80, 0x38, 0x3C, 0x07, 0x01, 0xC0, 0xE0, 0x1E, 0x1E,
  0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xD8,
  0x01, 0xDC, 0x01, 0x9C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0E, 0x0E, 0x0E,
  0x1C, 0x06, 0x18, 0x06, 0x38, 0x07, 0x30, 0x07, 0x60, 0x07, 0xE0, 0x03,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0x83, 0x01, 0xFC, 0x03,
  0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x07, 0xFE, 0x1F, 0xFF, 0x1F, 0x03, 0x9E, 0x01, 0xCE, 0x01, 0xEF, 0x00,
  0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE1, 0xDC, 0x7F, 0xCF, 0x9F, 0x83, 0xC0,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0xF8, 0x0E, 0xFF, 0x87, 0xE0, 0xF1, 0xF0,
  0x3C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07,
  0x38, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x1E,
  0x03, 0xC7, 0xC1, 0xE1, 0xDF, 0xF0, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0x83, 0xC3, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xF7, 0x00, 0x73, 0xC0, 0x70, 0xF0, 0x78, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x1F, 0x9E, 0x0F, 0xFB, 0x83, 0xC1, 0xF0,
  0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC7,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E,
  0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x1F, 0x83, 0xFE, 0xE0, 0x3F, 0x1C, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0x83, 0xC3, 0x80, 0xF3, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x63, 0xC0, 0x78, 0xF0, 0x78, 0x3F, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xF8, 0xE0, 0xFF, 0xB8, 0x3C, 0x3F, 0x0F, 0x03, 0xE1, 0xC0, 0x3C,
  0x78, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x07, 0xC3,
  0xE1, 0xB8, 0x3F, 0xEE, 0x03, 0xF1, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x0F,
  0x01, 0xC1, 0xE0, 0x78, 0x1E, 0x1E, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0xFC, 0x0E, 0xFF, 0x87, 0x61, 0xE1, 0xF0,
  0x3C, 0x78, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x20, 0x78, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x1E, 0x1E, 0x07,
  0x83, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x1E, 0x01, 0xC7, 0x00, 0x79, 0xC0,
  0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xE3, 0xC0,
  0x3C, 0x38, 0x07, 0x07, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xF0,
  0xE0, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x1C, 0xF1, 0xE1, 0xDF, 0x3F, 0x1E, 0x3E, 0x71, 0xE3, 0xC7, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x38, 0x30, 0x73, 0x87, 0x07, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x70, 0x70, 0xE7, 0x06, 0x0E, 0x70, 0xE0, 0xE7, 0x0E, 0x1C, 0x70,
  0xE1, 0xCE, 0x0E, 0x1C, 0xE0, 0xC1, 0xCE, 0x1C, 0x1C, 0x0E, 0x3F, 0x03,
  0xBF, 0xE1, 0xD8, 0x7C, 0x7C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0xF1, 0xC0,
  0x38, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C,
  0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x3C,
  0x03, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xF3, 0x80,
  0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0xC0, 0x70, 0xF0, 0xF0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0x1F, 0x80, 0xEF, 0xF8, 0x3F, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x3B, 0xFE, 0x0F, 0x3F, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xC3, 0xFE, 0xE1, 0xE0, 0xF8,
  0xF0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07,
  0x8F, 0x03, 0xE3, 0xC1, 0xF0, 0x7F, 0xDC, 0x0F, 0xC7, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x3F, 0x8E, 0x7F, 0x87, 0x7F, 0xC3, 0xF8, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0x81, 0xC3,
  0x80, 0x71, 0x80, 0x39, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x39, 0xE0, 0x78, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xE7, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x1C, 0x01,
  0xC7, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3,
  0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0,
  0x38, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC1, 0xB8, 0x7F, 0xCC,
  0x0F, 0xC7, 0x00, 0xF0, 0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x38, 0x03,
  0x87, 0x00, 0xF0, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x38,
  0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x1E,
  0x1C, 0xE1, 0xE1, 0xCE, 0x3E, 0x1C, 0xE3, 0x63, 0x8E, 0x76, 0x38, 0xE6,
  0x73, 0x0E, 0xE7, 0x70, 0xEC, 0x77, 0x0F, 0xC3, 0x60, 0xD8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x3C, 0x70, 0x00, 0xE7, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x3C, 0x07, 0x80,
  0xE0, 0x78, 0x07, 0x87, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x78, 0x01,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3C, 0x1F, 0xFC, 0x00, 0xFC,
};

const GFXglyph LiberationMono_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 8, 23, 21, 7, -23 },
  { 24, 13, 11, 21, 6, -25 },
  { 42, 21, 23, 21, 0, -23 },
  { 103, 20, 29, 21, 1, -26 },
  { 176, 23, 23, 21, -1, -23 },
  { 243, 19, 23, 21, 0, -23 },
  { 298, 6, 11, 21, 10, -25 },
  { 307, 13, 32, 21, 5, -25 },
  { 359, 13, 32, 21, 3, -25 },
  { 411, 13, 12, 21, 6, -25 },
  { 431, 17, 16, 21, 2, -20 },
  { 465, 10, 11, 21, 1, -5 },
  { 479, 11, 3, 21, 5, -10 },
  { 484, 5, 5, 21, 7, -5 },
  { 488, 22, 25, 21, 0, -25 },
  { 557, 18, 23, 21, 2, -23 },
  { 609, 17, 23, 21, 1, -23 },
  { 658, 19, 23, 21, 1, -23 },
  { 713, 18, 23, 21, 2, -23 },
  { 765, 18, 23, 21, 1, -23 },
  { 817, 19, 23, 21, 1, -23 },
  { 872, 17, 23, 21, 3, -23 },
  { 921, 16, 23, 21, 5, -23 },
  { 967, 18, 23, 21, 2, -23 },
  { 1019, 18, 23, 21, 2, -23 },
  { 1071, 7, 18, 21, 7, -18 },
  { 1087, 11, 24, 21, 3, -18 },
  { 1120, 17, 17, 21, 2, -20 },
  { 1157, 17, 10, 21, 2, -17 },
  { 1179, 17, 17, 21, 2, -20 },
  { 1216, 17, 23, 21, 3, -23 },
  { 1265, 21, 30, 21, 0, -25 },
  { 1344, 21, 23, 21, -2, -23 },
  { 1405, 19, 23, 21, 1, -23 },
  { 1460, 19, 23, 21, 2, -23 },
  { 1515, 19, 23, 21, 1, -23 },
  { 1570, 20, 23, 21, 1, -23 },
  { 1628, 19, 23, 21, 2, -23 },
  { 1683, 19, 23, 21, 2, -23 },
  { 1738, 20, 23, 21, 1, -23 },
  { 1796, 18, 23, 21, 2, -23 },
  { 1848, 18, 23, 21, 2, -23 },
  { 1900, 21, 23, 21, 1, -23 },
  { 1961, 16, 23, 21, 2, -23 },
  { 2007, 21, 23, 21, 0, -23 },
  { 2068, 20, 23, 21, 1, -23 },
  { 2126, 18, 23, 21, 2, -23 },
  { 2178, 20, 23, 21, 1, -23 },
  { 2236, 18, 30, 21, 2, -23 },
  { 2304, 20, 23, 21, 1, -23 },
  { 2362, 19, 23, 21, 1, -23 },
  { 2417, 19, 23, 21, 3, -23 },
  { 2472, 19, 23, 21, 2, -23 },
  { 2527, 21, 23, 21, 3, -23 },
  { 2588, 22, 23, 21, 2, -23 },
  { 2652, 23, 23, 21, -1, -23 },
  { 2719, 20, 23, 21, 3, -23 },
  { 2777, 23, 23, 21, -1, -23 },
  { 2844, 15, 32, 21, 4, -25 },
  { 2904, 12, 25, 21, 5, -25 },
  { 2942, 16, 32, 21, 1, -25 },
  { 3006, 16, 15, 21, 2, -23 },
  { 3036, 22, 2, 21, -3, 2 },
  { 3042, 6, 4, 21, 10, -25 },
  { 3045, 17, 18, 21, 1, -18 },
  { 3084, 18, 25, 21, 1, -25 },
  { 3141, 17, 18, 21, 2, -18 },
  { 3180, 19, 25, 21, 2, -25 },
  { 3240, 17, 18, 21, 2, -18 },
  { 3279, 18, 25, 21, 4, -25 },
  { 3336, 19, 25, 21, 1, -18 },
  { 3396, 18, 25, 21, 1, -25 },
  { 3453, 17, 25, 21, 1, -25 },
  { 3507, 18, 32, 21, -1, -25 },
  { 3579, 19, 25, 21, 2, -25 },
  { 3639, 18, 25, 21, 0, -25 },
  { 3696, 20, 18, 21, 0, -18 },
  { 3741, 18, 18, 21, 1, -18 },
  { 3782, 17, 18, 21, 2, -18 },
  { 3821, 19, 25, 21, 0, -18 },
  { 3881, 18, 25, 21, 2, -18 },
  { 3938, 17, 18, 21, 3, -18 },
  { 3977, 17, 18, 21, 2, -18 },
  { 4016, 13, 23, 21, 5, -23 },
  { 4054, 18, 18, 21, 2, -18 },
  { 4095, 19, 18, 21, 3, -18 },
  { 4138, 20, 18, 21, 2, -18 },
  { 4183, 21, 18, 21, 0, -18 },
  { 4231, 22, 25, 21, 0, -18 },
  { 4300, 18, 18, 21, 1, -18 },
  { 4341, 17, 32, 21, 4, -25 },
  { 4409, 3, 32, 21, 9, -25 },
  { 4421, 17, 32, 21, 0, -25 },
  { 4489, 18, 4, 21, 2, -13 },
};

const GFXfont LiberationMono_Italic35pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic35pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic35pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _LIBERATIONMONO_ITALIC35PT7B_H_
