#ifndef _LIBERATIONMONO_ITALIC21PT7B_H_
#define _LIBERATIONMONO_ITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCC, 0x63, 0x18, 0xC4, 0x23, 0x00, 0x04, 0x60, 0x67, 0x66,
  0xC6, 0xC6, 0xC6, 0xC4, 0x84, 0x02, 0x10, 0x10, 0x81, 0x08, 0x08, 0x43,
  0xFF, 0x84, 0x20, 0x62, 0x02, 0x10, 0xFF, 0xE1, 0x08, 0x08, 0x40, 0x44,
  0x04, 0x20, 0x21, 0x00, 0x00, 0x80, 0x18, 0x07, 0xE1, 0x93, 0x11, 0x33,
  0x11, 0x33, 0x01, 0xB0, 0x0F, 0x80, 0x2E, 0x02, 0x60, 0x23, 0xC6, 0x24,
  0x66, 0x64, 0xC3, 0xF8, 0x04, 0x00, 0xC0, 0x1C, 0x09, 0x30, 0x99, 0x88,
  0x8C, 0x84, 0x6C, 0x22, 0xC0, 0xEC, 0x00, 0xDE, 0x05, 0x90, 0x48, 0x84,
  0xC4, 0x46, 0x66, 0x32, 0x60, 0xE0, 0x03, 0xC1, 0x8C, 0x21, 0x84, 0x20,
  0x8C, 0x1E, 0x07, 0x01, 0xE1, 0x66, 0x78, 0xCB, 0x0F, 0x61, 0xCC, 0x38,
  0xF9, 0xC0, 0x6D, 0xAD, 0xB0, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x30, 0xC3, 0x00, 0x18, 0x33, 0x4B, 0xE3, 0x89, 0x12, 0x00,
  0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x18, 0xE3, 0x18, 0x63, 0x08, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0F, 0x83,
  0x18, 0xC1, 0x90, 0x36, 0x06, 0xC0, 0xD9, 0x9E, 0x72, 0xCE, 0xD8, 0x1B,
  0x02, 0x60, 0xC6, 0x30, 0x7C, 0x00, 0x03, 0x03, 0xC3, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x3F, 0xF0,
  0x07, 0xC0, 0xC7, 0x18, 0x31, 0x83, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x07, 0xFC, 0x0F, 0xC3, 0x1C,
  0xC1, 0x90, 0x30, 0x0C, 0x03, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x1B, 0x03,
  0x60, 0xCE, 0x38, 0x7C, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1B, 0x0D, 0x86,
  0x63, 0x19, 0x86, 0xC1, 0xBF, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x1F,
  0xE6, 0x00, 0xC0, 0x18, 0x02, 0xF0, 0xE3, 0x98, 0x30, 0x06, 0x00, 0xC0,
  0x1B, 0x03, 0x60, 0xCE, 0x30, 0x7C, 0x00, 0x07, 0xC1, 0x1C, 0x41, 0x98,
  0x02, 0x00, 0xDF, 0x1C, 0x73, 0x06, 0x60, 0xC8, 0x19, 0x03, 0x30, 0xC6,
  0x30, 0x7C, 0x00, 0xFF, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x0F, 0x83, 0x1C,
  0xC1, 0x98, 0x33, 0x04, 0x61, 0x83, 0xC3, 0x8C, 0x40, 0xD8, 0x1B, 0x03,
  0x60, 0xCE, 0x38, 0x7C, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x90, 0x36, 0x06,
  0xC0, 0xD8, 0x1B, 0x06, 0x31, 0xC3, 0xD8, 0x02, 0x60, 0xC6, 0x30, 0xF8,
  0x00, 0x31, 0x8C, 0x00, 0x00, 0x00, 0x67, 0x38, 0x0C, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x70, 0xC3, 0x06, 0x18, 0x20, 0x00, 0x00, 0x40,
  0x60, 0xE1, 0xC0, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x40, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x40,
  0xE0, 0xE1, 0xC0, 0x80, 0x00, 0x1F, 0x1C, 0x74, 0x0F, 0x03, 0x00, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0xE0, 0x31, 0x82, 0x04, 0x20, 0x33, 0x3A, 0x92, 0x75, 0xB1, 0x29, 0x1B,
  0x58, 0x96, 0x84, 0xB4, 0x65, 0x22, 0x49, 0x36, 0x4E, 0xE3, 0x00, 0x08,
  0x10, 0x61, 0x81, 0xF0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0xD8, 0x06, 0xC0,
  0x66, 0x02, 0x30, 0x31, 0x81, 0x04, 0x1F, 0xF1, 0x81, 0x88, 0x0C, 0xC0,
  0x66, 0x03, 0x60, 0x18, 0x3F, 0xC6, 0x1C, 0xC1, 0x98, 0x36, 0x04, 0xC1,
  0x9F, 0xC3, 0x06, 0x60, 0xD8, 0x0F, 0x03, 0x60, 0x6C, 0x19, 0xFC, 0x00,
  0x07, 0xC3, 0x1C, 0xC1, 0x98, 0x36, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x01, 0x30, 0x66, 0x18, 0x7C, 0x00, 0x3F, 0x86, 0x18, 0xC1,
  0x90, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xD8, 0x1B, 0x03, 0x60,
  0xCC, 0x31, 0xF8, 0x00, 0x3F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x7F, 0xC6, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFC, 0x3F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x7F, 0xC6,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC3,
  0x1C, 0xC1, 0x90, 0x36, 0x00, 0xC0, 0x18, 0xFE, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0x30, 0x66, 0x18, 0x7C, 0x00, 0x30, 0x63, 0x06, 0x30, 0x63, 0x06,
  0x60, 0x66, 0x04, 0x7F, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x18,
  0xC1, 0x8C, 0x18, 0x1F, 0xE0, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0x00, 0x07,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x33, 0x06, 0x31, 0x86, 0x30, 0x78, 0x00, 0x30, 0x33, 0x0E, 0x31, 0xC3,
  0x38, 0x67, 0x06, 0xE0, 0x7C, 0x07, 0x60, 0x67, 0x0C, 0x30, 0xC3, 0x8C,
  0x18, 0xC1, 0xCC, 0x0C, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3F, 0xE0, 0x18, 0x38,
  0xE1, 0xCF, 0x1C, 0x79, 0xA3, 0x4B, 0x1A, 0xD8, 0x94, 0xCC, 0xE4, 0x66,
  0x23, 0x03, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x20, 0x38, 0x23, 0x86,
  0x38, 0x62, 0x86, 0x6C, 0x66, 0xC4, 0x64, 0x46, 0x6C, 0x46, 0xCC, 0x6C,
  0xC2, 0xCC, 0x38, 0xC3, 0x88, 0x38, 0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x36,
  0x06, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xC6, 0x30,
  0x7C, 0x00, 0x3F, 0xC6, 0x0C, 0xC1, 0x90, 0x36, 0x06, 0xC0, 0xD8, 0x33,
  0xF8, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0F, 0x83,
  0x18, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0xC6, 0x30, 0x7C, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xF0, 0x3F,
  0xC6, 0x0C, 0xC1, 0x90, 0x36, 0x06, 0xC1, 0x9F, 0xC3, 0x30, 0x43, 0x18,
  0x63, 0x0E, 0x60, 0xCC, 0x19, 0x81, 0x80, 0x07, 0xE0, 0xC7, 0x18, 0x33,
  0x03, 0x30, 0x01, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x60, 0x06, 0xC0, 0x66,
  0x06, 0x60, 0xC3, 0xF0, 0xFF, 0xE0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x00,
  0x30, 0x33, 0x02, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x46, 0x0C,
  0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xE3, 0x03, 0xE0, 0xC0, 0x3C, 0x06,
  0xC0, 0x6C, 0x0C, 0x40, 0xC6, 0x18, 0x61, 0x06, 0x30, 0x66, 0x06, 0x60,
  0x2C, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x60, 0x1A, 0x00, 0xD0, 0x0D, 0x80,
  0x6C, 0x63, 0x63, 0x13, 0x29, 0x99, 0x4C, 0xDA, 0x46, 0x96, 0x3C, 0xB1,
  0xC5, 0x0E, 0x38, 0x61, 0xC0, 0x0C, 0x0C, 0x30, 0x60, 0x63, 0x01, 0x98,
  0x03, 0x60, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x06, 0xC0, 0x33, 0x01, 0x8C,
  0x0C, 0x18, 0x30, 0x61, 0x80, 0xC0, 0xC0, 0x66, 0x06, 0x60, 0xC7, 0x18,
  0x33, 0x03, 0x60, 0x1E, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x7F, 0xF0, 0x0F, 0xC3, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0F, 0xC0, 0xC0, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0x40, 0xC1, 0x80, 0x0F, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x3F, 0x00, 0x03, 0x01, 0x40, 0xD8, 0x26, 0x19, 0x8C, 0x22, 0x09, 0x83,
  0xC0, 0xC0, 0x7F, 0xF8, 0xC6, 0x30, 0x0F, 0x8C, 0x36, 0x0C, 0x03, 0x3F,
  0x98, 0x6C, 0x1B, 0x06, 0xC3, 0xB1, 0x67, 0x9C, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x37, 0x8E, 0x33, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0xE1,
  0xB8, 0xCD, 0xE0, 0x0F, 0x86, 0x18, 0x81, 0xB0, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC1, 0x8C, 0x30, 0xF8, 0x00, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x1F, 0x63, 0x14, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0x8C,
  0x18, 0xC1, 0x8E, 0x38, 0x7D, 0x80, 0x0F, 0x8E, 0x33, 0x0D, 0x81, 0x60,
  0x7F, 0xFC, 0x03, 0x00, 0xC0, 0x98, 0xC3, 0xE0, 0x07, 0xE1, 0x80, 0x20,
  0x0C, 0x0F, 0xFC, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x1F, 0x66, 0x2C, 0x83, 0x30, 0x66, 0x0D,
  0x81, 0xB0, 0x36, 0x0C, 0xC1, 0x8C, 0x71, 0xF6, 0x00, 0xCC, 0x31, 0x8C,
  0x1F, 0x00, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8E, 0x33, 0x0D, 0x83,
  0x60, 0xD8, 0x36, 0x0D, 0x02, 0xC1, 0xB0, 0x6C, 0x18, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x01, 0xF8, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x1F, 0xF8, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC3, 0xF0, 0x00, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x0E, 0x63, 0x0C, 0xC1, 0x60, 0x3C, 0x0C, 0xC1, 0x98,
  0x31, 0x86, 0x30, 0x83, 0x30, 0x60, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xF8, 0x3E, 0x73, 0x3B, 0x33, 0x36, 0x33, 0x62, 0x36, 0x63,
  0x66, 0x24, 0x66, 0xC6, 0x6C, 0x46, 0xCC, 0x60, 0x37, 0x8A, 0x33, 0x0D,
  0x83, 0x60, 0xD8, 0x36, 0x0D, 0x02, 0xC1, 0xB0, 0x6C, 0x18, 0x0F, 0x8C,
  0x32, 0x0D, 0x81, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0x98, 0xC3, 0xE0,
  0x1B, 0xC3, 0x8C, 0xE1, 0x98, 0x13, 0x06, 0x60, 0xCC, 0x1B, 0x83, 0x70,
  0xCE, 0x31, 0xBC, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x1F, 0x66, 0x29,
  0x83, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x26, 0x0C, 0xC1, 0x9C, 0x71, 0xF6,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x27, 0xCB, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0x8C, 0x32, 0x0C,
  0x80, 0x3C, 0x07, 0xC0, 0x38, 0x02, 0xC0, 0xB0, 0x67, 0xE0, 0x10, 0x30,
  0x30, 0xFF, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x7C,
  0x30, 0x66, 0x0D, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x36, 0x0C, 0xC1,
  0x8C, 0x71, 0xF6, 0x00, 0xC0, 0x78, 0x1B, 0x06, 0x30, 0xC6, 0x30, 0xC6,
  0x19, 0x83, 0x60, 0x2C, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x66, 0xCA, 0x6C, 0xA4, 0xD2, 0xCF, 0x2C, 0xE2, 0x8E, 0x38, 0xC3,
  0x80, 0x18, 0x31, 0x86, 0x0C, 0xC0, 0xD8, 0x07, 0x00, 0x60, 0x0F, 0x01,
  0x98, 0x31, 0x86, 0x0C, 0xC0, 0xC0, 0x30, 0x19, 0x81, 0x8C, 0x08, 0x20,
  0xC1, 0x8C, 0x0C, 0x60, 0x66, 0x01, 0x20, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x7F, 0xC0,
  0x03, 0xE0, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x1C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x0F, 0x00, 0x78, 0x10, 0xC4, 0x0F,
  0x00,
};

const GFXglyph LiberationMono_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 14, 13, 4, -14 },
  { 10, 8, 7, 13, 4, -15 },
  { 17, 13, 14, 13, 0, -14 },
  { 40, 12, 18, 13, 0, -16 },
  { 67, 13, 14, 13, 0, -14 },
  { 90, 11, 14, 13, 0, -14 },
  { 110, 3, 7, 13, 6, -15 },
  { 113, 8, 19, 13, 3, -15 },
  { 132, 7, 19, 13, 2, -15 },
  { 149, 7, 7, 13, 4, -15 },
  { 156, 10, 9, 13, 1, -12 },
  { 168, 6, 7, 13, 1, -3 },
  { 174, 6, 1, 13, 3, -6 },
  { 175, 3, 3, 13, 4, -3 },
  { 177, 13, 15, 13, 0, -15 },
  { 202, 11, 14, 13, 1, -14 },
  { 222, 10, 14, 13, 1, -14 },
  { 240, 12, 14, 13, 0, -14 },
  { 261, 11, 14, 13, 1, -14 },
  { 281, 10, 14, 13, 1, -14 },
  { 299, 11, 14, 13, 1, -14 },
  { 319, 11, 14, 13, 1, -14 },
  { 339, 10, 14, 13, 3, -14 },
  { 357, 11, 14, 13, 1, -14 },
  { 377, 11, 14, 13, 1, -14 },
  { 397, 5, 11, 13, 4, -11 },
  { 404, 7, 15, 13, 2, -11 },
  { 418, 10, 9, 13, 1, -12 },
  { 430, 10, 5, 13, 1, -10 },
  { 437, 10, 9, 13, 1, -12 },
  { 449, 10, 14, 13, 2, -14 },
  { 467, 13, 18, 13, 0, -15 },
  { 497, 13, 14, 13, -1, -14 },
  { 520, 11, 14, 13, 1, -14 },
  { 540, 11, 14, 13, 1, -14 },
  { 560, 11, 14, 13, 1, -14 },
  { 580, 12, 14, 13, 1, -14 },
  { 601, 12, 14, 13, 1, -14 },
  { 622, 11, 14, 13, 1, -14 },
  { 642, 12, 14, 13, 1, -14 },
  { 663, 11, 14, 13, 1, -14 },
  { 683, 11, 14, 13, 1, -14 },
  { 703, 12, 14, 13, 1, -14 },
  { 724, 10, 14, 13, 1, -14 },
  { 742, 13, 14, 13, 0, -14 },
  { 765, 12, 14, 13, 1, -14 },
  { 786, 11, 14, 13, 1, -14 },
  { 806, 11, 14, 13, 1, -14 },
  { 826, 11, 18, 13, 1, -14 },
  { 851, 11, 14, 13, 1, -14 },
  { 871, 12, 14, 13, 0, -14 },
  { 892, 11, 14, 13, 2, -14 },
  { 912, 12, 14, 13, 1, -14 },
  { 933, 12, 14, 13, 2, -14 },
  { 954, 13, 14, 13, 1, -14 },
  { 977, 14, 14, 13, -1, -14 },
  { 1002, 12, 14, 13, 2, -14 },
  { 1023, 13, 14, 13, 0, -14 },
  { 1046, 10, 19, 13, 2, -15 },
  { 1070, 7, 15, 13, 3, -15 },
  { 1084, 9, 19, 13, 1, -15 },
  { 1106, 10, 9, 13, 1, -14 },
  { 1118, 13, 1, 13, -2, 1 },
  { 1120, 4, 3, 13, 6, -15 },
  { 1122, 10, 11, 13, 1, -11 },
  { 1136, 10, 15, 13, 1, -15 },
  { 1155, 11, 11, 13, 1, -11 },
  { 1171, 12, 15, 13, 1, -15 },
  { 1194, 10, 11, 13, 1, -11 },
  { 1208, 11, 15, 13, 2, -15 },
  { 1229, 11, 15, 13, 1, -11 },
  { 1250, 10, 15, 13, 1, -15 },
  { 1269, 11, 15, 13, 0, -15 },
  { 1290, 11, 19, 13, -1, -15 },
  { 1317, 11, 15, 13, 1, -15 },
  { 1338, 11, 15, 13, 0, -15 },
  { 1359, 12, 11, 13, 0, -11 },
  { 1376, 10, 11, 13, 1, -11 },
  { 1390, 10, 11, 13, 1, -11 },
  { 1404, 11, 15, 13, 0, -11 },
  { 1425, 11, 15, 13, 1, -11 },
  { 1446, 10, 11, 13, 2, -11 },
  { 1460, 10, 11, 13, 1, -11 },
  { 1474, 8, 14, 13, 3, -14 },
  { 1488, 11, 11, 13, 1, -11 },
  { 1504, 11, 11, 13, 2, -11 },
  { 1520, 12, 11, 13, 1, -11 },
  { 1537, 12, 11, 13, 0, -11 },
  { 1554, 13, 15, 13, 0, -11 },
  { 1579, 12, 11, 13, 0, -11 },
  { 1596, 11, 19, 13, 2, -15 },
  { 1623, 2, 19, 13, 5, -15 },
  { 1628, 10, 19, 13, 0, -15 },
  { 1652, 11, 3, 13, 1, -9 },
};

const GFXfont LiberationMono_Italic21pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic21pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic21pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _LIBERATIONMONO_ITALIC21PT7B_H_
