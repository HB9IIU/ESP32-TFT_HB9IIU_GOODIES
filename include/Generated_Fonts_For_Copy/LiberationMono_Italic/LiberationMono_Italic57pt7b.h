#ifndef _LIBERATIONMONO_ITALIC57PT7B_H_
#define _LIBERATIONMONO_ITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80,
  0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78,
  0x07, 0x81, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x3C, 0xFF,
  0x00, 0xFC, 0x1C, 0x1F, 0x80, 0xFC, 0x0E, 0x07, 0xC0, 0x7C, 0x07, 0x03,
  0xF0, 0x7C, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0x60, 0x1F, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x03, 0xF0, 0x78,
  0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xE1, 0xFC, 0x00, 0x00,
  0x70, 0x3F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x0E, 0x01, 0xF0, 0x30, 0x07, 0x00, 0xF8, 0xF8,
  0x07, 0x80, 0x7C, 0x7C, 0x03, 0xC0, 0x3E, 0x3F, 0x01, 0xE0, 0x3E, 0x1F,
  0x80, 0xE0, 0x3F, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0xFC, 0x38, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0x00,
  0xF8, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x1E, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x0F, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x3C, 0x00, 0x03, 0xE3, 0xE1, 0xE0,
  0x00, 0x0F, 0xFF, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x00,
  0xF1, 0xFF, 0xF0, 0x00, 0x07, 0x8F, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x3C, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x1F, 0xF8, 0x01,
  0xF0, 0x7E, 0xF0, 0x03, 0xC1, 0xF1, 0xF0, 0x07, 0x87, 0xC3, 0xE0, 0x1E,
  0x1F, 0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0xF0, 0xF8, 0x07, 0xC1, 0xE1,
  0xF0, 0x0F, 0x87, 0x83, 0xC0, 0x0F, 0x8F, 0x0F, 0x80, 0x1F, 0x3C, 0x1F,
  0x00, 0x1F, 0xF8, 0x3E, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0x7F, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF8,
  0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xE7, 0xFF, 0xF8, 0xFF, 0x87, 0xFF,
  0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x3C, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x10, 0x3C, 0x09, 0xF1, 0xE3, 0xCF, 0xEE,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x03, 0xE3, 0xC0, 0x3E, 0x1E,
  0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0x20, 0x10, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0xFE, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x0F,
  0xE0, 0xF9, 0xF0, 0x7E, 0x07, 0xDF, 0x83, 0xF0, 0x3E, 0xF8, 0x1F, 0x83,
  0xF7, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x7F, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFD, 0xF0, 0x03, 0xFF,
  0x9F, 0x00, 0x3F, 0xF3, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x07, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0xFF, 0x00, 0x03, 0xCF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x07, 0xF0, 0x03, 0xE3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0x03, 0xDF, 0xFF, 0xF8, 0x7D, 0xF0, 0x7F, 0x87, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0xFE, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0x81,
  0xF7, 0x81, 0xFF, 0xFF, 0x7C, 0x07, 0xFF, 0xF3, 0xE0, 0x0F, 0xFE, 0x1E,
  0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x1F, 0x00, 0xF0, 0x3C, 0x0F, 0xF1, 0xDE, 0x07,
  0x03, 0xFF, 0x7B, 0xC1, 0xE0, 0xF8, 0xEE, 0x78, 0x38, 0x3C, 0x0F, 0xCF,
  0x0F, 0x0F, 0x01, 0xF1, 0xE1, 0xC1, 0xC0, 0x3E, 0x3C, 0x78, 0x78, 0x07,
  0xC7, 0x8F, 0x1E, 0x00, 0xF0, 0xE1, 0xC3, 0xC0, 0x1E, 0x1C, 0x78, 0xF0,
  0x07, 0x83, 0x8F, 0x1E, 0x00, 0xF0, 0xF1, 0xC3, 0x80, 0x1E, 0x1C, 0x38,
  0xF0, 0x07, 0x83, 0x8F, 0x1E, 0x00, 0xF0, 0xF1, 0xE3, 0x80, 0x1C, 0x1E,
  0x3C, 0xF0, 0x07, 0x83, 0x87, 0x1E, 0x00, 0xF0, 0xF0, 0xE3, 0xC0, 0x3C,
  0x1C, 0x1C, 0x78, 0x07, 0x83, 0x87, 0x8F, 0x01, 0xE0, 0xE0, 0xF1, 0xE0,
  0x7C, 0x3C, 0x1E, 0x3C, 0x1F, 0x87, 0x03, 0xC7, 0xC7, 0x71, 0xC0, 0x78,
  0x7F, 0xCF, 0xF0, 0x0F, 0x0F, 0xF1, 0xFC, 0x01, 0xE0, 0xF8, 0x1F, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x06, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x7F, 0xFC, 0x7C, 0x01, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xCF, 0xC0, 0x3F,
  0xFF, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x07, 0xC1, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x38, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x03, 0xE1, 0xFC, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x3E, 0x7F, 0x00,
  0x00, 0x0F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1D, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0x78, 0x03, 0xBE, 0x07, 0xDE, 0x01, 0xEF,
  0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0x7C, 0x1E,
  0x7C, 0x07, 0x9F, 0x07, 0x9F, 0x03, 0xE7, 0xC3, 0xC7, 0x80, 0xF8, 0xF0,
  0xF1, 0xE0, 0x3C, 0x3C, 0x78, 0xF8, 0x0F, 0x0F, 0x1E, 0x3E, 0x03, 0xC3,
  0xCF, 0x0F, 0x81, 0xF0, 0xFB, 0xC3, 0xC0, 0x7C, 0x1F, 0xE0, 0xF0, 0x1F,
  0x07, 0xF8, 0x7C, 0x07, 0x81, 0xFC, 0x1F, 0x01, 0xE0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x81, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F,
  0x03, 0xFC, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x3E,
  0x07, 0xDE, 0x00, 0x3C, 0x07, 0xDF, 0x00, 0x7C, 0x07, 0x9F, 0x00, 0x7C,
  0x07, 0x9F, 0x00, 0x7C, 0x0F, 0x8F, 0x00, 0x7C, 0x0F, 0x8F, 0x80, 0x78,
  0x0F, 0x8F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x0F, 0x07, 0x80, 0xF8,
  0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0,
  0x1F, 0x03, 0xE1, 0xF0, 0x1E, 0x03, 0xE1, 0xF0, 0x1E, 0x03, 0xE1, 0xF0,
  0x3E, 0x01, 0xE1, 0xF0, 0x3E, 0x01, 0xF1, 0xE0, 0x3E, 0x01, 0xF3, 0xE0,
  0x3E, 0x01, 0xF3, 0xE0, 0x3C, 0x00, 0xF3, 0xE0, 0x7C, 0x00, 0xFB, 0xE0,
  0x7C, 0x00, 0xFB, 0xC0, 0x7C, 0x00, 0xFB, 0xC0, 0x7C, 0x00, 0x7B, 0xC0,
  0x78, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x03, 0xFE, 0x03, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1C, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xFE,
  0x07, 0xC0, 0x7C, 0x0F, 0xE0, 0x7C, 0x07, 0xC1, 0xFE, 0x07, 0xC0, 0x78,
  0x1F, 0xE0, 0xF8, 0x07, 0x83, 0xDE, 0x0F, 0x80, 0x78, 0x3D, 0xE0, 0xF0,
  0x07, 0x87, 0x8E, 0x0F, 0x00, 0x78, 0x78, 0xE1, 0xF0, 0x0F, 0x8F, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0xF1, 0xE0, 0x0F, 0x8F, 0x0F, 0x3E, 0x00, 0xF9,
  0xE0, 0xF3, 0xC0, 0x0F, 0x9E, 0x0F, 0x3C, 0x00, 0xFB, 0xC0, 0xF7, 0xC0,
  0x0F, 0xBC, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0xF7, 0x80, 0x0F, 0x78, 0x0F,
  0x78, 0x00, 0xF7, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x07,
  0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0x7C, 0x3F, 0x80, 0x0F,
  0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x0F,
  0xF0, 0xFC, 0x01, 0xDF, 0x0F, 0xE0, 0x79, 0xF8, 0x7F, 0xFF, 0x1F, 0xF7,
  0xFF, 0xE1, 0xFF, 0x3F, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x1F, 0xC0, 0x07, 0xC7, 0xFF, 0x80, 0x3E, 0x7F, 0xFE, 0x01, 0xF7, 0xFF,
  0xF8, 0x1F, 0x78, 0x1F, 0xC0, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x03, 0xF0,
  0x3F, 0xF0, 0x7F, 0x81, 0xF7, 0xFF, 0xF8, 0x1F, 0x3F, 0xFF, 0x80, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF,
  0xCF, 0x80, 0x7F, 0xFF, 0xBF, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7B, 0xE0, 0x1F, 0xFF, 0xE7, 0xC0, 0x1F, 0xFF, 0x8F, 0x00, 0x1F, 0xFE,
  0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x40, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0xC0, 0x7F, 0xFF, 0x9F, 0x03,
  0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x81, 0xF0,
  0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7E,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x1E,
  0xF8, 0x0F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x8F, 0x80, 0x3F, 0xFC, 0x3E,
  0x00, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x07, 0xC7, 0xFF, 0x80, 0x3E, 0x7F,
  0xFE, 0x01, 0xE7, 0xFF, 0xF8, 0x1F, 0x7C, 0x1F, 0xC0, 0xFF, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x01, 0xF1, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x01, 0xE7, 0xF8, 0x7F, 0x81, 0xF7, 0xFC, 0x7F,
  0xC0, 0xF7, 0xFE, 0x7F, 0xF0, 0x7B, 0x1F, 0x71, 0xF8, 0x3F, 0x07, 0xF0,
  0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xC1, 0xF0, 0x1E,
  0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0x01,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0x1F, 0xFE, 0x00, 0xF1, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0xE0, 0x7D,
  0xF0, 0x7F, 0x03, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF1, 0xFF,
  0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF, 0xE0, 0x1F, 0x78, 0x1F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x80,
  0x3F, 0x00, 0xFF, 0xC0, 0xFE, 0x01, 0xF7, 0xFF, 0xF8, 0x03, 0xE7, 0xFF,
  0xE0, 0x0F, 0x87, 0xFF, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC7, 0xC0,
  0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xFB, 0xF0, 0x7F, 0x83, 0xFF, 0x03, 0xF0,
  0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x00, 0x07,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0xFE, 0x07, 0xBE, 0x07, 0xFF, 0xF9,
  0xF0, 0x1F, 0xFF, 0x9F, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0xFF, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xF0, 0x3F, 0xFC, 0x1F,
  0x0F, 0xFF, 0x83, 0xE3, 0xFF, 0xE0, 0x7C, 0xFF, 0xFC, 0x0F, 0xBF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x38, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x07, 0xBE, 0x0F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFE, 0x3E, 0x03,
  0xFF, 0xC3, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x0F,
  0xC0, 0x3C, 0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0x81, 0xFC, 0x07, 0xC3, 0xE0,
  0x7F, 0x83, 0xE0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x87, 0x9E, 0x1F, 0x03, 0xE1, 0xE7, 0x87, 0xC0, 0xF8, 0xF1, 0xE1, 0xE0,
  0x3E, 0x3C, 0x78, 0xF8, 0x0F, 0x9E, 0x0E, 0x3E, 0x03, 0xE7, 0x83, 0x8F,
  0x00, 0xFB, 0xC0, 0xE7, 0xC0, 0x3C, 0xF0, 0x3D, 0xF0, 0x0F, 0x78, 0x0F,
  0x78, 0x03, 0xDE, 0x03, 0xFE, 0x00, 0xF7, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x5F, 0xFF, 0xF8, 0x1E, 0xFF, 0xFF, 0xFF,
  0xF7, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 13, 38, 34, 11, -38 },
  { 63, 22, 18, 34, 10, -41 },
  { 113, 34, 38, 34, 1, -38 },
  { 275, 33, 46, 34, 1, -42 },
  { 465, 38, 40, 34, -1, -39 },
  { 655, 31, 40, 34, 0, -39 },
  { 810, 8, 18, 34, 17, -41 },
  { 828, 21, 53, 34, 9, -41 },
  { 968, 21, 53, 34, 4, -41 },
  { 1108, 21, 20, 34, 10, -41 },
  { 1161, 28, 28, 34, 3, -33 },
  { 1259, 16, 18, 34, 2, -8 },
  { 1295, 16, 4, 34, 9, -16 },
  { 1303, 8, 8, 34, 11, -8 },
  { 1311, 36, 42, 34, 0, -41 },
  { 1500, 29, 40, 34, 3, -39 },
  { 1645, 28, 38, 34, 1, -38 },
  { 1778, 31, 39, 34, 1, -39 },
  { 1930, 29, 40, 34, 3, -39 },
  { 2075, 29, 38, 34, 2, -38 },
  { 2213, 31, 39, 34, 2, -38 },
  { 2365, 28, 40, 34, 4, -39 },
  { 2505, 26, 38, 34, 8, -38 },
  { 2629, 29, 40, 34, 3, -39 },
  { 2774, 29, 40, 34, 3, -39 },
  { 2919, 12, 30, 34, 11, -30 },
  { 2964, 18, 40, 34, 5, -30 },
  { 3054, 28, 29, 34, 3, -33 },
  { 3156, 28, 18, 34, 3, -28 },
  { 3219, 28, 29, 34, 3, -33 },
  { 3321, 28, 39, 34, 5, -39 },
  { 3458, 35, 49, 34, 0, -41 },
  { 3673, 34, 38, 34, -3, -38 },
  { 3835, 31, 38, 34, 2, -38 },
  { 3983, 31, 40, 34, 3, -39 },
  { 4138, 31, 38, 34, 2, -38 },
  { 4286, 32, 38, 34, 2, -38 },
  { 4438, 33, 38, 34, 2, -38 },
  { 4595, 30, 40, 34, 3, -39 },
  { 4745, 32, 38, 34, 2, -38 },
  { 4897, 30, 38, 34, 3, -38 },
  { 5040, 28, 39, 34, 4, -38 },
  { 5177, 34, 38, 34, 2, -38 },
  { 5339, 25, 38, 34, 4, -38 },
  { 5458, 34, 38, 34, 1, -38 },
  { 5620, 32, 38, 34, 2, -38 },
  { 5772, 30, 40, 34, 3, -39 },
  { 5922, 32, 38, 34, 2, -38 },
  { 6074, 30, 51, 34, 3, -39 },
  { 6266, 32, 38, 34, 2, -38 },
  { 6418, 32, 40, 34, 1, -39 },
  { 6578, 30, 38, 34, 6, -38 },
  { 6721, 32, 39, 34, 3, -38 },
  { 6877, 33, 38, 34, 5, -38 },
  { 7034, 36, 38, 34, 3, -38 },
  { 7205, 38, 38, 34, -2, -38 },
  { 7386, 33, 38, 34, 5, -38 },
  { 7543, 36, 38, 34, -1, -38 },
  { 7714, 26, 53, 34, 6, -41 },
  { 7887, 20, 42, 34, 8, -41 },
  { 7992, 26, 53, 34, 2, -41 },
  { 8165, 27, 25, 34, 3, -38 },
  { 8250, 35, 3, 34, -4, 3 },
  { 8264, 11, 7, 34, 16, -40 },
  { 8274, 28, 32, 34, 2, -31 },
  { 8386, 29, 42, 34, 2, -41 },
  { 8539, 28, 32, 34, 3, -31 },
  { 8651, 31, 42, 34, 3, -41 },
  { 8814, 28, 32, 34, 3, -31 },
  { 8926, 30, 41, 34, 6, -41 },
  { 9080, 30, 43, 34, 2, -31 },
  { 9242, 29, 41, 34, 2, -41 },
  { 9391, 28, 41, 34, 1, -41 },
  { 9535, 30, 53, 34, -2, -41 },
  { 9734, 30, 41, 34, 4, -41 },
  { 9888, 28, 41, 34, 1, -41 },
  { 10032, 33, 31, 34, 0, -31 },
  { 10160, 29, 31, 34, 2, -31 },
  { 10273, 28, 32, 34, 3, -31 },
  { 10385, 31, 43, 34, 0, -31 },
  { 10552, 29, 43, 34, 3, -31 },
  { 10708, 27, 31, 34, 5, -31 },
  { 10813, 27, 32, 34, 3, -31 },
  { 10921, 23, 39, 34, 7, -38 },
  { 11034, 28, 31, 34, 4, -30 },
  { 11143, 30, 30, 34, 5, -30 },
  { 11256, 34, 30, 34, 3, -30 },
  { 11384, 34, 30, 34, 0, -30 },
  { 11512, 35, 42, 34, 0, -30 },
  { 11696, 31, 30, 34, 1, -30 },
  { 11813, 29, 53, 34, 6, -41 },
  { 12006, 4, 53, 34, 15, -41 },
  { 12033, 29, 53, 34, -1, -41 },
  { 12226, 29, 7, 34, 3, -22 },
};

const GFXfont LiberationMono_Italic57pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic57pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic57pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _LIBERATIONMONO_ITALIC57PT7B_H_
