#ifndef _LIBERATIONMONO_ITALIC33PT7B_H_
#define _LIBERATIONMONO_ITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x00, 0x78, 0x77, 0x8F,
  0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xCC, 0x1C,
  0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x04, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x18, 0x01, 0x81, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x30,
  0x30, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x40, 0xC0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x18, 0x18, 0x01, 0x81, 0x00, 0x10, 0x30, 0x03,
  0x03, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1E, 0x67, 0x87, 0x0C, 0x70,
  0xE1, 0x8E, 0x18, 0x70, 0xC7, 0x0C, 0x00, 0x71, 0x80, 0x0F, 0x30, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x37, 0xC0, 0x06, 0x3C, 0x00, 0xC3, 0x80,
  0x18, 0x70, 0x03, 0x0E, 0x60, 0xC1, 0xCE, 0x18, 0x39, 0xC3, 0x0E, 0x3C,
  0x67, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xC0, 0x38, 0xFE, 0x03, 0x86, 0x38, 0x18, 0x70, 0xC1,
  0x83, 0x06, 0x18, 0x38, 0x71, 0x81, 0xC3, 0x98, 0x0E, 0x19, 0xC0, 0x71,
  0xDC, 0x01, 0xFD, 0xC0, 0x07, 0xCC, 0x00, 0x00, 0xCF, 0x80, 0x0C, 0xFE,
  0x00, 0xCE, 0x30, 0x0C, 0xE1, 0x80, 0xE7, 0x0C, 0x0E, 0x30, 0x60, 0xE1,
  0x83, 0x06, 0x0C, 0x38, 0x60, 0x63, 0x86, 0x03, 0xF8, 0x60, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x03, 0x80,
  0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x78, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x18, 0x77, 0x06, 0x39, 0xC1, 0x9C, 0x30, 0xE6, 0x0E, 0x73, 0x81, 0xD8,
  0xE0, 0x7E, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0xC3, 0xFC, 0x7F, 0xEF, 0xC7,
  0xE0, 0xE0, 0x7B, 0x9C, 0xEE, 0x73, 0x9C, 0xC6, 0x00, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x06, 0x04, 0x63, 0xF6, 0xF7, 0xFE, 0x1F, 0x00, 0xE0, 0x1B,
  0x03, 0x30, 0x63, 0x84, 0x10, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x30,
  0x18, 0x00, 0x7F, 0xFF, 0xEF, 0xF8, 0x7B, 0xDE, 0xEF, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x31,
  0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0xF3, 0x98, 0x71,
  0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0C, 0x70, 0x0E, 0x3C, 0x0E, 0x0F, 0x0E, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xB8, 0x1C, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x78, 0x78, 0x38, 0x0F, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x78, 0x78, 0x38, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xF0, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03, 0x07, 0x03, 0x03, 0x83,
  0x03, 0x83, 0x01, 0xC3, 0x00, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1D, 0xF8, 0x07, 0xFF, 0x83, 0xE0, 0xF0,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x38, 0x03, 0x8F, 0x01, 0xE1, 0xE0, 0xF0, 0x3F, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xE3, 0xC1, 0xC0, 0xF1, 0xC0, 0x38,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x31, 0xF8, 0x3B, 0xFE, 0x1F, 0x87,
  0x8F, 0x01, 0xC7, 0x00, 0xF7, 0x80, 0x7B, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0F, 0x0F, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x70,
  0x78, 0x38, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E,
  0x0E, 0x0F, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x78, 0x38, 0x38, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x03, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0F, 0x3C, 0x37, 0x1F, 0xE6,
  0x0F, 0x8E, 0x00, 0x0C, 0x00, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xF0, 0xF0,
  0x7F, 0xE0, 0x3F, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x71, 0xE0, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x3C, 0x1E,
  0x38, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0xE0, 0x38, 0x06,
  0x07, 0x00, 0x70, 0x60, 0x03, 0x0C, 0x3D, 0xB1, 0xC7, 0xDB, 0x18, 0xC7,
  0xB3, 0x98, 0x73, 0x33, 0x87, 0x33, 0x30, 0x63, 0x67, 0x06, 0x36, 0x60,
  0x66, 0x66, 0x0C, 0x66, 0xE0, 0xC6, 0xCC, 0x18, 0xCC, 0xC1, 0x8C, 0xCC,
  0x39, 0x8C, 0xE7, 0x98, 0xCF, 0xDF, 0x0C, 0x79, 0xE0, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x04, 0x03, 0x81, 0xC0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00, 0x3B,
  0x80, 0x03, 0x38, 0x00, 0x71, 0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C,
  0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0xE0, 0x7C, 0x70, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xE0, 0x3C, 0x38, 0x07,
  0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7,
  0x00, 0xF3, 0xC0, 0x78, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0x43, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x18, 0xE0, 0x07, 0x3C,
  0x03, 0x87, 0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0xE0, 0xF0, 0x70, 0x1E, 0x1C, 0x03, 0x87, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70,
  0x0F, 0x1C, 0x03, 0x87, 0x01, 0xC3, 0xC1, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0x83, 0xC3, 0xC3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x18,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x7F, 0xBC, 0x3F, 0xDC, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x78,
  0x07, 0x1C, 0x07, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0x7E, 0x00, 0x0E, 0x00,
  0xE1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0xE0, 0x38,
  0xE0, 0x38, 0xF0, 0x70, 0x78, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0E, 0x00,
  0xF0, 0xE0, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x1E, 0x01, 0xC3,
  0xC0, 0x1C, 0x78, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x03, 0xBC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x03, 0x87, 0x00, 0x70, 0x78, 0x07,
  0x03, 0xC0, 0x70, 0x3C, 0x07, 0x01, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xF0,
  0xE0, 0x07, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0x80, 0x0F,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xD8, 0x1F, 0x0D, 0x83, 0x60,
  0xD8, 0x36, 0x1D, 0xC6, 0xE1, 0xDC, 0xEE, 0x1D, 0xCC, 0xE1, 0x8D, 0xCC,
  0x18, 0xD8, 0xC3, 0x8F, 0x9C, 0x38, 0xF1, 0xC3, 0x8F, 0x1C, 0x30, 0xE1,
  0x83, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xE1, 0xE0, 0x18, 0x3C,
  0x07, 0x0F, 0xC0, 0xE1, 0xF8, 0x1C, 0x3F, 0x03, 0x87, 0x60, 0x60, 0xCE,
  0x1C, 0x39, 0xC3, 0x87, 0x18, 0x70, 0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x0E,
  0x30, 0x60, 0xCE, 0x1C, 0x1D, 0xC3, 0x83, 0xB8, 0x70, 0x77, 0x0E, 0x06,
  0xC1, 0x80, 0xF8, 0x70, 0x1F, 0x0E, 0x03, 0xE1, 0xC0, 0x3C, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x1D,
  0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x0E, 0x3C, 0x0E, 0x0F, 0x0E, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE3, 0xC0, 0x79, 0xC0,
  0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x0E, 0x3C, 0x0E, 0x0F, 0x0F, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x38, 0x0F, 0x0E, 0x00, 0xE1,
  0xC0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x3C, 0x03, 0x87,
  0x01, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0x87, 0x00, 0x70, 0xF0, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x78, 0x70,
  0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0xF0, 0x7C, 0x38, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0xF3, 0xE0, 0x78, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0xC1, 0xE0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCF, 0x00,
  0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38,
  0x01, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0xB0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE,
  0x1E, 0x1C, 0xE1, 0xE1, 0x8E, 0x1E, 0x38, 0xE3, 0x63, 0x8E, 0x36, 0x30,
  0xE6, 0x67, 0x0E, 0x66, 0x70, 0xEE, 0x66, 0x0E, 0xC6, 0xE0, 0xDC, 0x6E,
  0x0D, 0x86, 0xC0, 0xF8, 0x6C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0E, 0x07,
  0x80, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x38,
  0x01, 0xC1, 0xC0, 0x07, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x07, 0x00,
  0x38, 0x1C, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x01, 0xC3, 0xC0,
  0x07, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x1C, 0x03, 0x83,
  0x80, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01,
  0xDC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xE0, 0x0D, 0xC0, 0x31, 0x80, 0xE3, 0x01, 0x86, 0x07, 0x0E, 0x0C,
  0x1C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x77, 0x00, 0xEC, 0x00, 0xF8, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xC3, 0x01, 0xF8, 0x07,
  0xFE, 0x0F, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07,
  0xFE, 0x1F, 0xFE, 0x3C, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0xE0, 0x1C, 0xE0,
  0x3C, 0xE0, 0x3C, 0xF0, 0xDC, 0x7F, 0x9F, 0x3E, 0x0F, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39, 0xF8,
  0x3B, 0xFE, 0x1D, 0x87, 0x0F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0,
  0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9E,
  0x01, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xE1, 0xE3, 0xBF, 0xE1, 0xC7, 0xC0,
  0x01, 0xF8, 0x07, 0xFE, 0x1E, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0x78, 0x78, 0x3F, 0xE0, 0x1F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x3E, 0x38, 0x3F, 0xDC, 0x1E, 0x1F, 0x0E, 0x03, 0xC3, 0x80,
  0xF1, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x3C,
  0x37, 0x07, 0xF9, 0x80, 0xFC, 0xE0, 0x01, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E,
  0x38, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0xF0, 0x1C,
  0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xF1, 0xC1, 0xFE, 0x60, 0xF0, 0xF8, 0x70, 0x1E, 0x1C, 0x07, 0x8E,
  0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE1, 0xE1, 0xB8,
  0x3F, 0xCE, 0x07, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0xE0, 0x38, 0x3C,
  0x0E, 0x07, 0x87, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39, 0xF8,
  0x39, 0xFE, 0x1D, 0x87, 0x0F, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x38,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x08,
  0x1E, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x38, 0x1E, 0x1C,
  0x1E, 0x0E, 0x1E, 0x07, 0x1E, 0x03, 0x1E, 0x03, 0x9E, 0x01, 0xDE, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x1C, 0x38, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC3, 0x80, 0xF1, 0xC0, 0x38, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1C, 0xE3, 0xC3, 0xFE, 0xFC, 0x69, 0xF3, 0x8E, 0x3C, 0x71, 0xC7, 0x0E,
  0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x86, 0x38, 0x61, 0xC6, 0x1C, 0x39,
  0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0x83, 0x18, 0x30, 0xE7,
  0x0E, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x70, 0x0C, 0x7E, 0x0E, 0x7F, 0x87,
  0x61, 0xC3, 0xC0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x0E, 0x00, 0x03, 0xF8,
  0x0F, 0xFC, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x78, 0x7F, 0xE0, 0x1F, 0x80, 0x06, 0x3F,
  0x03, 0x9F, 0xE0, 0xEC, 0x38, 0x3C, 0x07, 0x0F, 0x01, 0xC3, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF8, 0x78, 0x37, 0xFC,
  0x1C, 0x7C, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0x87, 0xFB, 0x87,
  0x87, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01,
  0xE3, 0x80, 0xF1, 0xE1, 0xB8, 0x7F, 0xB8, 0x1F, 0x9C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x7F, 0x18, 0xFE, 0x19, 0xFE, 0x1B, 0x80, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1E, 0x0E, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x0C, 0xC0, 0x1C, 0xE0, 0x1C, 0xF0, 0x78, 0x7F, 0xF0, 0x3F,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE3, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0xF0, 0xFF, 0x00, 0x18, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xE1,
  0xB8, 0x7F, 0x9C, 0x1F, 0x8C, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x78,
  0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCC, 0x00,
  0x6E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC3, 0x87, 0x38,
  0xF0, 0xE7, 0x1E, 0x18, 0xE7, 0xE7, 0x1C, 0xCC, 0xE3, 0x39, 0x98, 0x66,
  0x37, 0x0D, 0xC6, 0xE1, 0xB0, 0xD8, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x1C, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x03, 0x80,
  0x70, 0x70, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x3C,
  0x00, 0xE1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x0E,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x70, 0x07, 0x06, 0x00,
  0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x38, 0x00, 0x3B, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x07,
  0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7F, 0xE0, 0xF0, 0x7F, 0xC0, 0x0F, 0xC0,
};

const GFXglyph LiberationMono_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 22, 20, 7, -22 },
  { 21, 12, 10, 20, 6, -24 },
  { 36, 20, 22, 20, 0, -22 },
  { 91, 19, 28, 20, 1, -25 },
  { 158, 21, 22, 20, 0, -22 },
  { 216, 18, 22, 20, 0, -22 },
  { 266, 5, 10, 20, 10, -24 },
  { 273, 12, 31, 20, 5, -24 },
  { 320, 13, 31, 20, 2, -24 },
  { 371, 12, 12, 20, 6, -24 },
  { 389, 16, 16, 20, 2, -19 },
  { 421, 9, 11, 20, 1, -5 },
  { 434, 10, 3, 20, 5, -9 },
  { 438, 5, 5, 20, 6, -5 },
  { 442, 21, 24, 20, 0, -24 },
  { 505, 17, 22, 20, 2, -22 },
  { 552, 16, 22, 20, 1, -22 },
  { 596, 18, 22, 20, 1, -22 },
  { 646, 18, 22, 20, 1, -22 },
  { 696, 17, 22, 20, 1, -22 },
  { 743, 18, 22, 20, 1, -22 },
  { 793, 17, 22, 20, 2, -22 },
  { 840, 15, 22, 20, 5, -22 },
  { 882, 18, 22, 20, 1, -22 },
  { 932, 16, 22, 20, 2, -22 },
  { 976, 7, 18, 20, 6, -18 },
  { 992, 10, 24, 20, 3, -18 },
  { 1022, 16, 17, 20, 2, -19 },
  { 1056, 16, 10, 20, 2, -16 },
  { 1076, 16, 17, 20, 2, -19 },
  { 1110, 16, 22, 20, 3, -22 },
  { 1154, 20, 28, 20, 0, -24 },
  { 1224, 20, 22, 20, -2, -22 },
  { 1279, 18, 22, 20, 1, -22 },
  { 1329, 18, 22, 20, 2, -22 },
  { 1379, 18, 22, 20, 1, -22 },
  { 1429, 19, 22, 20, 1, -22 },
  { 1482, 19, 22, 20, 1, -22 },
  { 1535, 17, 22, 20, 2, -22 },
  { 1582, 19, 22, 20, 1, -22 },
  { 1635, 17, 22, 20, 2, -22 },
  { 1682, 16, 22, 20, 2, -22 },
  { 1726, 20, 22, 20, 1, -22 },
  { 1781, 15, 22, 20, 2, -22 },
  { 1823, 20, 22, 20, 0, -22 },
  { 1878, 19, 22, 20, 1, -22 },
  { 1931, 17, 22, 20, 2, -22 },
  { 1978, 18, 22, 20, 1, -22 },
  { 2028, 17, 29, 20, 2, -22 },
  { 2090, 19, 22, 20, 1, -22 },
  { 2143, 18, 22, 20, 1, -22 },
  { 2193, 18, 22, 20, 3, -22 },
  { 2243, 18, 22, 20, 2, -22 },
  { 2293, 19, 22, 20, 3, -22 },
  { 2346, 20, 22, 20, 2, -22 },
  { 2401, 22, 22, 20, -1, -22 },
  { 2462, 19, 22, 20, 3, -22 },
  { 2515, 21, 22, 20, -1, -22 },
  { 2573, 14, 31, 20, 4, -24 },
  { 2628, 11, 24, 20, 5, -24 },
  { 2661, 15, 31, 20, 1, -24 },
  { 2720, 15, 15, 20, 2, -22 },
  { 2749, 20, 2, 20, -2, 2 },
  { 2754, 6, 4, 20, 9, -23 },
  { 2757, 16, 18, 20, 1, -18 },
  { 2793, 17, 24, 20, 1, -24 },
  { 2844, 16, 18, 20, 2, -18 },
  { 2880, 18, 24, 20, 2, -24 },
  { 2934, 16, 18, 20, 2, -18 },
  { 2970, 18, 24, 20, 3, -24 },
  { 3024, 18, 25, 20, 1, -18 },
  { 3081, 17, 24, 20, 1, -24 },
  { 3132, 16, 24, 20, 1, -24 },
  { 3180, 17, 31, 20, -1, -24 },
  { 3246, 17, 24, 20, 2, -24 },
  { 3297, 17, 24, 20, 0, -24 },
  { 3348, 19, 18, 20, 0, -18 },
  { 3391, 17, 18, 20, 1, -18 },
  { 3430, 16, 18, 20, 2, -18 },
  { 3466, 18, 25, 20, 0, -18 },
  { 3523, 17, 25, 20, 2, -18 },
  { 3577, 16, 18, 20, 3, -18 },
  { 3613, 16, 18, 20, 2, -18 },
  { 3649, 13, 23, 20, 4, -23 },
  { 3687, 17, 18, 20, 2, -18 },
  { 3726, 17, 18, 20, 3, -18 },
  { 3765, 19, 18, 20, 2, -18 },
  { 3808, 20, 18, 20, 0, -18 },
  { 3853, 20, 25, 20, 0, -18 },
  { 3916, 17, 18, 20, 1, -18 },
  { 3955, 17, 31, 20, 3, -24 },
  { 4021, 2, 31, 20, 9, -24 },
  { 4029, 16, 31, 20, 0, -24 },
  { 4091, 17, 4, 20, 2, -13 },
};

const GFXfont LiberationMono_Italic33pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic33pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic33pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _LIBERATIONMONO_ITALIC33PT7B_H_
