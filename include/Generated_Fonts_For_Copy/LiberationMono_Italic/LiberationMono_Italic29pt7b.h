#ifndef _LIBERATIONMONO_ITALIC29PT7B_H_
#define _LIBERATIONMONO_ITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x60, 0x00,
  0x00, 0xE3, 0x8E, 0x00, 0x78, 0xEE, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xC3,
  0x98, 0x63, 0x0C, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x18, 0x30,
  0x06, 0x08, 0x01, 0x06, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x18, 0x30, 0x06,
  0x08, 0x01, 0x06, 0x00, 0xC1, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x08,
  0x01, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x40, 0x18, 0x30, 0x06, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0xE2, 0x78, 0x63,
  0x1C, 0x71, 0x86, 0x38, 0xC0, 0x1C, 0x60, 0x07, 0x30, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0D, 0xE0, 0x06, 0x38, 0x03, 0x1C, 0xC1, 0x0E, 0x61, 0x87,
  0x38, 0xC3, 0x1E, 0x67, 0x87, 0xFF, 0x80, 0xFE, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0xC3, 0xF0, 0x30, 0xE7, 0x0C, 0x18, 0x63, 0x07, 0x1C,
  0x60, 0xC3, 0x18, 0x18, 0x66, 0x03, 0x9D, 0x80, 0x3F, 0x60, 0x07, 0xDB,
  0xE0, 0x06, 0xFE, 0x01, 0xB8, 0xC0, 0x66, 0x18, 0x1C, 0xC3, 0x03, 0x18,
  0x60, 0xC3, 0x18, 0x30, 0x63, 0x0C, 0x0F, 0xC3, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0x8E, 0x07, 0x06, 0x06, 0x0C, 0x06, 0x1C, 0x06,
  0x78, 0x07, 0xE0, 0x0F, 0x06, 0x1F, 0x06, 0x33, 0x86, 0x61, 0x8C, 0xE1,
  0xCC, 0xE0, 0xF8, 0xC0, 0xF8, 0xE0, 0x70, 0xE0, 0xF8, 0x7F, 0xDF, 0x3F,
  0x0E, 0x7F, 0xEE, 0xEC, 0xCC, 0xC0, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x18, 0x32, 0x6F, 0xFE, 0x1C, 0x07, 0x81, 0xB8, 0x63, 0x0C, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0x60, 0xC0, 0xFF, 0xFF,
  0xFE, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x30, 0x0D, 0xC0,
  0x36, 0x00, 0xD8, 0x03, 0xE3, 0x8F, 0x9E, 0x7E, 0x71, 0xF0, 0x06, 0xC0,
  0x1B, 0x00, 0xEC, 0x03, 0x38, 0x1C, 0xF0, 0xE1, 0xFF, 0x03, 0xF0, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x3F, 0x07, 0xDC, 0x3C, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8,
  0x0F, 0xFC, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x01, 0xF8,
  0x0F, 0xFC, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x1E, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x30, 0x1C, 0x70, 0x78, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x73, 0x01, 0xC6, 0x03,
  0x1C, 0x0C, 0x38, 0x30, 0x70, 0xC0, 0xC3, 0x01, 0x8F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0xFF,
  0x0F, 0xFE, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x3B, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x38, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0x80,
  0x01, 0xF0, 0x1F, 0xF0, 0xE1, 0xC7, 0x03, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0xF8, 0x6F, 0xF3, 0xE0, 0xEF, 0x03, 0xB8, 0x06, 0xE0, 0x1B, 0x80,
  0xEE, 0x03, 0xB8, 0x1C, 0x70, 0xE1, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x38, 0x38, 0xE0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x8E, 0x0E, 0x0F, 0xF0, 0x1F, 0xE0,
  0xF0, 0xF3, 0x80, 0xE6, 0x00, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0x70,
  0x78, 0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xC3, 0xCE, 0x07,
  0x30, 0x0D, 0xC0, 0x37, 0x00, 0xD8, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x87,
  0xCF, 0xF6, 0x1F, 0x38, 0x00, 0xC0, 0x07, 0x30, 0x18, 0xE1, 0xC3, 0xFE,
  0x03, 0xE0, 0x00, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF3, 0x8E, 0x38, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0x60, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0x00, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0xF0, 0x71, 0xC0, 0x77,
  0x00, 0xEC, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C,
  0x06, 0x0E, 0x01, 0xC3, 0x1C, 0xB1, 0x99, 0xEC, 0x6C, 0x33, 0x33, 0x0C,
  0xCD, 0x83, 0x36, 0x61, 0x89, 0xB0, 0x66, 0x6C, 0x19, 0x93, 0x0C, 0x4C,
  0xC3, 0x13, 0x21, 0xCC, 0xC8, 0x62, 0x33, 0x29, 0x0C, 0xF3, 0x83, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x06, 0x07, 0x07, 0x80, 0xFF, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x0C, 0xC0,
  0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03, 0x83, 0x03, 0x81,
  0x81, 0xC0, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x1C, 0x60, 0x06, 0x70,
  0x03, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x1C, 0x0E,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x3F, 0xF0,
  0x3F, 0xF8, 0x70, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E,
  0xE0, 0x1C, 0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xF8,
  0x78, 0x71, 0xC0, 0x73, 0x80, 0xEE, 0x00, 0x9C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x03, 0x38, 0x06,
  0x70, 0x1C, 0x70, 0xF0, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0xFC,
  0x1C, 0x3E, 0x1C, 0x0E, 0x18, 0x06, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x06, 0x30, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0x60, 0x18, 0xE0, 0x38, 0xE0, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8,
  0x78, 0x71, 0xC0, 0x73, 0x80, 0xCE, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE1,
  0xFD, 0xC3, 0xFB, 0x80, 0x77, 0x00, 0xCC, 0x01, 0x9C, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0x70, 0x78, 0xFF, 0xC0, 0x7E, 0x00, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x81,
  0xCE, 0x0E, 0x38, 0x38, 0xF1, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x1C, 0x03,
  0x87, 0x01, 0xC1, 0xC0, 0xE0, 0x60, 0xF0, 0x18, 0x78, 0x0E, 0x3C, 0x03,
  0x9C, 0x00, 0xEE, 0x00, 0x37, 0x80, 0x0F, 0xF0, 0x07, 0xDC, 0x01, 0xE7,
  0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x06, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x3C,
  0x38, 0x07, 0x0E, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFC,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x7C, 0x1E, 0x1B, 0x0D, 0x86,
  0xC7, 0xE1, 0xB9, 0xB8, 0x6E, 0xEC, 0x39, 0xB3, 0x0C, 0x78, 0xC3, 0x1E,
  0x70, 0xC7, 0x1C, 0x31, 0xC6, 0x1C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x38,
  0x60, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0xC0, 0x1E, 0x03, 0x1E, 0x03, 0x1E,
  0x07, 0x1F, 0x07, 0x1F, 0x06, 0x3B, 0x06, 0x3B, 0x06, 0x33, 0x8E, 0x31,
  0x8E, 0x31, 0x8C, 0x71, 0xCC, 0x71, 0xCC, 0x70, 0xDC, 0x60, 0xDC, 0x60,
  0xFC, 0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0x78, 0xC0, 0x78, 0x01, 0xF8, 0x07,
  0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70,
  0x07, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0,
  0x1C, 0x70, 0x18, 0x70, 0x38, 0x78, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x1F,
  0xF8, 0x1F, 0xFE, 0x1C, 0x0F, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x0E, 0x30, 0x1C, 0x3F, 0xF8, 0x7F, 0xE0, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x18, 0x07, 0x38,
  0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x3F,
  0xE0, 0x1F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xF8, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0F, 0x18, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x70,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0x70, 0x60, 0x70, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0x01, 0xF8, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xE0,
  0x1C, 0xF0, 0x78, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x38,
  0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60,
  0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x38, 0xC0,
  0x38, 0xC0, 0x30, 0xC0, 0x70, 0xE0, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0xE0,
  0x03, 0xB0, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x60,
  0xC0, 0x70, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x1C,
  0x01, 0x8C, 0x00, 0xCE, 0x00, 0x66, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x70, 0xC3, 0x0E, 0x18, 0x63,
  0xC7, 0x0C, 0x78, 0xC1, 0x9B, 0x18, 0x33, 0x67, 0x06, 0xEE, 0xC0, 0xD8,
  0xD8, 0x1B, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x01, 0xC1,
  0xC0, 0x00, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x01, 0x80, 0x38, 0x30,
  0x03, 0x87, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1B, 0x80, 0x03, 0x18, 0x00, 0x71,
  0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0x30, 0x30,
  0x38, 0x70, 0x18, 0xE0, 0x1D, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07,
  0xF8, 0x3F, 0xC1, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0xF8, 0x3F, 0xC0, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0xD8, 0x0C,
  0xC0, 0x66, 0x06, 0x38, 0x30, 0xC3, 0x06, 0x30, 0x31, 0x81, 0x98, 0x07,
  0xC0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x86, 0x03, 0xF0,
  0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xFF, 0x8F, 0xFE,
  0x78, 0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0xF3, 0x86, 0xCF, 0xF3,
  0xDF, 0x0F, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x9F, 0x06, 0xFF, 0x0F, 0x0E, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x00, 0xE6, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x71,
  0xE1, 0xC7, 0x7F, 0x0E, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0xE3, 0xC3, 0x8C,
  0x07, 0x70, 0x1D, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x3B, 0xC3, 0xC7, 0xFE, 0x07, 0xE0, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0xF1, 0x87, 0xFF, 0x1C,
  0x3E, 0x70, 0x3C, 0xE0, 0x71, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x30, 0x0C, 0x60, 0x38, 0xC0, 0x71, 0x81, 0xE3, 0x87, 0xC7, 0xFB, 0x83,
  0xE6, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x8E, 0x06, 0x70, 0x1D, 0x80,
  0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x33, 0xC3, 0xC7, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x1F, 0xFF, 0xBF, 0xFE, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0xC6,
  0x1F, 0xEC, 0x78, 0xF8, 0xC0, 0xF3, 0x81, 0xE6, 0x01, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xC0, 0x39, 0x80, 0x63, 0x01, 0xC7, 0x07, 0x8E, 0x1F,
  0x1F, 0xEE, 0x0F, 0x9C, 0x00, 0x30, 0x00, 0xE3, 0x81, 0xC7, 0x87, 0x07,
  0xFC, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x9F, 0x06, 0xFF, 0x0F, 0x0E, 0x1C, 0x0E, 0x70, 0x1C, 0xE0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x18,
  0xC0, 0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03, 0xC1, 0xFF, 0x03, 0xF8, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x01, 0xC6,
  0x07, 0x1C, 0x18, 0x38, 0x60, 0x71, 0x80, 0xCE, 0x01, 0xB8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x61, 0xC0, 0xC1, 0xC3, 0x83, 0x87,
  0x03, 0x8E, 0x07, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x19, 0xCF, 0x0F, 0xEF,
  0xC7, 0x34, 0xE7, 0x1C, 0x73, 0x8E, 0x39, 0x86, 0x18, 0xC3, 0x0C, 0x61,
  0x86, 0x71, 0xC7, 0x38, 0xE3, 0x98, 0x61, 0x8C, 0x30, 0xC6, 0x18, 0x67,
  0x1C, 0x33, 0x8E, 0x39, 0xC7, 0x1C, 0x18, 0xF8, 0x37, 0xF8, 0x78, 0x71,
  0xE0, 0x73, 0x80, 0xE7, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x1C, 0xE0,
  0x39, 0xC0, 0x63, 0x80, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18,
  0x07, 0xE0, 0x7F, 0xE3, 0xC3, 0x8C, 0x07, 0x70, 0x1D, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0xB0, 0x0C, 0xE0, 0x73, 0xC3,
  0x87, 0xFC, 0x0F, 0xC0, 0x0C, 0x7C, 0x0D, 0xFE, 0x0F, 0x0E, 0x0E, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x06, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x3C, 0x38, 0x77, 0xF0, 0x73, 0xE0,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0x8C, 0x7F, 0xF3, 0x87, 0xDC, 0x0F, 0x70, 0x3D, 0x80, 0x6E, 0x03,
  0xB8, 0x0E, 0xE0, 0x3B, 0x00, 0xEC, 0x07, 0x30, 0x1C, 0xE0, 0xF3, 0x87,
  0xCF, 0xF7, 0x0F, 0x98, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0xF9, 0x9F, 0xCD, 0xC0, 0x68, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0x07, 0xE0, 0xFF, 0xCE, 0x0E, 0x60, 0x33,
  0x00, 0x18, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0x80, 0x0C, 0x00,
  0x6C, 0x03, 0x70, 0x73, 0xFF, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x0F, 0xFF, 0xFF, 0xCE, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xFE, 0x3F, 0x80, 0x38,
  0x0C, 0xC0, 0x73, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x66, 0x01, 0x98,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0xF3, 0x87, 0xCF,
  0xF7, 0x1F, 0x9C, 0x60, 0x07, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70,
  0x18, 0x30, 0x38, 0x30, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xC0, 0x19,
  0xC0, 0x19, 0x80, 0x1B, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0C, 0x61, 0xC3, 0x18, 0xF1,
  0xC6, 0x3C, 0x61, 0x9B, 0x18, 0x66, 0xCE, 0x1B, 0x33, 0x06, 0xCC, 0xC1,
  0xA1, 0x70, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0xC1, 0xC0, 0x1C,
  0x03, 0x87, 0x03, 0x83, 0x83, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x1D, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0x9C, 0x01, 0xCE,
  0x01, 0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0x18, 0x01, 0xC6,
  0x00, 0xE1, 0xC0, 0x30, 0x70, 0x1C, 0x1C, 0x06, 0x03, 0x03, 0x80, 0xC0,
  0xC0, 0x38, 0x70, 0x0E, 0x18, 0x01, 0x8C, 0x00, 0x67, 0x00, 0x19, 0x80,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x3C, 0x03, 0xFF, 0x0A, 0x0F, 0xF0, 0x07, 0xC0,
};

const GFXglyph LiberationMono_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 19, 17, 6, -19 },
  { 16, 11, 9, 17, 5, -21 },
  { 29, 18, 19, 17, 0, -19 },
  { 72, 17, 23, 17, 0, -21 },
  { 121, 19, 19, 17, 0, -19 },
  { 167, 16, 19, 17, 0, -19 },
  { 205, 4, 9, 17, 9, -21 },
  { 210, 11, 27, 17, 4, -21 },
  { 248, 11, 27, 17, 2, -21 },
  { 286, 11, 10, 17, 5, -21 },
  { 300, 14, 14, 17, 2, -17 },
  { 325, 8, 9, 17, 1, -4 },
  { 334, 8, 2, 17, 5, -8 },
  { 336, 4, 4, 17, 6, -4 },
  { 338, 18, 21, 17, 0, -21 },
  { 386, 14, 19, 17, 2, -19 },
  { 420, 14, 19, 17, 1, -19 },
  { 454, 15, 19, 17, 1, -19 },
  { 490, 15, 19, 17, 1, -19 },
  { 526, 15, 19, 17, 1, -19 },
  { 562, 16, 19, 17, 1, -19 },
  { 600, 14, 19, 17, 2, -19 },
  { 634, 13, 19, 17, 4, -19 },
  { 665, 15, 19, 17, 1, -19 },
  { 701, 14, 19, 17, 2, -19 },
  { 735, 6, 16, 17, 6, -16 },
  { 747, 10, 21, 17, 2, -16 },
  { 774, 14, 15, 17, 2, -17 },
  { 801, 14, 9, 17, 2, -14 },
  { 817, 14, 15, 17, 2, -17 },
  { 844, 15, 19, 17, 2, -19 },
  { 880, 18, 25, 17, 0, -21 },
  { 937, 17, 19, 17, -1, -19 },
  { 978, 16, 19, 17, 1, -19 },
  { 1016, 15, 19, 17, 2, -19 },
  { 1052, 16, 19, 17, 1, -19 },
  { 1090, 17, 19, 17, 1, -19 },
  { 1131, 17, 19, 17, 1, -19 },
  { 1172, 15, 19, 17, 2, -19 },
  { 1208, 16, 19, 17, 1, -19 },
  { 1246, 16, 19, 17, 1, -19 },
  { 1284, 14, 19, 17, 2, -19 },
  { 1318, 18, 19, 17, 1, -19 },
  { 1361, 13, 19, 17, 2, -19 },
  { 1392, 18, 19, 17, 0, -19 },
  { 1435, 16, 19, 17, 1, -19 },
  { 1473, 16, 19, 17, 1, -19 },
  { 1511, 16, 19, 17, 1, -19 },
  { 1549, 16, 25, 17, 1, -19 },
  { 1599, 16, 19, 17, 1, -19 },
  { 1637, 16, 19, 17, 1, -19 },
  { 1675, 16, 19, 17, 3, -19 },
  { 1713, 16, 19, 17, 2, -19 },
  { 1751, 17, 19, 17, 2, -19 },
  { 1792, 19, 19, 17, 1, -19 },
  { 1838, 20, 19, 17, -1, -19 },
  { 1886, 16, 19, 17, 3, -19 },
  { 1924, 18, 19, 17, 0, -19 },
  { 1967, 13, 27, 17, 3, -21 },
  { 2011, 10, 21, 17, 4, -21 },
  { 2038, 13, 27, 17, 1, -21 },
  { 2082, 13, 13, 17, 2, -19 },
  { 2104, 18, 1, 17, -2, 2 },
  { 2107, 6, 4, 17, 8, -21 },
  { 2110, 14, 16, 17, 1, -16 },
  { 2138, 15, 21, 17, 1, -21 },
  { 2178, 14, 16, 17, 2, -16 },
  { 2206, 15, 21, 17, 2, -21 },
  { 2246, 14, 16, 17, 2, -16 },
  { 2274, 15, 21, 17, 3, -21 },
  { 2314, 15, 22, 17, 1, -16 },
  { 2356, 15, 21, 17, 1, -21 },
  { 2396, 14, 21, 17, 1, -21 },
  { 2433, 15, 27, 17, -1, -21 },
  { 2484, 15, 21, 17, 2, -21 },
  { 2524, 15, 21, 17, 0, -21 },
  { 2564, 17, 16, 17, 0, -16 },
  { 2598, 15, 16, 17, 1, -16 },
  { 2628, 14, 16, 17, 2, -16 },
  { 2656, 16, 22, 17, 0, -16 },
  { 2700, 14, 22, 17, 2, -16 },
  { 2739, 13, 16, 17, 3, -16 },
  { 2765, 13, 16, 17, 2, -16 },
  { 2791, 11, 20, 17, 4, -20 },
  { 2819, 14, 16, 17, 2, -16 },
  { 2847, 16, 16, 17, 2, -16 },
  { 2879, 18, 16, 17, 1, -16 },
  { 2915, 17, 16, 17, 0, -16 },
  { 2949, 18, 22, 17, 0, -16 },
  { 2999, 15, 16, 17, 1, -16 },
  { 3029, 15, 27, 17, 3, -21 },
  { 3080, 2, 27, 17, 8, -21 },
  { 3087, 14, 27, 17, 0, -21 },
  { 3135, 15, 4, 17, 2, -12 },
};

const GFXfont LiberationMono_Italic29pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic29pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic29pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _LIBERATIONMONO_ITALIC29PT7B_H_
