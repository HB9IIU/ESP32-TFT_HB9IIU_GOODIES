#ifndef _LIBERATIONMONO_ITALIC69PT7B_H_
#define _LIBERATIONMONO_ITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE3, 0xC7, 0xFE, 0x00, 0xFF, 0x03, 0xC1, 0xFE, 0x00, 0xFC, 0x03,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x7F,
  0x01, 0xF0, 0x07, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xF0,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xCF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x07,
  0xF8, 0x00, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0x0C, 0x00, 0x78, 0x01, 0xF8, 0xFC, 0x00, 0x78, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xF0, 0x3F,
  0xC0, 0x3F, 0xF1, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0x7C,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC1, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x8F, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x87,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0x83, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xFC, 0x00, 0x1F,
  0x03, 0xFB, 0xF0, 0x01, 0xF0, 0x3F, 0x9F, 0x80, 0x0F, 0x83, 0xF0, 0x7E,
  0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x07, 0xC3, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x07, 0xE0, 0x01, 0xFC, 0xF8, 0x3F, 0x00,
  0x07, 0xEF, 0x81, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0xC0,
  0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x1F,
  0xF0, 0x3F, 0xDF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x1F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x40, 0x3C, 0x04,
  0x78, 0x3C, 0x0F, 0x3F, 0x1E, 0x3F, 0xBF, 0xEF, 0x7F, 0xDF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x70,
  0x07, 0x00, 0x10, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0xCF, 0xF3, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x81, 0xFE,
  0x03, 0xF3, 0xF0, 0x3F, 0xC0, 0xFE, 0xFE, 0x07, 0xF8, 0x1F, 0x9F, 0x80,
  0xFF, 0x03, 0xF3, 0xF0, 0x3F, 0xC0, 0x7E, 0x7E, 0x07, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFF, 0x03, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xE0, 0x01, 0xFF, 0xF3,
  0xF0, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x0F,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x07, 0xC1, 0xFF, 0xF0, 0x03,
  0xF1, 0xFF, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xFC,
  0x1F, 0xBF, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFB, 0xF0,
  0x1F, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0xFF, 0xE3,
  0xF0, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0x8F, 0x3C, 0x07, 0xC0, 0x7F, 0xF3, 0xCF, 0x01,
  0xE0, 0x3F, 0xFC, 0xF3, 0xC0, 0xF8, 0x1F, 0x8F, 0x78, 0xF0, 0x3C, 0x0F,
  0x81, 0xDE, 0x3C, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x07, 0x83, 0xE0, 0x0F,
  0xC3, 0xC1, 0xE0, 0xF8, 0x03, 0xF0, 0xF0, 0xF8, 0x7C, 0x00, 0xF8, 0x3C,
  0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC7, 0x83,
  0xC0, 0x07, 0xC1, 0xE1, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x78, 0x78, 0x00,
  0x78, 0x1E, 0x3E, 0x3E, 0x00, 0x3E, 0x07, 0x8F, 0x0F, 0x80, 0x0F, 0x03,
  0xC3, 0xC3, 0xC0, 0x03, 0xC0, 0xF0, 0xF0, 0xF0, 0x01, 0xF0, 0x3C, 0x7C,
  0x7C, 0x00, 0x78, 0x1E, 0x1E, 0x1F, 0x00, 0x3E, 0x07, 0x87, 0x87, 0x80,
  0x0F, 0x81, 0xE1, 0xE1, 0xE0, 0x07, 0xC0, 0xF0, 0x78, 0x78, 0x01, 0xF0,
  0x3C, 0x1E, 0x3E, 0x00, 0xF8, 0x1F, 0x0F, 0x8F, 0x80, 0x3E, 0x07, 0x83,
  0xE3, 0xE0, 0x1F, 0x83, 0xC0, 0xF8, 0xF8, 0x0F, 0xE0, 0xF0, 0x3E, 0x1E,
  0x07, 0x78, 0x78, 0x0F, 0x87, 0xC3, 0xDE, 0x3C, 0x03, 0xE1, 0xFF, 0xE7,
  0xFF, 0x00, 0xF8, 0x3F, 0xF1, 0xFF, 0x80, 0x1E, 0x0F, 0xF8, 0x3F, 0x80,
  0x07, 0x80, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0xFE, 0x00, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x08,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F,
  0xE0, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xC7, 0xE0, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0xCF, 0xE0, 0x07,
  0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7D, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x03, 0xF7,
  0xE0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x07,
  0xC7, 0xE0, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0xF8, 0x7C, 0x03, 0xF1, 0xF8,
  0xFC, 0x7E, 0x01, 0xF0, 0x7C, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x7E, 0x1F,
  0x80, 0x7C, 0x1F, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xBE, 0x07, 0xC0, 0x3F,
  0x07, 0xDF, 0x07, 0xE0, 0x1F, 0x01, 0xFF, 0x03, 0xF0, 0x0F, 0x80, 0xFF,
  0x81, 0xF8, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xF8,
  0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0x01, 0xF7, 0xE0, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x01, 0xF0, 0x07, 0xDF,
  0x80, 0x07, 0xE0, 0x1F, 0x9F, 0x00, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x01, 0xF0,
  0xF8, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xF0, 0x07,
  0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x01,
  0xF8, 0x00, 0x7E, 0xF8, 0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x0F, 0xC0, 0x00,
  0xFB, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x38,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3E,
  0x01, 0xF8, 0x0F, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x07,
  0xE0, 0x7D, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x3E, 0x0F, 0xC0, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x1F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xC1, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x3C, 0x3E,
  0x00, 0x3F, 0x1E, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x00,
  0xF8, 0xF8, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFF,
  0x0F, 0xE0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0xF7, 0xF0, 0x7F, 0x81, 0xF9,
  0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0x13, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF,
  0x03, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0xF8, 0x01,
  0xF9, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xFC, 0x01, 0xFB, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xE0,
  0x00, 0x7E, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xFE, 0x00, 0x7E,
  0x3F, 0xFF, 0xC0, 0x07, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xFF,
  0xCF, 0xC0, 0x0F, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0x80, 0xFB, 0xF0, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x3F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xDF, 0x80, 0x3F,
  0xE0, 0x7E, 0xFC, 0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xFE, 0x7E,
  0x00, 0x1F, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x0F, 0xE0,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x02, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x3F,
  0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0xF7, 0xE0,
  0x1F, 0xF0, 0x3F, 0x7E, 0x03, 0xFC, 0x00, 0xF7, 0xE0, 0x3F, 0x80, 0x07,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFC, 0x03, 0xFE, 0x07, 0xEF,
  0xC0, 0x3F, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF,
  0xF1, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x03, 0xFC, 0x00, 0x1F, 0x87, 0xFF, 0xE0, 0x0F, 0xC3, 0xFF, 0xFC, 0x03,
  0xF1, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xFC,
  0x0F, 0xBC, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x07, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x01, 0xF1, 0xFF, 0x07, 0xFC, 0x01, 0xF3, 0xFF, 0x0F,
  0xFE, 0x03, 0xF7, 0xFF, 0x9F, 0xFE, 0x03, 0xEF, 0xFF, 0xBF, 0xFF, 0x03,
  0xEE, 0x1F, 0xB8, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0x0F, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xFF,
  0x80, 0xFD, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x03, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xE1, 0xFF,
  0xFE, 0x00, 0x1F, 0x8F, 0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0xFF, 0xF0, 0x01,
  0xFB, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFE, 0x00,
  0x7E, 0x7F, 0xFF, 0xF0, 0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x07, 0xE3, 0xFF,
  0xFC, 0x00, 0x1F, 0x87, 0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFC, 0x01,
  0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFE, 0xFC,
  0x07, 0xFC, 0x07, 0xDF, 0x81, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x07,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xEF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0x0F,
  0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7E,
  0x1F, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0, 0x1F, 0x9F, 0xFF, 0xF8, 0x0F,
  0xCF, 0xE0, 0x04, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xFE,
  0x07, 0xEF, 0xC0, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xF8, 0xF8, 0x07,
  0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xBC, 0x07, 0xC0, 0x7E, 0x07,
  0x9E, 0x07, 0xE0, 0x3F, 0x07, 0xCF, 0x03, 0xF0, 0x1F, 0x03, 0xC7, 0xC1,
  0xF0, 0x0F, 0x83, 0xE3, 0xE1, 0xF8, 0x07, 0xC1, 0xE1, 0xF0, 0xFC, 0x03,
  0xE1, 0xF0, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x7C, 0x7E, 0x00, 0xF8, 0xF8,
  0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0x3F, 0x00, 0x3E, 0x7C, 0x07, 0x9F,
  0x80, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x07,
  0xDE, 0x00, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x01, 0xBF, 0xFF, 0xFF,
  0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xB8, 0x00,
  0x3F, 0xFF, 0xF4, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph LiberationMono_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 45, 41, 14, -45 },
  { 86, 25, 22, 41, 13, -50 },
  { 155, 41, 45, 41, 1, -45 },
  { 386, 40, 54, 41, 1, -49 },
  { 656, 45, 47, 41, -1, -46 },
  { 921, 37, 47, 41, 0, -46 },
  { 1139, 11, 22, 41, 20, -50 },
  { 1170, 26, 64, 41, 10, -50 },
  { 1378, 26, 64, 41, 5, -50 },
  { 1586, 25, 24, 41, 12, -50 },
  { 1661, 33, 33, 41, 4, -39 },
  { 1798, 19, 22, 41, 3, -10 },
  { 1851, 20, 5, 41, 11, -21 },
  { 1864, 10, 10, 41, 13, -10 },
  { 1877, 44, 51, 41, 0, -50 },
  { 2158, 35, 47, 41, 4, -46 },
  { 2364, 33, 45, 41, 2, -45 },
  { 2550, 38, 46, 41, 1, -46 },
  { 2769, 36, 47, 41, 3, -46 },
  { 2981, 35, 45, 41, 2, -45 },
  { 3178, 37, 46, 41, 3, -45 },
  { 3391, 34, 47, 41, 5, -46 },
  { 3591, 31, 45, 41, 10, -45 },
  { 3766, 36, 47, 41, 3, -46 },
  { 3978, 35, 47, 41, 4, -46 },
  { 4184, 15, 36, 41, 13, -36 },
  { 4252, 22, 48, 41, 6, -36 },
  { 4384, 33, 35, 41, 4, -40 },
  { 4529, 33, 22, 41, 4, -34 },
  { 4620, 33, 35, 41, 4, -40 },
  { 4765, 33, 46, 41, 6, -46 },
  { 4955, 42, 60, 41, 0, -50 },
  { 5270, 42, 45, 41, -4, -45 },
  { 5507, 37, 45, 41, 2, -45 },
  { 5716, 37, 47, 41, 4, -46 },
  { 5934, 38, 45, 41, 2, -45 },
  { 6148, 40, 45, 41, 2, -45 },
  { 6373, 39, 45, 41, 3, -45 },
  { 6593, 36, 47, 41, 4, -46 },
  { 6805, 39, 45, 41, 2, -45 },
  { 7025, 37, 45, 41, 3, -45 },
  { 7234, 34, 46, 41, 5, -45 },
  { 7430, 42, 45, 41, 2, -45 },
  { 7667, 31, 45, 41, 4, -45 },
  { 7842, 41, 45, 41, 1, -45 },
  { 8073, 39, 45, 41, 2, -45 },
  { 8293, 37, 47, 41, 3, -46 },
  { 8511, 39, 45, 41, 2, -45 },
  { 8731, 37, 60, 41, 3, -46 },
  { 9009, 39, 45, 41, 2, -45 },
  { 9229, 39, 47, 41, 1, -46 },
  { 9459, 37, 45, 41, 7, -45 },
  { 9668, 38, 46, 41, 4, -45 },
  { 9887, 40, 45, 41, 6, -45 },
  { 10112, 43, 45, 41, 4, -45 },
  { 10354, 46, 45, 41, -2, -45 },
  { 10613, 39, 45, 41, 6, -45 },
  { 10833, 44, 45, 41, -1, -45 },
  { 11081, 31, 64, 41, 7, -50 },
  { 11329, 24, 51, 41, 10, -50 },
  { 11482, 31, 64, 41, 3, -50 },
  { 11730, 32, 31, 41, 4, -45 },
  { 11854, 42, 3, 41, -5, 4 },
  { 11870, 13, 9, 41, 19, -49 },
  { 11885, 34, 38, 41, 2, -37 },
  { 12047, 36, 51, 41, 2, -50 },
  { 12277, 34, 38, 41, 4, -37 },
  { 12439, 37, 51, 41, 4, -50 },
  { 12675, 33, 38, 41, 4, -37 },
  { 12832, 36, 50, 41, 7, -50 },
  { 13057, 36, 51, 41, 3, -37 },
  { 13287, 34, 50, 41, 3, -50 },
  { 13500, 34, 50, 41, 1, -50 },
  { 13713, 36, 64, 41, -2, -50 },
  { 14001, 37, 50, 41, 4, -50 },
  { 14233, 34, 50, 41, 1, -50 },
  { 14446, 40, 37, 41, 0, -37 },
  { 14631, 34, 37, 41, 3, -37 },
  { 14789, 34, 38, 41, 4, -37 },
  { 14951, 38, 51, 41, 0, -37 },
  { 15194, 35, 51, 41, 4, -37 },
  { 15418, 33, 37, 41, 6, -37 },
  { 15571, 33, 38, 41, 4, -37 },
  { 15728, 27, 47, 41, 9, -46 },
  { 15887, 34, 37, 41, 5, -36 },
  { 16045, 37, 36, 41, 6, -36 },
  { 16212, 41, 36, 41, 3, -36 },
  { 16397, 41, 36, 41, 0, -36 },
  { 16582, 44, 50, 41, -1, -36 },
  { 16857, 37, 36, 41, 1, -36 },
  { 17024, 35, 64, 41, 7, -50 },
  { 17304, 5, 64, 41, 18, -50 },
  { 17344, 35, 64, 41, -1, -50 },
  { 17624, 35, 9, 41, 4, -28 },
};

const GFXfont LiberationMono_Italic69pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic69pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic69pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _LIBERATIONMONO_ITALIC69PT7B_H_
