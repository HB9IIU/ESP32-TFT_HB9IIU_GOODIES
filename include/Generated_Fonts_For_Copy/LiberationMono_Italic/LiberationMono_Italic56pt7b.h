#ifndef _LIBERATIONMONO_ITALIC56PT7B_H_
#define _LIBERATIONMONO_ITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x7C,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x38, 0xFE, 0x03, 0xF0, 0x38, 0x3F,
  0x03, 0xE0, 0x78, 0x3F, 0x07, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0x70, 0x1F,
  0x07, 0xC0, 0x70, 0x1C, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x03, 0xFC, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC7, 0xF8,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x03, 0x80, 0x7C, 0x00, 0x03, 0x80, 0x7C, 0x38, 0x07, 0x80, 0x7C,
  0xF8, 0x07, 0x80, 0x78, 0xF8, 0x07, 0x80, 0xF8, 0xF8, 0x07, 0x00, 0xF8,
  0xFC, 0x07, 0x01, 0xF0, 0x7E, 0x0F, 0x07, 0xF0, 0x7F, 0x8F, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0x3C, 0x07, 0xC3,
  0xC0, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x3E, 0x00, 0x3C,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0x1F, 0x1E, 0x00, 0x01, 0xE1, 0xF1, 0xE0, 0x00, 0x0F, 0xFF,
  0x1E, 0x00, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x00, 0xF1,
  0xFF, 0x80, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x00, 0xF1, 0xF0, 0xF0, 0x00,
  0x0F, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0x78,
  0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x7C, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x78, 0x00, 0x7C, 0x7C, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x3C,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0xFC, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0xC0, 0x1F, 0xF0, 0x03, 0xC1, 0xFF, 0xC0, 0x1F,
  0x0F, 0xCF, 0x00, 0x78, 0x7E, 0x3E, 0x01, 0xE1, 0xF0, 0xF8, 0x0F, 0x0F,
  0x81, 0xF0, 0x3C, 0x7C, 0x07, 0xC1, 0xF1, 0xF0, 0x0F, 0x87, 0x87, 0x80,
  0x3E, 0x3C, 0x3E, 0x00, 0x7C, 0xF0, 0xF8, 0x01, 0xFF, 0x83, 0xE0, 0x03,
  0xFE, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7F,
  0x03, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFC, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0x80,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x02, 0x07, 0x03, 0x78, 0x70, 0xF7, 0xF7, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7B, 0x80, 0x0F,
  0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x1E, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x01,
  0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0x7E, 0x7E,
  0x7E, 0xFE, 0xFE, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x0F, 0xC1, 0xF1, 0xF0,
  0x7E, 0x0F, 0x9F, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xC1, 0xFC,
  0x1F, 0x3E, 0x0F, 0xC1, 0xF1, 0xF0, 0x7E, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xBE, 0x00, 0x3F, 0xE3, 0xE0, 0x03,
  0xF8, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0,
  0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x1F, 0xE0, 0x00, 0xF9, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xC0,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x03, 0xE3, 0xFF, 0xC0,
  0x3C, 0xFF, 0xFE, 0x07, 0xDF, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0x87, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xE0, 0xFE, 0x07,
  0xFE, 0x0F, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0x3C, 0x03, 0xFF, 0xC7, 0xC0,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0xF8, 0x07, 0x03, 0xC0, 0xFF,
  0x3D, 0xC1, 0xE0, 0x7F, 0xCE, 0x70, 0x78, 0x3C, 0x3F, 0x9C, 0x1C, 0x1E,
  0x0F, 0xC7, 0x0F, 0x0F, 0x01, 0xF1, 0xC3, 0x87, 0x80, 0x7C, 0x71, 0xE1,
  0xC0, 0x1E, 0x1C, 0x78, 0xF0, 0x07, 0x8F, 0x1C, 0x38, 0x03, 0xC3, 0xCF,
  0x1E, 0x00, 0xF0, 0xE3, 0xC7, 0x80, 0x38, 0x38, 0xE3, 0xC0, 0x1E, 0x0E,
  0x38, 0xF0, 0x07, 0x87, 0x9E, 0x38, 0x01, 0xC1, 0xC7, 0x8E, 0x00, 0xF0,
  0x71, 0xC7, 0x80, 0x38, 0x3C, 0x71, 0xE0, 0x1E, 0x0E, 0x1C, 0x78, 0x07,
  0x83, 0x87, 0x1E, 0x03, 0xC1, 0xC3, 0xC7, 0x80, 0xF0, 0x70, 0xF1, 0xE0,
  0x7C, 0x38, 0x3C, 0x78, 0x37, 0x1E, 0x0F, 0x1E, 0x3D, 0xCF, 0x03, 0xC3,
  0xFE, 0x7F, 0x80, 0xF0, 0xFF, 0x1F, 0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0x80, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xE1, 0xF8, 0x00,
  0x06, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x40, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0xFC,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x04, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0xFF, 0x1F, 0x00, 0x7F, 0xFC, 0x7C, 0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF,
  0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x1C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x01, 0xF0, 0x1F, 0xC0, 0x00,
  0x7C, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x3E, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xBC, 0x0F, 0xFC, 0x03, 0xDE, 0x07, 0xDE, 0x03, 0xDF, 0x03,
  0xCF, 0x01, 0xEF, 0x81, 0xE7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0xF3, 0xC0,
  0xF9, 0xF0, 0xF3, 0xE0, 0x7C, 0xF8, 0x79, 0xF0, 0x3C, 0x3C, 0x78, 0xF8,
  0x1E, 0x1E, 0x7C, 0x78, 0x0F, 0x0F, 0x3C, 0x3C, 0x0F, 0x87, 0xBC, 0x1E,
  0x07, 0xC3, 0xDE, 0x1F, 0x03, 0xC1, 0xEE, 0x0F, 0x81, 0xE0, 0x7F, 0x07,
  0x80, 0xF0, 0x3F, 0x03, 0xC0, 0xF8, 0x1F, 0x81, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0x07,
  0xF0, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xE0, 0x01, 0xF0, 0x3F,
  0xC0, 0x03, 0xE0, 0x7F, 0x80, 0x07, 0x81, 0xFF, 0x80, 0x1F, 0x03, 0xFF,
  0x00, 0x3E, 0x07, 0xFE, 0x00, 0x7C, 0x0F, 0x3C, 0x00, 0xF8, 0x1E, 0x7C,
  0x01, 0xE0, 0x7C, 0xF8, 0x07, 0xC0, 0xF9, 0xF0, 0x0F, 0x81, 0xF1, 0xE0,
  0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x07, 0x87, 0xC0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F,
  0x81, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x7C, 0x3C, 0x0F, 0x80, 0xF8, 0xF8,
  0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xE3, 0xE0, 0x78, 0x03, 0xE7, 0xC0,
  0xF0, 0x07, 0xCF, 0x03, 0xE0, 0x0F, 0x9E, 0x07, 0xC0, 0x0F, 0x7C, 0x0F,
  0x80, 0x1F, 0xF8, 0x1E, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x3F, 0xC0, 0xF8,
  0x00, 0x7F, 0x81, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xFE, 0x07, 0xC0,
  0x01, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x3F,
  0xC0, 0x7C, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x3E,
  0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3E,
  0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x38, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x18,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x03, 0xF8, 0x1F, 0x03, 0xE0, 0xFF, 0x03,
  0xC0, 0x78, 0x1F, 0xE0, 0xF8, 0x0F, 0x03, 0xBC, 0x1F, 0x01, 0xE0, 0xF7,
  0x83, 0xC0, 0x3C, 0x1C, 0xF0, 0xF8, 0x07, 0x87, 0x9E, 0x1F, 0x01, 0xF0,
  0xF3, 0xC3, 0xC0, 0x3E, 0x3C, 0x78, 0x78, 0x07, 0xC7, 0x8F, 0x1F, 0x00,
  0xF9, 0xE1, 0xE3, 0xC0, 0x1F, 0x3C, 0x3C, 0x78, 0x03, 0xE7, 0x03, 0x9F,
  0x00, 0x7D, 0xE0, 0x73, 0xC0, 0x0F, 0xB8, 0x0E, 0x78, 0x01, 0xEF, 0x01,
  0xFF, 0x00, 0x3D, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFC, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0xE3, 0xF0, 0x07, 0x7C, 0x7F,
  0x07, 0xCF, 0x87, 0xFF, 0xF1, 0xFE, 0xFF, 0xFC, 0x3F, 0xCF, 0xFF, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x3F, 0xF8, 0x03, 0xC7,
  0xFF, 0xC0, 0x7C, 0xFF, 0xFE, 0x07, 0xDE, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x80,
  0x3F, 0x07, 0xFE, 0x0F, 0xE0, 0x79, 0xFF, 0xFC, 0x0F, 0x9F, 0xFF, 0x80,
  0xF8, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xFF,
  0x9F, 0x00, 0x7F, 0xFF, 0xBE, 0x01, 0xFC, 0x0F, 0x7C, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x7B, 0xC0, 0x1F, 0xFF, 0xEF, 0x80, 0x1F, 0xFF, 0x9F, 0x00, 0x1F, 0xFE,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x60, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0x80, 0x7F,
  0xFF, 0xBE, 0x03, 0xFC, 0x1E, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0x7E, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x03, 0xFE,
  0x03, 0xF8, 0x1E, 0xF8, 0x0F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x9F, 0x00,
  0x3F, 0xF8, 0x7C, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x3E, 0x3F, 0xFC, 0x03,
  0xE7, 0xFF, 0xE0, 0x7C, 0xFF, 0xFE, 0x07, 0xDE, 0x07, 0xF0, 0x7F, 0x80,
  0x3F, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x7C, 0x07, 0xCF, 0xE1, 0xFE, 0x07, 0x9F, 0xF3, 0xFF,
  0x07, 0xBF, 0xF7, 0xFF, 0x07, 0xF1, 0xF7, 0x1F, 0x07, 0xE0, 0xFE, 0x1F,
  0x07, 0xC0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x1F,
  0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x1F,
  0x1F, 0x01, 0xF0, 0x1E, 0x1F, 0x01, 0xF0, 0x1E, 0x1F, 0x01, 0xE0, 0x3E,
  0x1F, 0x01, 0xE0, 0x3E, 0x1E, 0x03, 0xE0, 0x3E, 0x1E, 0x03, 0xE0, 0x3C,
  0x3E, 0x03, 0xE0, 0x3C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C,
  0x3C, 0x07, 0xC0, 0x7C, 0x3C, 0x07, 0xC0, 0x78, 0x7C, 0x07, 0xC0, 0x78,
  0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x78, 0x0F, 0x80, 0xF8,
  0x78, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x80, 0xF0,
  0xF8, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3C, 0x3F, 0xFC, 0x03,
  0xC7, 0xFF, 0xE0, 0x7C, 0xFF, 0xFE, 0x07, 0xDE, 0x07, 0xF0, 0x7F, 0x80,
  0x3F, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xF1, 0xFF, 0xC0, 0x03, 0xC7, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF,
  0xC0, 0x1F, 0x78, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x80,
  0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0xFF, 0xC1, 0xFC, 0x01, 0xF7, 0xFF,
  0xF0, 0x03, 0xEF, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0x87, 0x80, 0x7F, 0xFE, 0x7C, 0x07, 0xFF, 0xFB, 0xE0, 0x7F,
  0x03, 0xDF, 0x03, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x77, 0xC0, 0xFE, 0x0F,
  0xFC, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x9F, 0x00, 0x7F, 0xF0, 0xF8,
  0x00, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC3,
  0xE0, 0x7F, 0xF0, 0x78, 0x7F, 0xFC, 0x1E, 0x3F, 0xFF, 0x07, 0x8F, 0xFF,
  0xC3, 0xE7, 0xE0, 0x10, 0xFB, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x38, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x0E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFE, 0x07, 0xBE, 0x0F,
  0xFF, 0xF3, 0xC0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF, 0xC7, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x7E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xE0, 0x3C,
  0x3E, 0x07, 0xF0, 0x3E, 0x1F, 0x03, 0xB8, 0x1F, 0x0F, 0x83, 0xDC, 0x0F,
  0x07, 0xC1, 0xCE, 0x0F, 0x83, 0xE1, 0xE7, 0x07, 0xC1, 0xF0, 0xE3, 0xC3,
  0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0x78, 0xF1, 0xF0, 0x3E, 0x78, 0x78,
  0xF0, 0x1E, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x1E, 0x78, 0x07, 0x9E, 0x07,
  0x3C, 0x03, 0xDE, 0x03, 0xBE, 0x01, 0xEF, 0x01, 0xDE, 0x00, 0xFF, 0x00,
  0xEF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xDF, 0xFF, 0xF8, 0x1E, 0xFF, 0xFF, 0xFF,
  0xEF, 0x01, 0xFF, 0xFF, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 13, 37, 34, 11, -37 },
  { 62, 21, 17, 34, 10, -41 },
  { 107, 33, 37, 34, 1, -37 },
  { 260, 32, 45, 34, 1, -41 },
  { 440, 37, 39, 34, -1, -38 },
  { 621, 30, 39, 34, 0, -38 },
  { 768, 9, 17, 34, 16, -41 },
  { 788, 21, 53, 34, 8, -41 },
  { 928, 21, 53, 34, 4, -41 },
  { 1068, 20, 20, 34, 10, -41 },
  { 1118, 27, 28, 34, 3, -33 },
  { 1213, 16, 18, 34, 2, -8 },
  { 1249, 16, 4, 34, 9, -16 },
  { 1257, 8, 8, 34, 11, -8 },
  { 1265, 35, 42, 34, 0, -41 },
  { 1449, 29, 39, 34, 3, -38 },
  { 1591, 28, 37, 34, 1, -37 },
  { 1721, 31, 38, 34, 1, -38 },
  { 1869, 29, 39, 34, 3, -38 },
  { 2011, 28, 37, 34, 2, -37 },
  { 2141, 30, 38, 34, 2, -37 },
  { 2284, 28, 39, 34, 4, -38 },
  { 2421, 26, 37, 34, 8, -37 },
  { 2542, 29, 39, 34, 3, -38 },
  { 2684, 28, 39, 34, 3, -38 },
  { 2821, 12, 30, 34, 11, -30 },
  { 2866, 18, 40, 34, 5, -30 },
  { 2956, 27, 29, 34, 3, -33 },
  { 3054, 27, 18, 34, 3, -27 },
  { 3115, 27, 29, 34, 3, -33 },
  { 3213, 27, 38, 34, 5, -38 },
  { 3342, 34, 49, 34, 0, -41 },
  { 3551, 34, 37, 34, -3, -37 },
  { 3709, 30, 37, 34, 2, -37 },
  { 3848, 30, 39, 34, 3, -38 },
  { 3995, 30, 37, 34, 2, -37 },
  { 4134, 32, 37, 34, 2, -37 },
  { 4282, 32, 37, 34, 2, -37 },
  { 4430, 30, 39, 34, 3, -38 },
  { 4577, 31, 37, 34, 2, -37 },
  { 4721, 29, 37, 34, 3, -37 },
  { 4856, 27, 38, 34, 4, -37 },
  { 4985, 34, 37, 34, 2, -37 },
  { 5143, 24, 37, 34, 4, -37 },
  { 5254, 33, 37, 34, 1, -37 },
  { 5407, 31, 37, 34, 2, -37 },
  { 5551, 29, 39, 34, 3, -38 },
  { 5693, 31, 37, 34, 2, -37 },
  { 5837, 29, 50, 34, 3, -38 },
  { 6019, 31, 37, 34, 2, -37 },
  { 6163, 32, 39, 34, 1, -38 },
  { 6319, 30, 37, 34, 6, -37 },
  { 6458, 31, 38, 34, 3, -37 },
  { 6606, 33, 37, 34, 5, -37 },
  { 6759, 35, 37, 34, 3, -37 },
  { 6921, 38, 37, 34, -2, -37 },
  { 7097, 32, 37, 34, 5, -37 },
  { 7245, 36, 37, 34, -1, -37 },
  { 7412, 25, 53, 34, 6, -41 },
  { 7578, 19, 42, 34, 8, -41 },
  { 7678, 25, 53, 34, 2, -41 },
  { 7844, 26, 25, 34, 3, -37 },
  { 7926, 34, 3, 34, -4, 3 },
  { 7939, 10, 7, 34, 16, -40 },
  { 7948, 27, 32, 34, 2, -31 },
  { 8056, 28, 42, 34, 2, -41 },
  { 8203, 28, 32, 34, 3, -31 },
  { 8315, 31, 42, 34, 3, -41 },
  { 8478, 27, 32, 34, 3, -31 },
  { 8586, 29, 41, 34, 6, -41 },
  { 8735, 30, 43, 34, 2, -31 },
  { 8897, 28, 41, 34, 2, -41 },
  { 9041, 28, 41, 34, 1, -41 },
  { 9185, 30, 53, 34, -2, -41 },
  { 9384, 29, 41, 34, 4, -41 },
  { 9533, 27, 41, 34, 1, -41 },
  { 9672, 32, 31, 34, 0, -31 },
  { 9796, 28, 31, 34, 2, -31 },
  { 9905, 28, 32, 34, 3, -31 },
  { 10017, 31, 43, 34, 0, -31 },
  { 10184, 29, 43, 34, 3, -31 },
  { 10340, 26, 31, 34, 5, -31 },
  { 10441, 27, 32, 34, 3, -31 },
  { 10549, 22, 39, 34, 7, -38 },
  { 10657, 28, 31, 34, 4, -30 },
  { 10766, 30, 30, 34, 5, -30 },
  { 10879, 33, 30, 34, 3, -30 },
  { 11003, 33, 30, 34, 0, -30 },
  { 11127, 35, 42, 34, 0, -30 },
  { 11311, 30, 30, 34, 1, -30 },
  { 11424, 28, 53, 34, 6, -41 },
  { 11610, 4, 53, 34, 15, -41 },
  { 11637, 29, 53, 34, -1, -41 },
  { 11830, 29, 7, 34, 3, -22 },
};

const GFXfont LiberationMono_Italic56pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic56pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic56pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _LIBERATIONMONO_ITALIC56PT7B_H_
