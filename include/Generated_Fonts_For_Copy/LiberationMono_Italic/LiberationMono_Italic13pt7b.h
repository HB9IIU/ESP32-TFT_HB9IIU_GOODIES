#ifndef _LIBERATIONMONO_ITALIC13PT7B_H_
#define _LIBERATIONMONO_ITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x25, 0x20, 0x80, 0x4A, 0x57, 0x20, 0x12, 0x12, 0x7F, 0x24,
  0x24, 0xFE, 0x48, 0x48, 0x90, 0x04, 0x1E, 0x2B, 0x48, 0x68, 0x3C, 0x12,
  0x12, 0xD6, 0x7C, 0x10, 0x71, 0x52, 0x94, 0x68, 0x08, 0x16, 0x29, 0x4A,
  0x8E, 0x1C, 0x64, 0x91, 0xC7, 0x32, 0xA3, 0x46, 0x76, 0xEA, 0x11, 0x88,
  0x84, 0x62, 0x10, 0x84, 0x20, 0x84, 0x00, 0x10, 0x86, 0x10, 0x84, 0x62,
  0x11, 0x88, 0x8C, 0x00, 0x23, 0x5C, 0x45, 0x00, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x00, 0x6A, 0x40, 0xF0, 0x50, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0xC0, 0x3D, 0x14, 0x61, 0xB6, 0x18, 0xE2, 0x70, 0x0C,
  0x78, 0x20, 0x40, 0x81, 0x02, 0x0C, 0xFE, 0x1E, 0x44, 0x08, 0x10, 0x43,
  0x08, 0x20, 0xFC, 0x3D, 0x10, 0x43, 0x30, 0x30, 0x62, 0xF0, 0x06, 0x14,
  0x30, 0xA2, 0x48, 0xBF, 0x86, 0x08, 0x7D, 0x04, 0x1E, 0xCC, 0x10, 0xE2,
  0xF0, 0x3D, 0x94, 0x2E, 0xCE, 0x18, 0x62, 0x70, 0xFC, 0x21, 0x04, 0x21,
  0x04, 0x30, 0x80, 0x3D, 0x14, 0x51, 0x3B, 0x38, 0x62, 0xF0, 0x3D, 0x1C,
  0x61, 0xCD, 0xD0, 0xA6, 0xF0, 0x24, 0x00, 0x90, 0x11, 0x00, 0x02, 0x64,
  0x80, 0x04, 0x6E, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81,
  0x81, 0x19, 0x88, 0x00, 0x3D, 0x18, 0x41, 0x08, 0xC2, 0x00, 0x60, 0x0E,
  0x31, 0x21, 0x5F, 0x55, 0xA5, 0xA6, 0xAA, 0xBC, 0x80, 0xC4, 0x78, 0x06,
  0x0A, 0x0A, 0x12, 0x12, 0x3F, 0x21, 0x41, 0x41, 0x3E, 0x44, 0x8B, 0x17,
  0xC8, 0x50, 0xA3, 0xFC, 0x3C, 0xCF, 0x04, 0x08, 0x10, 0x20, 0x46, 0x78,
  0x3C, 0x44, 0x8B, 0x14, 0x28, 0x51, 0xA2, 0xF8, 0x3F, 0x20, 0x20, 0x60,
  0x7E, 0x40, 0x40, 0x40, 0xFE, 0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40,
  0x80, 0x3C, 0xCF, 0x04, 0x09, 0xD0, 0xA1, 0x46, 0x78, 0x23, 0x22, 0x22,
  0x62, 0x7E, 0x42, 0x46, 0x44, 0xC4, 0x7C, 0x20, 0x40, 0x83, 0x04, 0x08,
  0x10, 0xF8, 0x1C, 0x10, 0x43, 0x08, 0x20, 0xA6, 0xF0, 0x23, 0x26, 0x2C,
  0x78, 0x78, 0x68, 0x4C, 0x44, 0xC6, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20,
  0xF8, 0x23, 0x33, 0x57, 0x5A, 0x5A, 0x42, 0x42, 0x82, 0x84, 0x31, 0x32,
  0x32, 0x52, 0x4A, 0x4A, 0x4A, 0x4C, 0xC4, 0x3D, 0x1C, 0x61, 0x86, 0x18,
  0xE2, 0x70, 0x3E, 0x23, 0x23, 0x62, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x3D,
  0x1C, 0x61, 0x86, 0x18, 0xE2, 0x70, 0x83, 0x06, 0x3E, 0x23, 0x23, 0x62,
  0x7C, 0x48, 0x4C, 0x44, 0xC6, 0x1E, 0x23, 0x60, 0x20, 0x1C, 0x06, 0xC2,
  0xC6, 0x78, 0xFE, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x42, 0x8F,
  0x14, 0x28, 0x50, 0xA3, 0x44, 0xF0, 0x82, 0xC2, 0xC4, 0x44, 0x48, 0x48,
  0x50, 0x50, 0x20, 0x83, 0x82, 0x82, 0x92, 0xB4, 0xB4, 0xD4, 0xD8, 0x98,
  0x21, 0x22, 0x14, 0x18, 0x18, 0x38, 0x24, 0x44, 0x86, 0xC2, 0x44, 0x6C,
  0x28, 0x30, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x02, 0x04, 0x08, 0x18, 0x30,
  0x60, 0xC0, 0xFE, 0x1C, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10,
  0xF0, 0x8C, 0x44, 0x62, 0x23, 0x11, 0x38, 0x42, 0x11, 0x88, 0x42, 0x11,
  0x88, 0x4E, 0x00, 0x18, 0xA2, 0x92, 0x46, 0x10, 0xFF, 0x90, 0x3C, 0x4C,
  0x19, 0xE4, 0x59, 0x9D, 0x80, 0x20, 0x40, 0x81, 0xF2, 0x2C, 0x50, 0xA3,
  0x44, 0xF0, 0x39, 0x18, 0x20, 0x82, 0x27, 0x00, 0x02, 0x0C, 0x13, 0xE4,
  0xD0, 0xA3, 0x44, 0x99, 0xD0, 0x39, 0x18, 0x7F, 0x82, 0x27, 0x00, 0x1E,
  0x20, 0x87, 0xE2, 0x04, 0x08, 0x20, 0x40, 0x80, 0x3E, 0x4D, 0x0A, 0x14,
  0x49, 0x9D, 0x02, 0x48, 0xF0, 0x41, 0x04, 0x1F, 0x47, 0x18, 0x62, 0x8A,
  0x20, 0x04, 0x00, 0x01, 0xC0, 0x81, 0x02, 0x0C, 0x11, 0xFC, 0x04, 0x00,
  0x0F, 0x04, 0x20, 0x82, 0x08, 0x21, 0x84, 0xE0, 0x20, 0xC1, 0x02, 0x25,
  0x8E, 0x3C, 0x48, 0x99, 0x10, 0x1C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x11, 0xFC, 0x5E, 0x6A, 0x4A, 0x52, 0xD2, 0x92, 0x92, 0x7D, 0x1C, 0x61,
  0x8A, 0x28, 0x80, 0x39, 0x18, 0x61, 0x8E, 0x2F, 0x00, 0x3E, 0x45, 0x8A,
  0x14, 0x68, 0x9E, 0x60, 0x81, 0x00, 0x7D, 0x38, 0x63, 0x8A, 0x6E, 0x82,
  0x08, 0x60, 0x5D, 0x84, 0x10, 0x43, 0x08, 0x00, 0x39, 0x14, 0x1E, 0x0A,
  0x2F, 0x00, 0x42, 0x3E, 0x8C, 0x42, 0x10, 0xF0, 0x45, 0x18, 0x63, 0x8A,
  0x6E, 0x80, 0x87, 0x89, 0x32, 0x45, 0x0A, 0x18, 0x00, 0x83, 0x06, 0xD5,
  0xAD, 0x5B, 0x26, 0x00, 0x22, 0x24, 0x18, 0x18, 0x28, 0x6C, 0xC4, 0x41,
  0x62, 0x22, 0x24, 0x28, 0x28, 0x10, 0x30, 0x20, 0xC0, 0x3E, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x00, 0x0E, 0x20, 0x40, 0x81, 0x04, 0x30, 0x10, 0x20,
  0x41, 0x83, 0x03, 0x80, 0xFF, 0xF8, 0x38, 0x20, 0x82, 0x08, 0x20, 0x46,
  0x10, 0x41, 0x0C, 0xE0, 0xE0, 0x70,
};

const GFXglyph LiberationMono_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 3, -9 },
  { 5, 5, 4, 8, 2, -10 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 8, 11, 8, 0, -10 },
  { 28, 8, 9, 8, 0, -9 },
  { 37, 7, 9, 8, 0, -9 },
  { 45, 2, 4, 8, 4, -10 },
  { 46, 5, 13, 8, 2, -10 },
  { 55, 5, 13, 8, 1, -10 },
  { 64, 5, 5, 8, 2, -10 },
  { 68, 6, 7, 8, 1, -8 },
  { 74, 3, 4, 8, 1, -2 },
  { 76, 4, 1, 8, 2, -4 },
  { 77, 2, 2, 8, 2, -2 },
  { 78, 8, 10, 8, 0, -10 },
  { 88, 6, 9, 8, 1, -9 },
  { 95, 7, 9, 8, 0, -9 },
  { 103, 7, 9, 8, 0, -9 },
  { 111, 6, 9, 8, 1, -9 },
  { 118, 7, 9, 8, 0, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 6, 9, 8, 2, -9 },
  { 147, 6, 9, 8, 1, -9 },
  { 154, 6, 9, 8, 1, -9 },
  { 161, 3, 7, 8, 2, -7 },
  { 164, 4, 9, 8, 1, -7 },
  { 169, 6, 7, 8, 1, -8 },
  { 175, 6, 4, 8, 1, -6 },
  { 178, 6, 7, 8, 1, -8 },
  { 184, 6, 9, 8, 1, -9 },
  { 191, 8, 12, 8, 0, -10 },
  { 203, 8, 9, 8, -1, -9 },
  { 212, 7, 9, 8, 0, -9 },
  { 220, 7, 9, 8, 1, -9 },
  { 228, 7, 9, 8, 0, -9 },
  { 236, 8, 9, 8, 0, -9 },
  { 245, 7, 9, 8, 1, -9 },
  { 253, 7, 9, 8, 1, -9 },
  { 261, 8, 9, 8, 0, -9 },
  { 270, 7, 9, 8, 1, -9 },
  { 278, 6, 9, 8, 1, -9 },
  { 285, 8, 9, 8, 0, -9 },
  { 294, 6, 9, 8, 1, -9 },
  { 301, 8, 9, 8, 0, -9 },
  { 310, 8, 9, 8, 0, -9 },
  { 319, 6, 9, 8, 1, -9 },
  { 326, 8, 9, 8, 0, -9 },
  { 335, 6, 12, 8, 1, -9 },
  { 344, 8, 9, 8, 0, -9 },
  { 353, 8, 9, 8, 0, -9 },
  { 362, 7, 9, 8, 1, -9 },
  { 370, 7, 9, 8, 1, -9 },
  { 378, 8, 9, 8, 1, -9 },
  { 387, 8, 9, 8, 1, -9 },
  { 396, 8, 9, 8, 0, -9 },
  { 405, 8, 9, 8, 1, -9 },
  { 414, 8, 9, 8, 0, -9 },
  { 423, 6, 13, 8, 1, -10 },
  { 433, 4, 10, 8, 2, -10 },
  { 438, 5, 13, 8, 1, -10 },
  { 447, 6, 6, 8, 1, -9 },
  { 452, 8, 1, 8, -1, 1 },
  { 453, 2, 2, 8, 4, -10 },
  { 454, 7, 7, 8, 0, -7 },
  { 461, 7, 10, 8, 0, -10 },
  { 470, 6, 7, 8, 1, -7 },
  { 476, 7, 10, 8, 1, -10 },
  { 485, 6, 7, 8, 1, -7 },
  { 491, 7, 10, 8, 1, -10 },
  { 500, 7, 10, 8, 0, -7 },
  { 509, 6, 10, 8, 1, -10 },
  { 517, 7, 10, 8, 0, -10 },
  { 526, 6, 13, 8, 0, -10 },
  { 536, 7, 10, 8, 1, -10 },
  { 545, 7, 10, 8, 0, -10 },
  { 554, 8, 7, 8, 0, -7 },
  { 561, 6, 7, 8, 1, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 7, 10, 8, 0, -7 },
  { 582, 6, 10, 8, 1, -7 },
  { 590, 6, 7, 8, 1, -7 },
  { 596, 6, 7, 8, 1, -7 },
  { 602, 5, 9, 8, 2, -9 },
  { 608, 6, 7, 8, 1, -7 },
  { 614, 7, 7, 8, 1, -7 },
  { 621, 7, 7, 8, 1, -7 },
  { 628, 8, 7, 8, 0, -7 },
  { 635, 8, 10, 8, 0, -7 },
  { 645, 7, 7, 8, 0, -7 },
  { 652, 7, 13, 8, 1, -10 },
  { 664, 1, 13, 8, 3, -10 },
  { 666, 6, 13, 8, 0, -10 },
  { 676, 6, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_Italic13pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic13pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _LIBERATIONMONO_ITALIC13PT7B_H_
