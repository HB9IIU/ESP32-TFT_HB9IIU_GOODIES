#ifndef _LIBERATIONMONO_ITALIC9PT7B_H_
#define _LIBERATIONMONO_ITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x88, 0xB6, 0x80, 0x01, 0x5E, 0xAF, 0xAA, 0x00, 0x11, 0xD6,
  0xA7, 0x16, 0xAE, 0x20, 0x66, 0xAD, 0x08, 0x39, 0x69, 0x80, 0x32, 0x4C,
  0xCA, 0xCB, 0xE0, 0xE0, 0x22, 0x44, 0x88, 0x88, 0x40, 0x44, 0x92, 0x52,
  0x80, 0x5F, 0x60, 0x44, 0xF4, 0x40, 0x6A, 0x00, 0xE0, 0x80, 0x08, 0x21,
  0x08, 0x21, 0x08, 0x00, 0x79, 0x9D, 0x9A, 0xE0, 0x13, 0x84, 0x22, 0x13,
  0xE0, 0x3A, 0x42, 0x22, 0x23, 0xC0, 0x3A, 0x42, 0x60, 0xC5, 0xC0, 0x19,
  0x4C, 0xAF, 0x88, 0x40, 0x3A, 0x1C, 0x10, 0xC9, 0xC0, 0x78, 0xE9, 0x9A,
  0xE0, 0xF1, 0x22, 0x44, 0x80, 0x3A, 0x52, 0x64, 0xC5, 0xC0, 0x79, 0x99,
  0xF2, 0xC0, 0x40, 0x80, 0x20, 0x05, 0x20, 0x1E, 0x8E, 0x10, 0xF0, 0xF0,
  0x86, 0x16, 0x80, 0x79, 0x12, 0x40, 0x40, 0x39, 0x17, 0xED, 0xDB, 0x6F,
  0x20, 0x70, 0x11, 0x8C, 0x97, 0xC6, 0x20, 0x7A, 0x52, 0xE4, 0xC7, 0xC0,
  0x79, 0x88, 0x89, 0xE0, 0x72, 0x52, 0x94, 0xCB, 0x80, 0x7A, 0x10, 0xF4,
  0x43, 0xE0, 0x7A, 0x10, 0xF4, 0x22, 0x00, 0x79, 0x8B, 0x99, 0xE0, 0x4A,
  0x52, 0xF4, 0xC6, 0x40, 0x38, 0x88, 0x42, 0x13, 0xC0, 0x31, 0x11, 0x2A,
  0xC0, 0x49, 0x46, 0x18, 0x52, 0x48, 0x80, 0x48, 0x88, 0x88, 0xE0, 0x49,
  0xE7, 0x9A, 0x8A, 0x28, 0x80, 0x4B, 0x5A, 0xD5, 0xCA, 0x40, 0x3A, 0x52,
  0x98, 0xA9, 0xC0, 0x7A, 0x52, 0xE4, 0x42, 0x00, 0x3A, 0x52, 0x98, 0xA9,
  0xC4, 0x30, 0x7A, 0x52, 0xE5, 0x4A, 0x20, 0x3A, 0x50, 0x60, 0xC5, 0xC0,
  0xF9, 0x10, 0x84, 0x21, 0x00, 0x4A, 0x52, 0x98, 0xC9, 0xC0, 0x8C, 0xA5,
  0x4A, 0x51, 0x00, 0x45, 0x1A, 0xAE, 0xB9, 0x4D, 0x00, 0x48, 0xA3, 0x08,
  0x51, 0x48, 0x80, 0x8C, 0x94, 0xC4, 0x21, 0x00, 0x78, 0x21, 0x08, 0x42,
  0x0F, 0x80, 0x34, 0x44, 0x48, 0x88, 0xC0, 0x89, 0x22, 0x48, 0x31, 0x11,
  0x12, 0x22, 0xE0, 0x11, 0x92, 0x90, 0xFC, 0xC0, 0x70, 0x5D, 0x2F, 0x80,
  0x42, 0x1E, 0x94, 0xA7, 0xC0, 0x3A, 0x21, 0x07, 0x00, 0x08, 0x4E, 0x94,
  0xC9, 0xC0, 0x69, 0xF8, 0xE0, 0x3A, 0x3C, 0x84, 0x42, 0x00, 0x3A, 0x53,
  0x27, 0x0B, 0x80, 0x42, 0x1E, 0x94, 0xA6, 0x40, 0x10, 0x1C, 0x22, 0x13,
  0xE0, 0x10, 0x71, 0x11, 0x22, 0xC0, 0x48, 0x9E, 0xCA, 0xA0, 0x30, 0x84,
  0x42, 0x13, 0xE0, 0x7B, 0x6B, 0x5A, 0x80, 0x7A, 0x52, 0x99, 0x00, 0x3A,
  0x63, 0x17, 0x00, 0x7A, 0x52, 0x9F, 0x42, 0x00, 0x3A, 0x53, 0x27, 0x08,
  0x40, 0xBC, 0x88, 0x80, 0x3A, 0x0C, 0x17, 0x00, 0x4F, 0x48, 0x8E, 0x99,
  0x9A, 0xE0, 0x94, 0xA9, 0x44, 0x00, 0x86, 0xAA, 0xB6, 0xD0, 0x49, 0x88,
  0xA9, 0x00, 0x49, 0x25, 0x14, 0x21, 0x0C, 0x00, 0x78, 0x88, 0x8F, 0x00,
  0x32, 0x44, 0x84, 0x44, 0x60, 0xFF, 0x80, 0x71, 0x11, 0x12, 0x22, 0xC0,
  0xC3,
};

const GFXglyph LiberationMono_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 5, 0, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 1, 3, 5, 3, -7 },
  { 28, 4, 9, 5, 1, -7 },
  { 33, 3, 9, 5, 1, -7 },
  { 37, 3, 4, 5, 2, -7 },
  { 39, 4, 5, 5, 1, -6 },
  { 42, 3, 3, 5, 0, -1 },
  { 44, 3, 1, 5, 1, -3 },
  { 45, 1, 1, 5, 2, -1 },
  { 46, 6, 7, 5, 0, -7 },
  { 52, 4, 7, 5, 1, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 4, 7, 5, 1, -7 },
  { 85, 4, 7, 5, 1, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 4, 7, 5, 1, -7 },
  { 98, 2, 5, 5, 2, -5 },
  { 100, 3, 7, 5, 1, -5 },
  { 103, 4, 5, 5, 1, -6 },
  { 106, 4, 3, 5, 1, -5 },
  { 108, 4, 5, 5, 1, -6 },
  { 111, 4, 7, 5, 1, -7 },
  { 115, 6, 9, 5, 0, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 5, 7, 5, 0, -7 },
  { 132, 4, 7, 5, 1, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 5, 7, 5, 0, -7 },
  { 146, 5, 7, 5, 0, -7 },
  { 151, 4, 7, 5, 1, -7 },
  { 155, 5, 7, 5, 0, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 4, 7, 5, 1, -7 },
  { 169, 6, 7, 5, 0, -7 },
  { 175, 4, 7, 5, 1, -7 },
  { 179, 6, 7, 5, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 5, 7, 5, 0, -7 },
  { 200, 5, 9, 5, 0, -7 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 5, 7, 5, 0, -7 },
  { 216, 5, 7, 5, 1, -7 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 5, 7, 5, 1, -7 },
  { 231, 6, 7, 5, 0, -7 },
  { 237, 6, 7, 5, 0, -7 },
  { 243, 5, 7, 5, 1, -7 },
  { 248, 6, 7, 5, 0, -7 },
  { 254, 4, 9, 5, 1, -7 },
  { 259, 3, 7, 5, 1, -7 },
  { 262, 4, 9, 5, 0, -7 },
  { 267, 5, 4, 5, 0, -7 },
  { 270, 6, 1, 5, -1, 1 },
  { 271, 1, 2, 5, 3, -8 },
  { 272, 5, 5, 5, 0, -5 },
  { 276, 5, 7, 5, 0, -7 },
  { 281, 5, 5, 5, 0, -5 },
  { 285, 5, 7, 5, 0, -7 },
  { 290, 4, 5, 5, 1, -5 },
  { 293, 5, 7, 5, 1, -7 },
  { 298, 5, 7, 5, 0, -5 },
  { 303, 5, 7, 5, 0, -7 },
  { 308, 5, 7, 5, 0, -7 },
  { 313, 4, 9, 5, 0, -7 },
  { 318, 4, 7, 5, 1, -7 },
  { 322, 5, 7, 5, 0, -7 },
  { 327, 5, 5, 5, 0, -5 },
  { 331, 5, 5, 5, 0, -5 },
  { 335, 5, 5, 5, 0, -5 },
  { 339, 5, 7, 5, 0, -5 },
  { 344, 5, 7, 5, 0, -5 },
  { 349, 4, 5, 5, 1, -5 },
  { 352, 5, 5, 5, 0, -5 },
  { 356, 4, 6, 5, 1, -6 },
  { 359, 4, 5, 5, 1, -5 },
  { 362, 5, 5, 5, 1, -5 },
  { 366, 6, 5, 5, 0, -5 },
  { 370, 5, 5, 5, 0, -5 },
  { 374, 6, 7, 5, 0, -5 },
  { 380, 5, 5, 5, 0, -5 },
  { 384, 4, 9, 5, 1, -7 },
  { 389, 1, 9, 5, 2, -7 },
  { 391, 4, 9, 5, 0, -7 },
  { 396, 4, 2, 5, 1, -4 },
};

const GFXfont LiberationMono_Italic9pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic9pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic9pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _LIBERATIONMONO_ITALIC9PT7B_H_
