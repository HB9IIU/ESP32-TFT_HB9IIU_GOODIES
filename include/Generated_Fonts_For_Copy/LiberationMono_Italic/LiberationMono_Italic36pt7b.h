#ifndef _LIBERATIONMONO_ITALIC36PT7B_H_
#define _LIBERATIONMONO_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0x70, 0xF0,
  0xF0, 0x78, 0x7B, 0xC3, 0xDC, 0x1C, 0xE1, 0xEF, 0x0F, 0x78, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x06, 0x06, 0x00, 0x38,
  0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xE0, 0x79, 0x9F, 0x0E, 0x18, 0xF1, 0xC1, 0x87, 0x1C, 0x38, 0x71,
  0xC3, 0x80, 0x1C, 0x30, 0x01, 0xE3, 0x00, 0x0F, 0x30, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x06, 0xF8, 0x00, 0x63, 0xC0, 0x06, 0x1E, 0x00, 0x60,
  0xE0, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x0C, 0x1C, 0xE0, 0xC1, 0xCF, 0x0C,
  0x38, 0x78, 0xCF, 0x83, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x07, 0x07, 0xF0, 0x0E, 0x0E, 0x38,
  0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x30, 0x18, 0x38, 0x60, 0x18, 0x38,
  0xC0, 0x38, 0x31, 0xC0, 0x38, 0x73, 0x80, 0x1C, 0xE7, 0x00, 0x1F, 0xEE,
  0x00, 0x0F, 0x9C, 0x00, 0x00, 0x19, 0xF0, 0x00, 0x33, 0xFC, 0x00, 0x67,
  0x1C, 0x00, 0xE6, 0x1C, 0x01, 0xCE, 0x0C, 0x03, 0x8E, 0x1C, 0x07, 0x0C,
  0x1C, 0x0E, 0x0C, 0x1C, 0x0C, 0x0C, 0x38, 0x18, 0x0E, 0x38, 0x30, 0x0F,
  0xF0, 0x70, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0x87, 0x00,
  0xE0, 0x60, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x3C, 0x03,
  0x9F, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x31, 0xFC, 0x0E, 0x71,
  0xC1, 0xDE, 0x38, 0x73, 0x83, 0x8E, 0xE0, 0x73, 0x9C, 0x07, 0x63, 0x80,
  0xFC, 0x70, 0x0F, 0x0E, 0x01, 0xF0, 0xF0, 0xFF, 0x1F, 0xFD, 0xF8, 0xFC,
  0x0F, 0x7B, 0xDC, 0xEF, 0x7B, 0x9C, 0xE6, 0x30, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0xC6, 0x17, 0xB7, 0x9F, 0xF8, 0x3E, 0x00,
  0xE0, 0x0F, 0x80, 0xEC, 0x0E, 0x70, 0xE1, 0x82, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF,
  0xEF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78,
  0x38, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xDC, 0x00, 0x77, 0x1F, 0x1D, 0xC7, 0x87, 0x71, 0xE1, 0xFC, 0x78,
  0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0x73,
  0xC0, 0x38, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x07, 0xB8, 0x1F, 0x9E, 0x07, 0x87,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0x0F,
  0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x7C, 0x38, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xF0,
  0x0E, 0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0x77, 0x00, 0x1C,
  0xE0, 0x07, 0x1C, 0x01, 0xC7, 0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x03, 0x03,
  0x80, 0xC0, 0x70, 0x30, 0x0E, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xCF, 0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0x78, 0x3C,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00, 0x78, 0x78, 0x0F, 0x07, 0xC1, 0xE0,
  0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xE1, 0xE1,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0xFC, 0x3D, 0xFF, 0x9D, 0x83, 0xCF, 0x80, 0xF7, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCF,
  0x01, 0xC3, 0xC3, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0x7F, 0xFF,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x73, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x83, 0xC0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x07, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x0E, 0x3E, 0x0F,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78,
  0x38, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0x87,
  0xE1, 0xFF, 0x38, 0x1F, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE3,
  0x80, 0x78, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0xC1, 0xE0, 0x78, 0xF0, 0x0E, 0x78, 0x03, 0xDC, 0x00, 0xFE, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0x00, 0x70,
  0x0E, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x87, 0x9B,
  0x0C, 0x3F, 0x6C, 0x63, 0x8F, 0x31, 0x8C, 0x1C, 0xCE, 0x70, 0x63, 0x33,
  0x83, 0x9C, 0xCC, 0x0E, 0x66, 0x30, 0x31, 0x99, 0xC1, 0xC6, 0x66, 0x06,
  0x39, 0x98, 0x18, 0xCE, 0xE0, 0xE3, 0x3B, 0x87, 0x18, 0xCE, 0x1C, 0x63,
  0x18, 0xB3, 0x0C, 0x7E, 0xF8, 0x38, 0xE1, 0xC0, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x10, 0x1C, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0x7F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x80, 0x03, 0x8E, 0x00,
  0x1E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x78,
  0x3C, 0x01, 0xC0, 0xF0, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0E, 0x03, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0,
  0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0x38, 0x07, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xE3,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0x70, 0x03, 0x8F, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x1E, 0x38, 0x01,
  0xCF, 0x00, 0x31, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x01, 0x1E, 0x00, 0x73, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x80, 0xE0,
  0x78, 0x78, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x0E, 0x07, 0xC0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x1E, 0x00,
  0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x78,
  0x01, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x87, 0x00, 0x70, 0x70, 0x0E, 0x0F,
  0x03, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x38, 0x01,
  0xCF, 0x00, 0x21, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC1, 0xFF,
  0x38, 0x3F, 0xEF, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x80, 0x1C,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x80, 0xF0,
  0x78, 0x7E, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x70, 0x78, 0x03,
  0x83, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x78,
  0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00,
  0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x1C, 0x07, 0x8F,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x1E, 0x1E, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF0,
  0x0E, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x1C,
  0x78, 0x00, 0x73, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xF9, 0xE0, 0x03, 0xC7, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x70, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3C, 0x1E, 0x01,
  0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xEC, 0x3B, 0x83, 0x38, 0xEE, 0x1C, 0xE7, 0x30, 0x73, 0x99, 0xC1, 0xCE,
  0xE7, 0x07, 0x3B, 0x1C, 0x18, 0x7C, 0x70, 0xE1, 0xE1, 0xC3, 0x87, 0x8E,
  0x0E, 0x1C, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0x0F, 0x80, 0x70, 0x7C, 0x03, 0x83, 0xE0, 0x1C, 0x1F, 0x00, 0xE0,
  0xFC, 0x07, 0x06, 0xE0, 0x70, 0x77, 0x03, 0x83, 0x98, 0x1C, 0x1C, 0xE0,
  0xE0, 0xE7, 0x07, 0x07, 0x38, 0x78, 0x70, 0xE3, 0x83, 0x87, 0x1C, 0x1C,
  0x38, 0xE0, 0xE1, 0xC7, 0x07, 0x07, 0x78, 0x70, 0x3B, 0x83, 0x81, 0xDC,
  0x1C, 0x0E, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x70, 0x0F, 0x83, 0x80,
  0x7C, 0x1C, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1E, 0x1E, 0x07,
  0x01, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x78,
  0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x1D, 0xE0,
  0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0xC0,
  0x1C, 0x78, 0x07, 0x07, 0x01, 0xC0, 0xF0, 0x70, 0x0F, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0E, 0x01, 0xE0, 0xE0, 0x0F, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1E, 0x1E, 0x07, 0x01, 0xE1, 0xE0,
  0x1C, 0x38, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x78, 0x01, 0xEE, 0x00,
  0x3D, 0xC0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xB8, 0x00,
  0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x07,
  0x07, 0x01, 0xE0, 0xF0, 0x78, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0E, 0x01, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x0F, 0x1C,
  0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x03, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0x83, 0x80, 0x38, 0x3C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0xF0, 0x70, 0x07, 0x0F, 0x00, 0x78, 0xF0, 0x07,
  0x8E, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0x81, 0xE0, 0xF0,
  0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x87, 0xC0, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0,
  0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00,
  0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xC0, 0x1E, 0x1E,
  0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x07,
  0x38, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x3C,
  0x1C, 0xF0, 0xF0, 0xE3, 0x87, 0xC3, 0x8E, 0x1B, 0x0E, 0x38, 0x6C, 0x70,
  0xE3, 0xB1, 0xC3, 0x8C, 0xC7, 0x0E, 0x73, 0x38, 0x39, 0x8C, 0xE0, 0xEE,
  0x33, 0x83, 0xB0, 0xCC, 0x0E, 0xC3, 0x70, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x0F,
  0x03, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x70,
  0x00, 0xE0, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xC7, 0x00, 0x03, 0xC7, 0x80,
  0x07, 0x83, 0x80, 0x07, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x73,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0x70, 0x07, 0x83, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x78, 0x3C, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x79, 0xC0, 0x01,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x1C, 0x70, 0x0C, 0x38,
  0x0E, 0x1C, 0x06, 0x06, 0x07, 0x03, 0x07, 0x01, 0xC3, 0x00, 0xE3, 0x80,
  0x71, 0x80, 0x19, 0xC0, 0x0F, 0xC0, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0xF0,
  0x78, 0x38, 0x0E, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x03, 0xFF, 0x87, 0xFF, 0xE3, 0xE0, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x3C,
  0x03, 0xCF, 0x01, 0xF3, 0xC0, 0xFC, 0xF0, 0x6F, 0x1F, 0xF3, 0xF3, 0xF0,
  0x7C, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x71, 0xF8, 0x0E, 0xFF, 0x81, 0xF8,
  0x78, 0x7C, 0x07, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00,
  0x71, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01,
  0xC7, 0x80, 0x38, 0xF0, 0x0E, 0x1F, 0x03, 0xC3, 0xF0, 0xF0, 0x77, 0xFC,
  0x1E, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x0E,
  0x38, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xCF, 0x00,
  0xF1, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x3F, 0x1C, 0x07, 0xFD, 0xC1, 0xE0, 0xDC, 0x1C,
  0x07, 0xC3, 0x80, 0x78, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0,
  0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xF0, 0x3E, 0x07, 0x86, 0xE0, 0x7F, 0xCE,
  0x01, 0xF0, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x0E,
  0x3C, 0x03, 0x8E, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0E, 0x7F, 0xFF, 0xBF,
  0xFF, 0xEE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x61, 0xC0, 0x38, 0x78, 0x3C, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0xE0,
  0x7F, 0x9C, 0x1E, 0x1B, 0x87, 0x01, 0x71, 0xC0, 0x3C, 0x38, 0x07, 0x8F,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x0E, 0x3C,
  0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x3C,
  0x37, 0x07, 0xFC, 0xE0, 0x3E, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xE0,
  0x1C, 0x1C, 0x07, 0x03, 0xC3, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0xFC, 0x0E, 0xFF, 0x83, 0xF0, 0xF1, 0xF0, 0x1C,
  0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0x9C, 0x01,
  0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x20, 0x7C, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x0E, 0x03, 0x83, 0xC0,
  0xE0, 0x70, 0x38, 0x0E, 0x1E, 0x01, 0xC7, 0x80, 0x39, 0xE0, 0x07, 0x78,
  0x01, 0xDE, 0x00, 0x3F, 0xE0, 0x07, 0xDC, 0x00, 0xE3, 0xC0, 0x1C, 0x38,
  0x07, 0x87, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xF0, 0x70, 0x1E,
  0x1E, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0xF0, 0xF0, 0xEF, 0xDF, 0x87, 0xCE, 0x9E, 0x3C, 0x78, 0x71, 0xC3, 0xC3,
  0x8E, 0x1C, 0x1C, 0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x70, 0x71, 0xC3,
  0x83, 0x8E, 0x1C, 0x1C, 0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x38, 0x71,
  0xC3, 0x83, 0x8E, 0x1C, 0x1C, 0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x38,
  0x70, 0x0E, 0x3F, 0x03, 0x9F, 0xE0, 0xFC, 0x3C, 0x7C, 0x07, 0x1E, 0x01,
  0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCE, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xF0, 0x78, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0,
  0x07, 0x38, 0x01, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x07, 0x1F, 0x80, 0x77, 0xFC, 0x07, 0xE1, 0xE0, 0xF8,
  0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3,
  0xC0, 0x1C, 0x3C, 0x03, 0x83, 0xE0, 0x78, 0x3F, 0x0F, 0x03, 0xBF, 0xE0,
  0x79, 0xF8, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFF,
  0x71, 0xE0, 0xDC, 0x70, 0x1F, 0x38, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x1E, 0x70, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0F, 0x38, 0x03, 0xCE, 0x01, 0xE3, 0xC0, 0xF8, 0x78, 0x6E, 0x1F, 0xF3,
  0x81, 0xF1, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x1F, 0x8E, 0x3F, 0xC7,
  0x3F, 0xE3, 0xB8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xF0, 0x1C,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x47, 0xFE, 0x0F, 0xF8, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0x78,
  0x6E, 0x1F, 0xF3, 0x83, 0xF0, 0xE0, 0xF0, 0x01, 0xFE, 0x00, 0x39, 0xC0,
  0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xF0, 0xE0, 0x1E, 0x38, 0x01, 0xCF,
  0x00, 0x39, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x70, 0x73, 0x87, 0x83, 0x9C, 0x3E,
  0x38, 0xE3, 0xF1, 0xC7, 0x1B, 0x8E, 0x39, 0xCC, 0xE1, 0xCC, 0x67, 0x0E,
  0xE3, 0x30, 0x76, 0x1B, 0x83, 0xF0, 0xDC, 0x1F, 0x06, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x38, 0x07, 0x81,
  0xE0, 0x38, 0x07, 0x03, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0xB8,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xB8, 0x00, 0x39, 0xC0, 0x03, 0x87, 0x00, 0x38, 0x3C, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x78,
  0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x3C, 0x03,
  0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x1B,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x1B, 0x07, 0xFF, 0x00, 0x1F, 0x80,
};

const GFXglyph LiberationMono_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 24, 22, 7, -24 },
  { 25, 13, 11, 22, 7, -26 },
  { 43, 22, 24, 22, 0, -24 },
  { 109, 20, 30, 22, 1, -27 },
  { 184, 24, 24, 22, -1, -24 },
  { 256, 19, 24, 22, 0, -24 },
  { 313, 5, 11, 22, 11, -26 },
  { 320, 14, 33, 22, 5, -26 },
  { 378, 13, 33, 22, 3, -26 },
  { 432, 13, 13, 22, 6, -26 },
  { 454, 18, 18, 22, 2, -21 },
  { 495, 10, 12, 22, 1, -5 },
  { 510, 10, 3, 22, 6, -10 },
  { 514, 5, 5, 22, 7, -5 },
  { 518, 23, 26, 22, 0, -26 },
  { 593, 18, 24, 22, 2, -24 },
  { 647, 18, 24, 22, 1, -24 },
  { 701, 19, 24, 22, 1, -24 },
  { 758, 18, 24, 22, 2, -24 },
  { 812, 19, 24, 22, 1, -24 },
  { 869, 20, 24, 22, 1, -24 },
  { 929, 17, 24, 22, 3, -24 },
  { 980, 17, 24, 22, 5, -24 },
  { 1031, 18, 24, 22, 2, -24 },
  { 1085, 18, 24, 22, 2, -24 },
  { 1139, 8, 19, 22, 7, -19 },
  { 1158, 12, 26, 22, 3, -19 },
  { 1197, 18, 18, 22, 2, -21 },
  { 1238, 18, 11, 22, 2, -18 },
  { 1263, 18, 18, 22, 2, -21 },
  { 1304, 18, 24, 22, 3, -24 },
  { 1358, 22, 31, 22, 0, -26 },
  { 1444, 22, 24, 22, -2, -24 },
  { 1510, 20, 24, 22, 1, -24 },
  { 1570, 19, 24, 22, 2, -24 },
  { 1627, 20, 24, 22, 1, -24 },
  { 1687, 21, 24, 22, 1, -24 },
  { 1750, 20, 24, 22, 2, -24 },
  { 1810, 19, 24, 22, 2, -24 },
  { 1867, 21, 24, 22, 1, -24 },
  { 1930, 19, 24, 22, 2, -24 },
  { 1987, 18, 24, 22, 2, -24 },
  { 2041, 22, 24, 22, 1, -24 },
  { 2107, 16, 24, 22, 2, -24 },
  { 2155, 22, 24, 22, 0, -24 },
  { 2221, 21, 24, 22, 1, -24 },
  { 2284, 19, 24, 22, 2, -24 },
  { 2341, 20, 24, 22, 1, -24 },
  { 2401, 19, 31, 22, 2, -24 },
  { 2475, 20, 24, 22, 1, -24 },
  { 2535, 20, 24, 22, 1, -24 },
  { 2595, 19, 24, 22, 4, -24 },
  { 2652, 20, 24, 22, 2, -24 },
  { 2712, 21, 24, 22, 3, -24 },
  { 2775, 22, 24, 22, 2, -24 },
  { 2841, 24, 24, 22, -1, -24 },
  { 2913, 21, 24, 22, 3, -24 },
  { 2976, 23, 24, 22, -1, -24 },
  { 3045, 16, 33, 22, 4, -26 },
  { 3111, 13, 26, 22, 5, -26 },
  { 3154, 17, 33, 22, 1, -26 },
  { 3225, 17, 16, 22, 2, -24 },
  { 3259, 22, 2, 22, -3, 2 },
  { 3265, 7, 5, 22, 10, -26 },
  { 3270, 18, 19, 22, 1, -19 },
  { 3313, 19, 26, 22, 1, -26 },
  { 3375, 18, 19, 22, 2, -19 },
  { 3418, 20, 26, 22, 2, -26 },
  { 3483, 18, 19, 22, 2, -19 },
  { 3526, 18, 26, 22, 4, -26 },
  { 3585, 19, 26, 22, 1, -19 },
  { 3647, 18, 26, 22, 1, -26 },
  { 3706, 17, 26, 22, 1, -26 },
  { 3762, 19, 33, 22, -1, -26 },
  { 3841, 19, 26, 22, 2, -26 },
  { 3903, 17, 26, 22, 1, -26 },
  { 3959, 21, 19, 22, 0, -19 },
  { 4009, 18, 19, 22, 1, -19 },
  { 4052, 18, 19, 22, 2, -19 },
  { 4095, 20, 26, 22, 0, -19 },
  { 4160, 18, 26, 22, 2, -19 },
  { 4219, 17, 19, 22, 3, -19 },
  { 4260, 17, 19, 22, 2, -19 },
  { 4301, 14, 24, 22, 5, -24 },
  { 4343, 18, 19, 22, 2, -19 },
  { 4386, 19, 19, 22, 3, -19 },
  { 4432, 21, 19, 22, 2, -19 },
  { 4482, 21, 19, 22, 0, -19 },
  { 4532, 22, 26, 22, 0, -19 },
  { 4604, 19, 19, 22, 1, -19 },
  { 4650, 18, 33, 22, 4, -26 },
  { 4725, 3, 33, 22, 9, -26 },
  { 4738, 18, 33, 22, 0, -26 },
  { 4813, 19, 4, 22, 2, -14 },
};

const GFXfont LiberationMono_Italic36pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic36pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic36pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _LIBERATIONMONO_ITALIC36PT7B_H_
