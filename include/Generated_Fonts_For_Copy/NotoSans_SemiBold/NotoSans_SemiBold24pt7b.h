#ifndef _NOTOSANS_SEMIBOLD24PT7B_H_
#define _NOTOSANS_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0x7F, 0x70, 0xEF, 0x9F,
  0x1E, 0x3C, 0x78, 0xC0, 0x06, 0x30, 0x39, 0xC0, 0xE6, 0x03, 0x18, 0x0C,
  0x63, 0xFF, 0xFF, 0xFF, 0xC7, 0x38, 0x18, 0xC0, 0x63, 0x0F, 0xFF, 0xBF,
  0xFE, 0x39, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0x06, 0x00,
  0x60, 0x3F, 0xE7, 0xFE, 0xF6, 0x6E, 0x60, 0xE6, 0x07, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x6E, 0x06, 0x78, 0x6F, 0xFF, 0xEF, 0xFC, 0x3F, 0x00,
  0x60, 0x06, 0x00, 0x7C, 0x06, 0x0F, 0xC1, 0xC3, 0x98, 0x30, 0x63, 0x8C,
  0x0C, 0x73, 0x81, 0x8E, 0x60, 0x31, 0xDC, 0x47, 0x33, 0x3E, 0x7E, 0xEF,
  0xCF, 0x99, 0x9C, 0x07, 0x71, 0x80, 0xCE, 0x30, 0x31, 0xC6, 0x0E, 0x38,
  0xC1, 0x83, 0x38, 0x70, 0x7E, 0x1C, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0E, 0x38, 0x06, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x3F, 0x07, 0x3F, 0xC7, 0xBC, 0xF3, 0x9C, 0x3F, 0xCE, 0x0F, 0xC7,
  0x83, 0xC3, 0xE7, 0xF0, 0xFF, 0xFC, 0x3F, 0xCF, 0x80, 0xFB, 0x6D, 0x80,
  0x1C, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18,
  0x71, 0xC3, 0x8E, 0x1C, 0xE1, 0x87, 0x0E, 0x38, 0xE1, 0x87, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xC7, 0x18, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x63, 0x3F, 0xFF, 0xFF, 0xC7, 0xC0, 0xD8, 0x3B, 0x8E, 0x38, 0x44, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x77, 0x6E, 0xEC, 0xFF, 0xFF, 0xC0, 0x7F,
  0x70, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x06, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x1F, 0x83, 0xFC,
  0x79, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0x0E,
  0x3C, 0xFF, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x3F, 0x8F, 0xFC, 0x71, 0xE4, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xFC, 0x61, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC1, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0E, 0xC1, 0xEF, 0xFC, 0x7F, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x07, 0x70, 0x33, 0x83, 0x9C, 0x38, 0xE1, 0x87, 0x18, 0x39,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0xE3, 0xEF, 0xFC, 0x7F, 0x80,
  0x0F, 0xE1, 0xFE, 0x3C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE7, 0x8F, 0xFE,
  0xFD, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x79, 0xE3, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x00, 0x3F, 0x87, 0xFC, 0x70, 0xE6, 0x0E, 0x60, 0xE7,
  0x0E, 0x7F, 0xC1, 0xF8, 0x1F, 0x87, 0xBC, 0xF0, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xE7, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xFC, 0x71, 0xEE, 0x0E,
  0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x0F, 0x7B, 0xF7, 0xF7, 0x1E, 0x60, 0x0E,
  0x00, 0xE0, 0x1C, 0x07, 0xC7, 0xF8, 0x7E, 0x00, 0x7F, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x70, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x77, 0x6E, 0xEC, 0x00,
  0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x0C, 0x00, 0x7F, 0x9F,
  0xF9, 0x87, 0x00, 0x70, 0x0C, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0x80,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x78, 0x0E, 0x1C, 0x00, 0xE3, 0x07, 0x8E, 0xE3, 0xF8,
  0xD8, 0xE3, 0x1F, 0x38, 0x63, 0xE7, 0x0C, 0x7C, 0xC1, 0x8F, 0x98, 0x71,
  0xF3, 0x8E, 0x7E, 0x3F, 0xFC, 0xC7, 0xCF, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x06, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x38, 0x7D, 0xC0,
  0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9F, 0xF8, 0xFF, 0xE7, 0x0F, 0xB8, 0x1D,
  0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0xFF, 0xDF, 0xFC, 0xFF, 0xC0, 0x07, 0xFC,
  0x7F, 0xE3, 0xE3, 0x9E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xF3,
  0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x8E, 0x3F, 0x38, 0x1E, 0xE0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3B, 0x81, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0xF8, 0x71,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xE1,
  0xFD, 0xC0, 0x3B, 0x80, 0x77, 0x80, 0xEF, 0x01, 0xCF, 0xC7, 0x8F, 0xFF,
  0x07, 0xFC, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x7F, 0xFE, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xDE, 0x00, 0xE0, 0x7B, 0x81, 0xCE, 0x0E,
  0x38, 0x70, 0xE3, 0xC3, 0x9E, 0x0E, 0xF0, 0x3B, 0x80, 0xFF, 0x03, 0xFE,
  0x0F, 0x38, 0x38, 0xF0, 0xE1, 0xE3, 0x83, 0x8E, 0x0F, 0x38, 0x1E, 0xE0,
  0x3C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFB, 0x03,
  0x7E, 0xE1, 0xDF, 0xB8, 0x77, 0xE6, 0x19, 0xF9, 0xCE, 0x7E, 0x73, 0x9F,
  0x8C, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1,
  0xE1, 0xC0, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFD,
  0xC1, 0xF9, 0xC3, 0xF3, 0xC7, 0xE3, 0x8F, 0xC7, 0x9F, 0x87, 0x3F, 0x07,
  0x7E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1E, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0x8F, 0x8F, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x3B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xF3, 0xC0, 0x70, 0xFD, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF,
  0x8F, 0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1E, 0xFF,
  0xEF, 0xFC, 0xFC, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0x8F, 0x8F, 0x01, 0xC7, 0x00, 0xF3,
  0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0x70, 0xFD, 0xF8, 0x3F, 0xF8, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xFF, 0x87,
  0xFF, 0x38, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C, 0x3C, 0xFF,
  0xC7, 0xFC, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0x73, 0x83, 0xDC, 0x0E,
  0xE0, 0x78, 0x3F, 0xCF, 0xFD, 0xE3, 0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xFC, 0xFF, 0xFE,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC0, 0xE7, 0xCF, 0x8F, 0xFC, 0x1F, 0xE0,
  0xE0, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0x80, 0xE3, 0x83, 0xC7, 0x07, 0x0E,
  0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xEE,
  0x00, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xE0,
  0xF0, 0x39, 0xC1, 0xF0, 0x73, 0x83, 0xE0, 0xE7, 0x06, 0xC1, 0xC7, 0x1D,
  0x87, 0x0E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x38, 0xC6, 0x38, 0x3B, 0x8E,
  0xE0, 0x77, 0x1D, 0xC0, 0xEC, 0x3B, 0x81, 0xD8, 0x36, 0x01, 0xF0, 0x6C,
  0x03, 0xE0, 0xF8, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0xF0, 0x1E, 0xF0,
  0x78, 0xE0, 0xE0, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x3B, 0x80, 0x77, 0x81, 0xC7, 0x07, 0x8F, 0x0E,
  0x0F, 0x38, 0x0E, 0xF0, 0x1E, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0x8E, 0x1E,
  0x3C, 0x70, 0x73, 0x80, 0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFF, 0x80, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF,
  0x80, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xB0, 0x1B, 0x83, 0x18, 0x31, 0xC7,
  0x0C, 0x60, 0xEE, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0xF0, 0xE1, 0xC0,
  0x7F, 0x87, 0xFC, 0xC7, 0x80, 0x70, 0x0E, 0x3F, 0xDF, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0xC7, 0xBF, 0xB7, 0xE6, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0xF8, 0xFF, 0xCF, 0x9E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0x9E, 0xFF, 0xCC, 0xF8, 0x1F, 0xCF, 0xF7,
  0xCD, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0xCC, 0xFF,
  0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xF7, 0x3F,
  0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70,
  0x77, 0x8F, 0x3F, 0xF1, 0xF3, 0x1F, 0x83, 0xFE, 0x78, 0xE7, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x23, 0xFE, 0x1F,
  0xE0, 0x0F, 0xC7, 0xF1, 0xC0, 0x70, 0x1C, 0x1F, 0xEF, 0xF8, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x1F, 0x33, 0xFF, 0x79, 0xF7, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x74, 0x0F,
  0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1C, 0x71, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xB8, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE1, 0xCE, 0x38, 0xE7, 0x0E, 0xF0,
  0xFE, 0x0F, 0xE0, 0xF7, 0x0E, 0x78, 0xE3, 0x8E, 0x1C, 0xE1, 0xEE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0xCF, 0xDF, 0xFB, 0xFF,
  0xE7, 0xE7, 0xF0, 0x78, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F,
  0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E,
  0x0E, 0x0E, 0xCF, 0xCF, 0xFE, 0xF9, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x1F, 0xC1,
  0xFF, 0x1E, 0x3C, 0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x73, 0x83, 0x9E, 0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0xCF, 0x8F, 0xFC, 0xF9,
  0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xF9,
  0xEF, 0xFC, 0xEF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x1F, 0x73, 0xFF, 0x78, 0xF7, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x77, 0x07, 0x79, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xCF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0xDF, 0xEE, 0x0B, 0x80,
  0xF0, 0x1F, 0x83, 0xF8, 0x3E, 0x03, 0xC0, 0x7C, 0x3F, 0xFE, 0xFF, 0x00,
  0x18, 0x0C, 0x06, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xE4, 0x7E, 0x1F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xFF, 0xB7, 0xE6,
  0xE0, 0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x83,
  0xB8, 0x1D, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0xE0, 0xF0,
  0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x31, 0xB9, 0xC3, 0x99,
  0x9C, 0x3B, 0x99, 0xC3, 0xB9, 0xDC, 0x1B, 0x1F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0x7B, 0xC3, 0x8F, 0x38,
  0x3B, 0xC1, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0xC0, 0xEF, 0x0E,
  0x38, 0xF0, 0xEF, 0x07, 0x80, 0xE0, 0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE3,
  0x8E, 0x1C, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0x6E, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x7E, 0x03, 0xE0, 0x1C, 0x00,
  0xFF, 0xFF, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x0F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0xF8, 0xF0, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x0F, 0x1F, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xC0, 0x7C, 0x1F, 0xFF, 0x87,
  0xE0,
};

const GFXglyph NotoSans_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 7, 1, -17 },
  { 10, 7, 6, 11, 2, -17 },
  { 16, 14, 17, 16, 1, -17 },
  { 46, 12, 19, 14, 1, -18 },
  { 75, 19, 17, 21, 1, -17 },
  { 116, 17, 17, 18, 1, -17 },
  { 153, 3, 6, 6, 2, -17 },
  { 156, 6, 21, 8, 1, -17 },
  { 172, 6, 21, 8, 1, -17 },
  { 188, 11, 11, 13, 1, -18 },
  { 204, 12, 11, 14, 1, -14 },
  { 221, 4, 6, 7, 1, -3 },
  { 224, 6, 3, 8, 1, -8 },
  { 227, 4, 3, 7, 1, -3 },
  { 229, 9, 17, 10, 0, -17 },
  { 249, 12, 17, 14, 1, -17 },
  { 275, 7, 17, 14, 2, -17 },
  { 290, 12, 17, 14, 1, -17 },
  { 316, 12, 17, 14, 1, -17 },
  { 342, 13, 17, 14, 0, -17 },
  { 370, 12, 17, 14, 1, -17 },
  { 396, 12, 17, 14, 1, -17 },
  { 422, 12, 17, 14, 1, -17 },
  { 448, 12, 17, 14, 1, -17 },
  { 474, 12, 17, 14, 1, -17 },
  { 500, 4, 13, 7, 1, -13 },
  { 507, 4, 16, 7, 1, -13 },
  { 515, 12, 12, 14, 1, -15 },
  { 533, 12, 7, 14, 1, -12 },
  { 544, 12, 12, 14, 1, -15 },
  { 562, 11, 17, 11, 0, -17 },
  { 586, 19, 19, 22, 1, -17 },
  { 632, 16, 17, 16, 0, -17 },
  { 666, 13, 17, 16, 2, -17 },
  { 694, 14, 17, 15, 1, -17 },
  { 724, 14, 17, 18, 2, -17 },
  { 754, 10, 17, 13, 2, -17 },
  { 776, 10, 17, 13, 2, -17 },
  { 798, 15, 17, 17, 1, -17 },
  { 830, 14, 17, 18, 2, -17 },
  { 860, 7, 17, 9, 1, -17 },
  { 875, 7, 22, 7, -2, -17 },
  { 895, 14, 17, 16, 2, -17 },
  { 925, 10, 17, 13, 2, -17 },
  { 947, 18, 17, 22, 2, -17 },
  { 986, 15, 17, 19, 2, -17 },
  { 1018, 17, 17, 19, 1, -17 },
  { 1055, 12, 17, 15, 2, -17 },
  { 1081, 17, 21, 19, 1, -17 },
  { 1126, 13, 17, 15, 2, -17 },
  { 1154, 11, 17, 13, 1, -17 },
  { 1178, 13, 17, 14, 0, -17 },
  { 1206, 14, 17, 18, 2, -17 },
  { 1236, 15, 17, 15, 0, -17 },
  { 1268, 23, 17, 23, 0, -17 },
  { 1317, 15, 17, 15, 0, -17 },
  { 1349, 14, 17, 14, 0, -17 },
  { 1379, 12, 17, 14, 1, -17 },
  { 1405, 5, 21, 8, 2, -17 },
  { 1419, 9, 17, 10, 0, -17 },
  { 1439, 5, 21, 8, 1, -17 },
  { 1453, 12, 11, 14, 1, -17 },
  { 1470, 10, 2, 10, 0, 2 },
  { 1473, 6, 3, 8, 1, -18 },
  { 1476, 11, 13, 14, 1, -13 },
  { 1494, 12, 18, 15, 2, -18 },
  { 1521, 10, 13, 12, 1, -13 },
  { 1538, 12, 18, 15, 1, -18 },
  { 1565, 12, 13, 14, 1, -13 },
  { 1585, 10, 18, 9, 0, -18 },
  { 1608, 12, 19, 15, 1, -13 },
  { 1637, 12, 18, 15, 2, -18 },
  { 1664, 3, 18, 7, 2, -18 },
  { 1671, 6, 24, 7, -1, -18 },
  { 1689, 12, 18, 14, 2, -18 },
  { 1716, 3, 18, 7, 2, -18 },
  { 1723, 19, 13, 23, 2, -13 },
  { 1754, 12, 13, 15, 2, -13 },
  { 1774, 13, 13, 15, 1, -13 },
  { 1796, 12, 19, 15, 2, -13 },
  { 1825, 12, 19, 15, 1, -13 },
  { 1854, 8, 13, 10, 2, -13 },
  { 1867, 10, 13, 12, 1, -13 },
  { 1884, 9, 16, 10, 0, -16 },
  { 1902, 11, 13, 15, 2, -13 },
  { 1920, 13, 13, 13, 0, -13 },
  { 1942, 20, 13, 20, 0, -13 },
  { 1975, 13, 13, 13, 0, -13 },
  { 1997, 13, 19, 13, 0, -13 },
  { 2028, 10, 13, 12, 1, -13 },
  { 2045, 8, 21, 9, 0, -17 },
  { 2066, 3, 24, 13, 5, -18 },
  { 2075, 8, 21, 9, 1, -17 },
  { 2096, 12, 3, 14, 1, -10 },
};

const GFXfont NotoSans_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMIBOLD24PT7B_H_
