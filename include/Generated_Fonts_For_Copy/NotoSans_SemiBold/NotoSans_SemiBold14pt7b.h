#ifndef _NOTOSANS_SEMIBOLD14PT7B_H_
#define _NOTOSANS_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDD, 0x99, 0x1B, 0x09, 0x04, 0x8F, 0xF1, 0x61,
  0xB3, 0xFC, 0x48, 0x24, 0x36, 0x00, 0x10, 0x4F, 0xF4, 0xD3, 0xC3, 0xC7,
  0x9F, 0xF1, 0x04, 0xE1, 0x96, 0x62, 0x48, 0x4B, 0x0B, 0x5D, 0xDE, 0xC2,
  0xD8, 0x9B, 0x33, 0x64, 0x38, 0x78, 0x26, 0x13, 0x0F, 0x03, 0x07, 0xCF,
  0x3D, 0x8E, 0xCF, 0x3E, 0xC0, 0xFA, 0x6B, 0x49, 0x24, 0x99, 0x30, 0xC6,
  0x23, 0x33, 0x33, 0x32, 0x6C, 0x18, 0x31, 0x4F, 0xF3, 0x8D, 0x89, 0x00,
  0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0x60, 0xFF, 0xF0, 0x08, 0xC6, 0x23,
  0x11, 0x8C, 0x46, 0x00, 0x7B, 0x3C, 0xE1, 0x86, 0x18, 0x73, 0xCD, 0xE0,
  0x37, 0xD1, 0x11, 0x11, 0x11, 0x7B, 0x30, 0xC3, 0x0C, 0x63, 0x18, 0xFF,
  0xF0, 0xFB, 0x30, 0xC3, 0x79, 0xF0, 0xC3, 0x8F, 0xE0, 0x0C, 0x0C, 0x1C,
  0x34, 0x24, 0x44, 0xFF, 0xFF, 0x04, 0x04, 0xFF, 0xFC, 0x30, 0xF8, 0x30,
  0xC3, 0x9F, 0xE0, 0x3D, 0x8C, 0x20, 0xBF, 0x38, 0x71, 0xCD, 0xE0, 0xFF,
  0xFC, 0x18, 0x20, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x7B, 0x3C, 0xF3, 0x7B,
  0xEC, 0xE1, 0xCD, 0xE0, 0x7B, 0x38, 0xE1, 0xCF, 0xD0, 0x43, 0x1B, 0xC0,
  0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x04, 0x33, 0xB8, 0xE0, 0xE0, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x0D, 0xCC, 0x20, 0xF9, 0x30, 0xC3,
  0x18, 0xC2, 0x00, 0x30, 0xC0, 0x1F, 0x06, 0x19, 0x01, 0x6F, 0xB9, 0x33,
  0x66, 0x64, 0xDC, 0xFE, 0xC0, 0x0C, 0x10, 0xFC, 0x00, 0x1C, 0x0E, 0x05,
  0x86, 0xC3, 0x21, 0x19, 0xFC, 0xC2, 0x41, 0xE0, 0xC0, 0xFC, 0xCE, 0xC6,
  0xC6, 0xFC, 0xFE, 0xC2, 0xC3, 0xCE, 0xFC, 0x3F, 0x72, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x72, 0x3E, 0xFC, 0xFE, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3,
  0xC3, 0xFE, 0xFC, 0xFF, 0xFC, 0x30, 0xFF, 0xFC, 0x30, 0xFF, 0xF0, 0xFF,
  0xFC, 0x30, 0xFF, 0xFC, 0x30, 0xC3, 0x00, 0x3F, 0x73, 0xC0, 0xC0, 0xC0,
  0xCF, 0xC3, 0xC3, 0x73, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC3, 0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC,
  0xCC, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0,
  0xFC, 0x1F, 0xC7, 0xF8, 0xBD, 0x17, 0xB6, 0xF6, 0x9E, 0x53, 0xCE, 0x79,
  0x8C, 0xE1, 0xF0, 0xFC, 0x7B, 0x3D, 0x9E, 0x6F, 0x37, 0x8F, 0xC3, 0xE1,
  0xC0, 0x3E, 0x3B, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x77, 0x1F,
  0x00, 0xFD, 0xFF, 0x1E, 0x3C, 0xFF, 0xB0, 0x60, 0xC1, 0x80, 0x3E, 0x3B,
  0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x77, 0x1F, 0x01, 0x80, 0x70,
  0xFC, 0xCE, 0xC6, 0xC6, 0xCE, 0xF8, 0xCC, 0xCC, 0xC6, 0xC3, 0x7F, 0x3C,
  0x30, 0x70, 0xE0, 0xC3, 0x8F, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x67, 0x3E, 0xC1, 0xA0, 0x98, 0xCC, 0x62, 0x21, 0xB0, 0xD8, 0x28, 0x1C,
  0x0E, 0x00, 0xC3, 0x1E, 0x38, 0xD1, 0xC6, 0xCA, 0x26, 0x5B, 0x36, 0xD8,
  0xB2, 0xC7, 0x1C, 0x38, 0xE0, 0xC3, 0x00, 0xE3, 0xB1, 0x8D, 0x82, 0x81,
  0xC0, 0xE0, 0xD8, 0x6C, 0x63, 0x61, 0xC0, 0xC3, 0x63, 0x66, 0x36, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x7F, 0x7E, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0x7F, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC2, 0x18, 0xC2, 0x18,
  0x43, 0x18, 0x40, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x18, 0x18, 0x3C,
  0x24, 0x66, 0xC3, 0xFC, 0xC8, 0x80, 0x3B, 0xF0, 0xCF, 0xEE, 0x3C, 0xFD,
  0xC1, 0x83, 0x06, 0xCF, 0xD8, 0xF1, 0xE3, 0xC7, 0xDF, 0xF0, 0x3D, 0xEC,
  0x30, 0xC3, 0x0E, 0x9E, 0x06, 0x0C, 0x19, 0xBF, 0xF8, 0xF1, 0xE3, 0xC7,
  0x9D, 0xD8, 0x39, 0xFB, 0x17, 0xFF, 0xF8, 0x31, 0x3E, 0x1C, 0xE6, 0x1E,
  0xF9, 0x86, 0x18, 0x61, 0x86, 0x00, 0x37, 0xFF, 0x1E, 0x3C, 0x78, 0xF3,
  0xBB, 0x07, 0x1B, 0xF0, 0xC1, 0x83, 0x06, 0xCF, 0xF8, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0xB3, 0xFF, 0xFC, 0x23, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3E,
  0xC1, 0x83, 0x06, 0x3C, 0xDB, 0x3C, 0x7C, 0xD9, 0x9B, 0x18, 0xFF, 0xFF,
  0xFC, 0xD8, 0xDF, 0xFF, 0x18, 0xE3, 0x1C, 0x63, 0x8C, 0x71, 0x8E, 0x31,
  0x99, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x39, 0xFB, 0x1E, 0x3C, 0x78,
  0xF3, 0x3E, 0xD9, 0xFB, 0x1E, 0x3C, 0x78, 0xFB, 0xFE, 0xC1, 0x83, 0x00,
  0x37, 0xFF, 0x1E, 0x3C, 0x78, 0xF3, 0xBB, 0x06, 0x0C, 0x18, 0x9F, 0xF1,
  0x8C, 0x63, 0x18, 0x77, 0xE1, 0xC7, 0x8E, 0x7F, 0x23, 0xFE, 0xC6, 0x31,
  0x8C, 0x38, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xBF, 0xC3, 0xC6, 0x66,
  0x64, 0x2C, 0x3C, 0x38, 0x18, 0xC6, 0x38, 0xCD, 0x39, 0xB5, 0xB6, 0xB4,
  0x73, 0x8E, 0x71, 0x8C, 0xC3, 0x66, 0x3C, 0x38, 0x18, 0x3C, 0x66, 0xC7,
  0xC3, 0xC6, 0x66, 0x66, 0x2C, 0x3C, 0x38, 0x18, 0x18, 0x30, 0xF0, 0x7D,
  0xF0, 0xC6, 0x31, 0x86, 0x3F, 0x19, 0x8C, 0x63, 0x73, 0x86, 0x31, 0x8C,
  0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xCC, 0x44, 0x47, 0x76, 0x44, 0x4C, 0xE6,
  0xF0,
};

const GFXglyph NotoSans_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 9, 10, 9, 0, -10 },
  { 18, 6, 12, 8, 1, -11 },
  { 27, 11, 10, 12, 1, -10 },
  { 41, 9, 10, 10, 1, -10 },
  { 53, 2, 4, 4, 1, -10 },
  { 54, 3, 12, 5, 1, -10 },
  { 59, 4, 12, 5, 0, -10 },
  { 65, 7, 7, 8, 0, -11 },
  { 72, 6, 6, 8, 1, -8 },
  { 77, 3, 4, 4, 0, -2 },
  { 79, 4, 2, 4, 0, -5 },
  { 80, 2, 2, 4, 1, -2 },
  { 81, 5, 10, 6, 0, -10 },
  { 88, 6, 10, 8, 1, -10 },
  { 96, 4, 10, 8, 1, -10 },
  { 101, 6, 10, 8, 1, -10 },
  { 109, 6, 10, 8, 1, -10 },
  { 117, 8, 10, 8, 0, -10 },
  { 127, 6, 10, 8, 1, -10 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 7, 10, 8, 0, -10 },
  { 152, 6, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 1, -10 },
  { 168, 2, 8, 4, 1, -8 },
  { 170, 3, 10, 4, 0, -8 },
  { 174, 6, 8, 8, 1, -9 },
  { 180, 6, 4, 8, 1, -7 },
  { 183, 6, 8, 8, 1, -9 },
  { 189, 6, 10, 6, 0, -10 },
  { 197, 11, 11, 13, 1, -10 },
  { 213, 9, 10, 9, 0, -10 },
  { 225, 8, 10, 9, 1, -10 },
  { 235, 8, 10, 9, 1, -10 },
  { 245, 8, 10, 10, 1, -10 },
  { 255, 6, 10, 8, 1, -10 },
  { 263, 6, 10, 8, 1, -10 },
  { 271, 8, 10, 10, 1, -10 },
  { 281, 8, 10, 11, 1, -10 },
  { 291, 5, 10, 5, 0, -10 },
  { 298, 4, 13, 4, -1, -10 },
  { 305, 8, 10, 9, 1, -10 },
  { 315, 6, 10, 8, 1, -10 },
  { 323, 11, 10, 13, 1, -10 },
  { 337, 9, 10, 11, 1, -10 },
  { 349, 9, 10, 11, 1, -10 },
  { 361, 7, 10, 9, 1, -10 },
  { 370, 9, 12, 11, 1, -10 },
  { 384, 8, 10, 9, 1, -10 },
  { 394, 6, 10, 8, 1, -10 },
  { 402, 8, 10, 8, 0, -10 },
  { 412, 8, 10, 10, 1, -10 },
  { 422, 9, 10, 9, 0, -10 },
  { 434, 13, 10, 13, 0, -10 },
  { 451, 9, 10, 9, 0, -10 },
  { 463, 8, 10, 8, 0, -10 },
  { 473, 8, 10, 8, 0, -10 },
  { 483, 3, 12, 5, 1, -10 },
  { 488, 5, 10, 6, 0, -10 },
  { 495, 4, 12, 5, 0, -10 },
  { 501, 8, 6, 8, 0, -10 },
  { 507, 6, 1, 6, 0, 1 },
  { 508, 3, 3, 5, 1, -11 },
  { 510, 6, 8, 8, 1, -8 },
  { 516, 7, 11, 9, 1, -11 },
  { 526, 6, 8, 7, 1, -8 },
  { 532, 7, 11, 9, 1, -11 },
  { 542, 7, 8, 8, 1, -8 },
  { 549, 6, 11, 5, 0, -11 },
  { 558, 7, 11, 9, 1, -8 },
  { 568, 7, 11, 9, 1, -11 },
  { 578, 2, 11, 4, 1, -11 },
  { 581, 4, 14, 4, -1, -11 },
  { 588, 7, 11, 8, 1, -11 },
  { 598, 2, 11, 4, 1, -11 },
  { 601, 11, 8, 13, 1, -8 },
  { 612, 7, 8, 9, 1, -8 },
  { 619, 7, 8, 9, 1, -8 },
  { 626, 7, 11, 9, 1, -8 },
  { 636, 7, 11, 9, 1, -8 },
  { 646, 5, 8, 6, 1, -8 },
  { 651, 5, 8, 7, 1, -8 },
  { 656, 5, 9, 6, 0, -9 },
  { 662, 7, 8, 9, 1, -8 },
  { 669, 8, 8, 8, 0, -8 },
  { 677, 11, 8, 12, 0, -8 },
  { 688, 8, 8, 8, 0, -8 },
  { 696, 8, 11, 8, 0, -8 },
  { 707, 6, 8, 7, 0, -8 },
  { 713, 5, 12, 5, 0, -10 },
  { 721, 2, 14, 8, 3, -11 },
  { 725, 4, 12, 5, 1, -10 },
  { 731, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMIBOLD14PT7B_H_
