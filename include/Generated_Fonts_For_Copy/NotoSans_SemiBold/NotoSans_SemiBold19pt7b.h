#ifndef _NOTOSANS_SEMIBOLD19PT7B_H_
#define _NOTOSANS_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x6C, 0x2F, 0xC0, 0xEF, 0x3C, 0xF3, 0x4C, 0x04,
  0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98, 0xFF,
  0xEF, 0xFE, 0x11, 0x03, 0x30, 0x33, 0x03, 0x30, 0x08, 0x1F, 0x9F, 0xFD,
  0x2C, 0x87, 0x41, 0xF0, 0x7E, 0x0F, 0x84, 0xE2, 0xFF, 0xFF, 0xE0, 0x40,
  0x20, 0x70, 0x31, 0xF0, 0xC3, 0x31, 0x86, 0x66, 0x0C, 0xCC, 0x19, 0xB0,
  0x33, 0x6F, 0x7D, 0xB7, 0x33, 0x66, 0x0C, 0xCC, 0x31, 0x98, 0x63, 0x31,
  0x86, 0xC3, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x1C, 0xC0, 0xC6, 0x07, 0x30,
  0x1F, 0x80, 0x70, 0x0F, 0x86, 0xEE, 0x76, 0x1B, 0x30, 0x79, 0xC3, 0xCF,
  0xFF, 0x1F, 0x9C, 0xFB, 0x64, 0x39, 0x98, 0xCE, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x31, 0x8E, 0x38, 0xCC, 0x66, 0x33, 0x33, 0x33, 0x33, 0x37, 0x66,
  0xC0, 0x18, 0x0C, 0x26, 0x5F, 0xF1, 0x81, 0xE1, 0xD8, 0xCE, 0x08, 0x04,
  0x02, 0x1F, 0xFF, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0xFF, 0x60, 0xFF,
  0x5F, 0x80, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0xC3,
  0x06, 0x1C, 0x00, 0x1C, 0x3F, 0x99, 0xDC, 0x7C, 0x3E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0xFC, 0x67, 0xF1, 0xF0, 0x0C, 0x73, 0xFF, 0x4C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x1C, 0x3F, 0xB9, 0xC8, 0x70, 0x38,
  0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0xFF, 0xFC, 0x3C, 0x7F,
  0xB1, 0xC0, 0x70, 0x30, 0x38, 0xF8, 0x7E, 0x03, 0x81, 0xC0, 0xF0, 0x7F,
  0xF7, 0xF0, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xC0, 0xF8, 0x37, 0x0C, 0xE1,
  0x9C, 0x63, 0x9F, 0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x3F,
  0x9F, 0xCC, 0x06, 0x07, 0x43, 0xFC, 0xDE, 0x03, 0x81, 0xC0, 0xF0, 0x7F,
  0xF7, 0xF0, 0x0F, 0x1F, 0x9C, 0x0C, 0x0E, 0x06, 0x73, 0xFD, 0xC7, 0xC1,
  0xE0, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0x80, 0x1C, 0x3F,
  0xB8, 0xFC, 0x7E, 0x3B, 0xB8, 0xF8, 0xFC, 0xE7, 0x60, 0xF0, 0x78, 0x3F,
  0xF3, 0xF0, 0x1C, 0x3F, 0x39, 0xD8, 0x7C, 0x1E, 0x0F, 0x8F, 0xFF, 0x7D,
  0x80, 0xC0, 0xC0, 0xE7, 0xE3, 0xE0, 0x5F, 0x80, 0x00, 0x5F, 0x80, 0x5F,
  0x80, 0x00, 0x1F, 0xEC, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x07, 0x01, 0xE0,
  0x3E, 0x03, 0x80, 0x40, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x3C, 0xF8, 0xE0, 0x40, 0x00, 0x3C, 0xFF,
  0x47, 0x03, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x18, 0x38, 0x38,
  0x03, 0xC0, 0x1F, 0xE0, 0xE0, 0x63, 0x80, 0x66, 0x3E, 0x78, 0xEC, 0xF3,
  0x19, 0xE6, 0x33, 0xCC, 0x67, 0x98, 0xCF, 0x3E, 0xF6, 0x39, 0xC6, 0x00,
  0x07, 0x02, 0x07, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1B,
  0x01, 0xD8, 0x0C, 0xE0, 0x63, 0x07, 0x18, 0x3F, 0xE1, 0xFF, 0x1C, 0x18,
  0xC0, 0xE6, 0x03, 0x70, 0x1C, 0xF8, 0x3F, 0xCC, 0x7B, 0x06, 0xC1, 0xB0,
  0xEF, 0xF3, 0xFC, 0xC3, 0xB0, 0x7C, 0x1F, 0x0E, 0xFF, 0xBF, 0x80, 0x07,
  0x83, 0xFC, 0xE3, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x23, 0xFC, 0x3F, 0x80, 0xF8, 0x1F, 0xE3, 0x1E, 0x60,
  0xEC, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0x61, 0xEF,
  0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83,
  0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x00, 0x07, 0x83, 0xFC, 0xF1, 0xB8, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x1F, 0xE3, 0xFC, 0x0D, 0x81, 0xB8, 0x33, 0xFE, 0x3F,
  0xC0, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0xFF, 0xDC, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xEF, 0xFC, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x67, 0xF7, 0x00, 0xC1, 0xF0, 0x6C, 0x33, 0x1C, 0xCE,
  0x37, 0x0F, 0x83, 0xF0, 0xEE, 0x33, 0x8C, 0x73, 0x0E, 0xC3, 0xB0, 0x70,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1B, 0xF8, 0x6F, 0x61,
  0xBD, 0x8C, 0xF7, 0x33, 0xCC, 0xCF, 0x36, 0x3C, 0xF8, 0xF1, 0xE3, 0xC7,
  0x0F, 0x1C, 0x30, 0xE0, 0x7C, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0xB8, 0xF3,
  0x1E, 0x73, 0xC7, 0x78, 0x6F, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xC0, 0x0F,
  0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0xF8, 0x7F,
  0xB3, 0xD8, 0x7C, 0x3E, 0x1F, 0x1D, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0xFE, 0x0F,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0xF8, 0x3F, 0xCC, 0x73, 0x0E, 0xC3,
  0xB0, 0xEC, 0x73, 0xF8, 0xFE, 0x31, 0x8C, 0x73, 0x0E, 0xC3, 0xB0, 0x70,
  0x1E, 0x3F, 0xB8, 0xDC, 0x0E, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0x01, 0xC0,
  0xF0, 0x6F, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0x70, 0xE7, 0xF8, 0x7E, 0x00, 0xE0, 0x7E, 0x07, 0x60,
  0x66, 0x0E, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x9C, 0x19, 0x81, 0x98, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0x60, 0xE0, 0xC0, 0xF8, 0x30, 0x76, 0x1E, 0x19,
  0x87, 0x86, 0x71, 0xE1, 0x9C, 0xFC, 0xE3, 0x33, 0x30, 0xCC, 0xCC, 0x33,
  0x33, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x03,
  0x80, 0xE0, 0x77, 0x0E, 0x30, 0xC3, 0x9C, 0x1D, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF8, 0x39, 0xC3, 0x0C, 0x70, 0xEE, 0x07, 0xE0, 0x6C,
  0x1D, 0xC3, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x70,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xF9,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xC0, 0xC1, 0x83,
  0x83, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x08, 0x0C, 0x07,
  0x06, 0x82, 0x63, 0x11, 0x8D, 0x82, 0xC1, 0x80, 0xFF, 0xE3, 0x0E, 0x7F,
  0x33, 0x80, 0xE0, 0x77, 0xFF, 0x1F, 0x0F, 0x87, 0xFF, 0xBE, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0x3E, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xFF, 0xB3, 0xC0, 0x3F, 0x7E, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0,
  0xE1, 0x7F, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x37, 0xFB, 0xBF, 0x87, 0xC3,
  0xC1, 0xE0, 0xF8, 0x7C, 0x37, 0xF9, 0xEC, 0x3F, 0x39, 0xF8, 0x7C, 0x3F,
  0xFE, 0x03, 0x81, 0xC0, 0x7F, 0x9F, 0xC0, 0x04, 0x1F, 0x3A, 0x30, 0x30,
  0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x7F, 0xBB,
  0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0x7F, 0x9E, 0xC0, 0x60, 0x36,
  0x7B, 0xF8, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBE, 0xEE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x39, 0xC0, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0xBF, 0x90, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x76, 0x73, 0x31, 0xB0,
  0xF8, 0x7E, 0x33, 0x19, 0xCC, 0x76, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xBE, 0xFB, 0xEF, 0xE1, 0xC7, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xFF, 0xBE, 0xEE,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x3F, 0x1C,
  0xEE, 0x1B, 0x87, 0xC1, 0xF0, 0x7E, 0x1F, 0x86, 0x7F, 0x8F, 0xC0, 0xFF,
  0xBE, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xFF, 0xBB, 0xCE,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x7F, 0xBB, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x87, 0xC3, 0x7F, 0x9E, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xCF,
  0xFF, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7E, 0xE6, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x07, 0xFE, 0xFC, 0x10, 0x60, 0xC7, 0xFF, 0xE6, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xF1, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0xCF, 0xB0, 0xE0, 0xD8, 0x76, 0x19, 0xC6,
  0x33, 0x8C, 0xC1, 0xB0, 0x78, 0x1E, 0x03, 0x80, 0xE3, 0x87, 0x63, 0xC6,
  0x63, 0xCE, 0x72, 0xCC, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x7C, 0x34, 0x78,
  0x1C, 0x38, 0x1C, 0x38, 0xF1, 0xCC, 0xE3, 0xB0, 0x7C, 0x0E, 0x07, 0x81,
  0xF0, 0xEE, 0x71, 0xB8, 0x70, 0xE0, 0xD8, 0x77, 0x18, 0xC6, 0x33, 0x8E,
  0xC1, 0xB0, 0x78, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x3E, 0x06, 0x00,
  0xFE, 0xFE, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0xE0, 0xFF, 0xFF, 0x02, 0x3C,
  0x70, 0xC1, 0x83, 0x06, 0x1C, 0xE1, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0x87, 0x0C, 0x30, 0xC3, 0x0C,
  0x1C, 0xF3, 0x0C, 0x30, 0xC7, 0x38, 0xC0, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 9, 1, -14 },
  { 11, 12, 14, 12, 0, -14 },
  { 32, 9, 15, 11, 1, -14 },
  { 49, 15, 14, 17, 1, -14 },
  { 76, 13, 14, 14, 1, -14 },
  { 99, 3, 5, 5, 1, -14 },
  { 101, 5, 17, 6, 1, -14 },
  { 112, 4, 17, 6, 1, -14 },
  { 121, 9, 8, 10, 1, -14 },
  { 130, 9, 9, 11, 1, -11 },
  { 141, 3, 4, 5, 1, -2 },
  { 143, 4, 2, 6, 1, -6 },
  { 144, 3, 3, 5, 1, -3 },
  { 146, 7, 14, 8, 0, -14 },
  { 159, 9, 14, 11, 1, -14 },
  { 175, 6, 14, 11, 1, -14 },
  { 186, 9, 14, 11, 1, -14 },
  { 202, 9, 14, 11, 1, -14 },
  { 218, 11, 14, 11, 0, -14 },
  { 238, 9, 14, 11, 1, -14 },
  { 254, 9, 14, 11, 1, -14 },
  { 270, 9, 14, 11, 1, -14 },
  { 286, 9, 14, 11, 1, -14 },
  { 302, 9, 14, 11, 1, -14 },
  { 318, 3, 11, 5, 1, -11 },
  { 323, 3, 13, 5, 1, -11 },
  { 328, 9, 10, 11, 1, -12 },
  { 340, 9, 5, 11, 1, -9 },
  { 346, 9, 10, 11, 1, -12 },
  { 358, 8, 14, 9, 0, -14 },
  { 372, 15, 16, 17, 1, -14 },
  { 402, 13, 14, 13, 0, -14 },
  { 425, 10, 14, 13, 2, -14 },
  { 443, 11, 14, 12, 1, -14 },
  { 463, 11, 14, 14, 2, -14 },
  { 483, 7, 14, 11, 2, -14 },
  { 496, 7, 14, 10, 2, -14 },
  { 509, 11, 14, 14, 1, -14 },
  { 529, 11, 14, 14, 2, -14 },
  { 549, 5, 14, 7, 1, -14 },
  { 558, 5, 18, 6, -1, -14 },
  { 570, 10, 14, 12, 2, -14 },
  { 588, 8, 14, 10, 2, -14 },
  { 602, 14, 14, 18, 2, -14 },
  { 627, 11, 14, 15, 2, -14 },
  { 647, 13, 14, 15, 1, -14 },
  { 670, 9, 14, 12, 2, -14 },
  { 686, 13, 17, 15, 1, -14 },
  { 714, 10, 14, 12, 2, -14 },
  { 732, 9, 14, 10, 1, -14 },
  { 748, 11, 14, 11, 0, -14 },
  { 768, 11, 14, 14, 2, -14 },
  { 788, 12, 14, 12, 0, -14 },
  { 809, 18, 14, 18, 0, -14 },
  { 841, 12, 14, 12, 0, -14 },
  { 862, 11, 14, 11, 0, -14 },
  { 882, 9, 14, 11, 1, -14 },
  { 898, 5, 17, 6, 1, -14 },
  { 909, 7, 14, 8, 0, -14 },
  { 922, 5, 17, 6, 0, -14 },
  { 933, 9, 9, 11, 1, -14 },
  { 944, 8, 1, 8, 0, 2 },
  { 945, 5, 3, 6, 1, -15 },
  { 947, 9, 10, 11, 1, -10 },
  { 959, 10, 14, 12, 1, -14 },
  { 977, 8, 10, 10, 1, -10 },
  { 987, 9, 14, 12, 1, -14 },
  { 1003, 9, 10, 11, 1, -10 },
  { 1015, 8, 15, 7, 0, -15 },
  { 1030, 9, 15, 12, 1, -10 },
  { 1047, 10, 14, 12, 1, -14 },
  { 1065, 3, 14, 5, 1, -14 },
  { 1071, 5, 19, 5, -1, -14 },
  { 1083, 9, 14, 11, 2, -14 },
  { 1099, 3, 14, 5, 1, -14 },
  { 1105, 16, 10, 18, 1, -10 },
  { 1125, 10, 10, 12, 1, -10 },
  { 1138, 10, 10, 12, 1, -10 },
  { 1151, 10, 15, 12, 1, -10 },
  { 1170, 9, 15, 12, 1, -10 },
  { 1187, 7, 10, 8, 1, -10 },
  { 1196, 8, 10, 9, 1, -10 },
  { 1206, 7, 13, 8, 0, -13 },
  { 1218, 10, 10, 12, 1, -10 },
  { 1231, 10, 10, 10, 0, -10 },
  { 1244, 16, 10, 16, 0, -10 },
  { 1264, 10, 10, 11, 0, -10 },
  { 1277, 10, 15, 10, 0, -10 },
  { 1296, 8, 10, 9, 1, -10 },
  { 1306, 7, 17, 7, 0, -14 },
  { 1321, 2, 18, 10, 4, -14 },
  { 1326, 6, 17, 7, 1, -14 },
  { 1339, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMIBOLD19PT7B_H_
