#ifndef _NOTOSANS_SEMIBOLD68PT7B_H_
#define _NOTOSANS_SEMIBOLD68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x8F, 0xFB, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0x83, 0xE0, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x03, 0xFD,
  0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x01, 0xFD, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07,
  0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0x0F, 0xE1, 0xFF, 0x0F,
  0x80, 0x60, 0xFF, 0x07, 0xC0, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x7F, 0xC1,
  0xF0, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x07, 0xFC,
  0x3E, 0x00, 0x03, 0xFF, 0x9F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xF1, 0xFF, 0x80, 0x00, 0xF8, 0x7F,
  0xE0, 0x00, 0x7C, 0x1F, 0xF0, 0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x0F, 0x83, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0xF8, 0x03, 0xE1,
  0xFF, 0x7F, 0xC1, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x87, 0xFF,
  0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0x8F, 0xE1,
  0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF1,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x1F, 0xC1, 0xFF,
  0xFE, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xFF, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x07, 0xFF, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xEF, 0xFC, 0x00,
  0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x20, 0x03, 0xF0, 0x00, 0x9F, 0x00, 0xF8, 0x07, 0xCF, 0xF0, 0x7C,
  0x1F, 0xE7, 0xFF, 0xBE, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C,
  0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xCF,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFD, 0xFE, 0x1F,
  0xF3, 0xF0, 0x7F, 0xC7, 0x01, 0xFF, 0x18, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0,
  0x07, 0xFE, 0x0F, 0x80, 0x01, 0xFF, 0x03, 0x80, 0x00, 0xFF, 0x81, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0x00, 0x07,
  0xFE, 0x0E, 0x00, 0x01, 0xFF, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFD, 0x00, 0x00, 0x07, 0xFE, 0xC0, 0x00, 0x07,
  0xFF, 0x7C, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xA0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x83, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x08, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x80, 0x00, 0x07, 0xFC, 0xC0, 0x00, 0x0F, 0xFC, 0xF8, 0x00,
  0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xE0, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF,
  0x07, 0xF9, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xBF, 0xFC, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xDF,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0xFF, 0xC3,
  0xF8, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x06, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xCF, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x7F, 0x1F, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFC, 0xFF, 0x07, 0xC0, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x7F,
  0xE3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFE, 0x1F, 0xF0, 0x7F, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xFE, 0x1E, 0x00, 0x0F, 0xF8, 0x60, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFF, 0xEF, 0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xFC, 0x03, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xBF, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xFB, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x0F, 0xDF, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xBF, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE,
  0x7E, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x03, 0xFE,
  0x07, 0xF1, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xF8,
  0x3F, 0xFC, 0x3F, 0x87, 0xF0, 0x0F, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0xE0,
  0x0F, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x1F, 0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0x40,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x03, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x07, 0xFF, 0xCF,
  0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xF0, 0x00, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0x80,
  0x01, 0xE0, 0x7F, 0xF0, 0x00, 0x02, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x7F, 0xFE, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x0F, 0xFF,
  0x00, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF3,
  0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0xFF, 0xBF,
  0x80, 0x00, 0x0F, 0xEF, 0xFF, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFF, 0xFE,
  0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xFF,
  0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xFF, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFF, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0x00,
  0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0,
  0x03, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE3, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xDF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFF,
  0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xC0, 0x03, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x10,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xC0, 0x00, 0x03, 0xFE,
  0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFE, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFE,
  0x03, 0x80, 0x07, 0xFE, 0x02, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF,
  0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0xFF,
  0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xE1, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x08, 0x7F, 0xF0, 0x01, 0xC3, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x30, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xC0,
  0x3F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF,
  0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x41, 0xFF, 0xC0, 0x00, 0x70, 0x7F, 0xFC,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x04, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x07,
  0xF0, 0x0F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xFF,
  0xBF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0x7C,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x86, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x40, 0x01, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x3F,
  0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x07,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xFB, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xFC,
  0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFB, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xFE, 0x03, 0xFC, 0x7F,
  0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x01, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF,
  0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xC1, 0xFC,
  0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xF0,
  0x7F, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0x3F,
  0xC0, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x18, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFE, 0xFE, 0x0F,
  0xFE, 0xFF, 0x1F, 0xFE, 0xFF, 0x3F, 0xFE, 0xFF, 0x7F, 0xFE, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFF, 0xDE, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC, 0x01, 0xF8, 0xFF,
  0x80, 0x03, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFE, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFE, 0x0E, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x1F, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xDF, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFE,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0x87, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFC,
  0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x00, 0x7F,
  0xC7, 0xF0, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x01, 0xF9, 0xFC, 0x00, 0x07, 0xFB, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xF7, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x9F, 0xFF,
  0x80, 0x00, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x40, 0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiBold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 11, 50, 19, 4, -49 },
  { 70, 22, 18, 31, 4, -49 },
  { 120, 40, 48, 44, 2, -48 },
  { 360, 33, 56, 39, 3, -52 },
  { 591, 54, 50, 60, 3, -49 },
  { 929, 47, 50, 51, 3, -49 },
  { 1223, 9, 18, 17, 4, -49 },
  { 1244, 17, 60, 22, 3, -49 },
  { 1372, 17, 60, 22, 2, -49 },
  { 1500, 33, 32, 37, 2, -52 },
  { 1632, 33, 33, 39, 3, -41 },
  { 1769, 12, 17, 19, 2, -8 },
  { 1795, 18, 7, 22, 2, -22 },
  { 1811, 11, 11, 19, 4, -10 },
  { 1827, 26, 49, 27, 1, -49 },
  { 1987, 33, 50, 39, 3, -49 },
  { 2194, 22, 49, 39, 5, -49 },
  { 2329, 33, 49, 39, 3, -49 },
  { 2532, 33, 50, 39, 3, -49 },
  { 2739, 37, 49, 39, 1, -49 },
  { 2966, 32, 50, 39, 4, -49 },
  { 3166, 33, 50, 39, 3, -49 },
  { 3373, 34, 49, 39, 2, -49 },
  { 3582, 33, 50, 39, 3, -49 },
  { 3789, 33, 50, 39, 3, -49 },
  { 3996, 11, 39, 19, 4, -38 },
  { 4050, 13, 47, 19, 2, -38 },
  { 4127, 33, 35, 39, 3, -42 },
  { 4272, 33, 20, 39, 3, -34 },
  { 4355, 33, 35, 39, 3, -42 },
  { 4500, 30, 50, 31, 0, -49 },
  { 4688, 55, 55, 61, 3, -49 },
  { 5067, 46, 49, 46, 0, -49 },
  { 5349, 35, 49, 45, 6, -49 },
  { 5564, 37, 50, 43, 4, -49 },
  { 5796, 40, 49, 50, 6, -49 },
  { 6041, 28, 49, 38, 6, -49 },
  { 6213, 28, 49, 37, 6, -49 },
  { 6385, 40, 50, 49, 4, -49 },
  { 6635, 39, 49, 51, 6, -49 },
  { 6874, 21, 49, 25, 2, -49 },
  { 7003, 20, 63, 21, -5, -49 },
  { 7161, 38, 49, 44, 6, -49 },
  { 7394, 29, 49, 37, 6, -49 },
  { 7572, 51, 49, 63, 6, -49 },
  { 7885, 42, 49, 54, 6, -49 },
  { 8143, 46, 50, 54, 4, -49 },
  { 8431, 33, 49, 42, 6, -49 },
  { 8634, 46, 61, 54, 4, -49 },
  { 8985, 37, 49, 44, 6, -49 },
  { 9212, 32, 50, 37, 3, -49 },
  { 9412, 37, 49, 39, 1, -49 },
  { 9639, 39, 50, 51, 6, -49 },
  { 9883, 43, 49, 43, 0, -49 },
  { 10147, 64, 49, 65, 0, -49 },
  { 10539, 43, 49, 43, 0, -49 },
  { 10803, 41, 49, 41, 0, -49 },
  { 11055, 35, 49, 39, 2, -49 },
  { 11270, 16, 60, 22, 5, -49 },
  { 11390, 27, 49, 27, 0, -49 },
  { 11556, 15, 60, 22, 2, -49 },
  { 11669, 35, 31, 39, 2, -49 },
  { 11805, 29, 5, 29, 0, 6 },
  { 11824, 17, 11, 23, 3, -52 },
  { 11848, 32, 39, 40, 3, -38 },
  { 12004, 34, 53, 43, 5, -52 },
  { 12230, 29, 39, 34, 3, -38 },
  { 12372, 34, 53, 43, 3, -52 },
  { 12598, 34, 39, 40, 3, -38 },
  { 12764, 27, 52, 25, 1, -52 },
  { 12940, 34, 54, 43, 3, -38 },
  { 13170, 33, 52, 43, 5, -52 },
  { 13385, 9, 51, 19, 5, -51 },
  { 13443, 18, 67, 19, -4, -51 },
  { 13594, 34, 52, 40, 6, -52 },
  { 13815, 9, 52, 19, 5, -52 },
  { 13874, 55, 38, 65, 5, -38 },
  { 14136, 33, 38, 43, 5, -38 },
  { 14293, 36, 39, 42, 3, -38 },
  { 14469, 34, 54, 43, 5, -38 },
  { 14699, 34, 54, 43, 3, -38 },
  { 14929, 24, 38, 30, 5, -38 },
  { 15043, 28, 39, 34, 3, -38 },
  { 15180, 25, 46, 28, 1, -45 },
  { 15324, 33, 38, 43, 5, -37 },
  { 15481, 37, 37, 37, 0, -37 },
  { 15653, 55, 37, 56, 1, -37 },
  { 15908, 36, 37, 38, 1, -37 },
  { 16075, 37, 53, 37, 0, -37 },
  { 16321, 29, 37, 33, 2, -37 },
  { 16456, 23, 60, 26, 1, -49 },
  { 16629, 7, 68, 37, 15, -52 },
  { 16689, 22, 60, 26, 3, -49 },
  { 16854, 33, 10, 39, 3, -29 },
};

const GFXfont NotoSans_SemiBold68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMIBOLD68PT7B_H_
