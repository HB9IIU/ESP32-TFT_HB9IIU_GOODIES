#ifndef _NOTOSANS_SEMIBOLD22PT7B_H_
#define _NOTOSANS_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x76, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF7, 0xE7, 0xE6, 0x66,
  0x66, 0x66, 0x66, 0x06, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x0E, 0x61,
  0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x0C, 0xC0, 0x33, 0x0F, 0xFF, 0xBF, 0xFE,
  0x19, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0x60, 0x04, 0x00, 0x80, 0x7E, 0x3F,
  0xEF, 0x5D, 0xC8, 0x39, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x02, 0x70,
  0x4F, 0x8B, 0xBF, 0xF3, 0xF8, 0x04, 0x00, 0x80, 0x38, 0x0C, 0x3E, 0x0C,
  0x33, 0x86, 0x18, 0xC6, 0x0C, 0x67, 0x06, 0x33, 0x03, 0x1B, 0x99, 0x9D,
  0xBE, 0x7D, 0xD9, 0x9C, 0xDC, 0xC0, 0xCE, 0x60, 0x67, 0x30, 0x63, 0x98,
  0x70, 0xCC, 0x30, 0x7E, 0x38, 0x1E, 0x1F, 0x00, 0x7F, 0x00, 0xE7, 0x03,
  0x8E, 0x07, 0x1C, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x01, 0x7F, 0x0C, 0xEF,
  0x3B, 0x8F, 0x77, 0x0F, 0xCE, 0x0F, 0x1E, 0x1F, 0x1F, 0xFF, 0x1F, 0xCF,
  0xFD, 0xB6, 0xC0, 0x19, 0xCC, 0xE6, 0x73, 0x9C, 0xC6, 0x31, 0x8E, 0x73,
  0x8C, 0x71, 0x8E, 0xC7, 0x1C, 0xE3, 0x1C, 0xE3, 0x18, 0xC6, 0x31, 0x9C,
  0xE6, 0x73, 0x38, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xFF, 0xFF, 0xF1, 0xE0,
  0xFC, 0x33, 0x1C, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF,
  0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x76, 0xEE, 0xCC, 0xFF,
  0xC0, 0x6F, 0x70, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0x1F, 0x07, 0xF1,
  0xCF, 0x30, 0xEE, 0x0D, 0xC1, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x6E, 0x1C, 0xE3, 0x8F, 0xE0, 0xF8, 0x0E, 0x3C, 0xFF, 0xFE, 0xF1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1F, 0x0F, 0xF3,
  0xCF, 0x20, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x3F, 0x1F, 0xF1, 0xCF, 0x20,
  0xE0, 0x1C, 0x03, 0x80, 0xE1, 0xF8, 0x3F, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x1D, 0x07, 0xBF, 0xE7, 0xF8, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x6C, 0x07,
  0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x31, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE7, 0xF9, 0x80, 0x60, 0x18,
  0x07, 0xF1, 0xFE, 0x67, 0xC0, 0x70, 0x0C, 0x03, 0x01, 0xF0, 0xFF, 0xFB,
  0xFC, 0x07, 0xC3, 0xF8, 0xF1, 0x38, 0x06, 0x01, 0xC0, 0x3B, 0xE7, 0xFE,
  0xF1, 0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE3, 0x8F, 0xF0, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x1F, 0x0F, 0xF1,
  0xC7, 0x70, 0xEE, 0x1C, 0xE3, 0x9F, 0xE0, 0xF8, 0x3F, 0x8E, 0x7B, 0x87,
  0x70, 0x7E, 0x0F, 0xC3, 0x9F, 0xF1, 0xFC, 0x1E, 0x0F, 0xF1, 0xCF, 0x70,
  0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x0F, 0x7F, 0xEF, 0xD8, 0x03, 0x00, 0xE0,
  0x1C, 0x07, 0x1F, 0xC3, 0xF0, 0x7F, 0x70, 0x00, 0x00, 0x06, 0xF7, 0x7F,
  0x70, 0x00, 0x00, 0x07, 0x6E, 0xEC, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0x80, 0x10,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x18, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x3E, 0x1F, 0x03, 0x80,
  0x40, 0x00, 0x3E, 0x3F, 0xE7, 0x38, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x3C,
  0x0E, 0x07, 0x01, 0x80, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x01, 0xF0,
  0x03, 0xFF, 0x01, 0xE0, 0xF0, 0xE0, 0x0C, 0x70, 0xE1, 0x98, 0xFE, 0x66,
  0x71, 0x9F, 0x18, 0x63, 0xC6, 0x18, 0xF3, 0x86, 0x7C, 0x63, 0x9B, 0x18,
  0xE6, 0xE3, 0xEF, 0x18, 0x61, 0x07, 0x00, 0x00, 0xF0, 0x30, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xEE,
  0x01, 0xDC, 0x07, 0x18, 0x0E, 0x38, 0x1C, 0x70, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC7, 0x01, 0x8E, 0x03, 0x9C, 0x07, 0x70, 0x07, 0xFE, 0x1F, 0xFB,
  0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFC, 0xFF, 0xDC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xFF, 0xF7, 0xFC, 0x07, 0xE1, 0xFF, 0x3E, 0xF7,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC3, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF9,
  0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xEE, 0x0F, 0x71, 0xF3, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x07, 0xF0, 0xFF,
  0xCF, 0xDE, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x3F, 0xE1, 0xFF,
  0x0F, 0xDC, 0x0E, 0xE0, 0x77, 0x83, 0x9E, 0x1C, 0x7F, 0xE1, 0xFF, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xFF, 0xF7, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0xF7, 0xC0, 0xE0, 0x7E, 0x0E, 0xE1, 0xCE,
  0x38, 0xE7, 0x8E, 0x70, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0x70, 0xE7, 0x8E,
  0x38, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xD8, 0x1F, 0xD8, 0x1B, 0xFC,
  0x1B, 0xEC, 0x3B, 0xEC, 0x33, 0xEE, 0x33, 0xE6, 0x73, 0xE6, 0x63, 0xE7,
  0x63, 0xE3, 0xE3, 0xE3, 0xC3, 0xE3, 0xC3, 0xE1, 0x83, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x3D, 0xC1, 0xE7, 0x0F, 0xB8, 0x7C, 0xE3, 0xE7, 0x1F,
  0x1C, 0xF8, 0x77, 0xC3, 0xBE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0x07,
  0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC0, 0xE7, 0x01, 0xEE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xC7,
  0x8F, 0x87, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F,
  0xC1, 0xF8, 0x77, 0x1E, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC0, 0xE7, 0x01,
  0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3B,
  0x80, 0xF7, 0x01, 0xC7, 0x8F, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x7C, 0xFF, 0x8F, 0xF0, 0xE3, 0x8E, 0x38, 0xE1,
  0xCE, 0x1C, 0xE0, 0xEE, 0x0F, 0x1F, 0x1F, 0xF7, 0xBB, 0x80, 0xE0, 0x38,
  0x07, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1C, 0x07, 0x01, 0xF0, 0xFF, 0xFB,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0x38, 0x79,
  0xFF, 0x83, 0xF8, 0xE0, 0x1F, 0x80, 0x67, 0x03, 0x9C, 0x0E, 0x70, 0x30,
  0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x1C, 0xE0, 0x73, 0x80, 0xCC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xD8, 0x3C, 0x0C, 0xE1, 0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x38, 0xC7,
  0x71, 0x87, 0x3B, 0x9C, 0x39, 0x8C, 0xE1, 0xCC, 0x66, 0x06, 0xE3, 0xB0,
  0x3E, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0,
  0x70, 0xF0, 0x3D, 0xC0, 0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0xE0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0x38, 0x38, 0x70,
  0xE1, 0xC7, 0x03, 0xB8, 0x0F, 0xE0, 0x3B, 0x81, 0xDC, 0x1C, 0x70, 0xE3,
  0x8E, 0x0E, 0x60, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFE, 0x0C,
  0x01, 0x80, 0x78, 0x0F, 0x03, 0x30, 0x66, 0x1C, 0x63, 0x0C, 0xE0, 0xD8,
  0x1C, 0xFF, 0x80, 0xE3, 0x8E, 0x30, 0x3F, 0x9F, 0xF2, 0x1C, 0x07, 0x01,
  0xCF, 0xF7, 0x9F, 0x87, 0xE1, 0xF8, 0x7F, 0xED, 0xF3, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x9E, 0x37, 0xE7, 0x8E, 0xE1, 0xDC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xBC, 0x77, 0xFC, 0xDF, 0x00, 0x1F, 0x9F, 0xDC,
  0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x5F, 0xE3, 0xF0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7D, 0xDF, 0xFB, 0x8F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xDC, 0x7B, 0xFF, 0x3E, 0x60, 0x1F,
  0x07, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E,
  0x08, 0xFF, 0x0F, 0xE0, 0x0F, 0x8F, 0xC7, 0x27, 0x03, 0x83, 0xFB, 0xFC,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00,
  0x3E, 0x6F, 0xFD, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xD0, 0x7B, 0xFE, 0x7F, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x33, 0xED, 0xFF, 0xC7, 0xE1, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xC0, 0x5F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x71, 0xC0, 0x00, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0xFB, 0xC0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xF8, 0xE7, 0x38, 0xEE, 0x1B, 0x83,
  0x70, 0x7F, 0x0E, 0xE1, 0xCE, 0x38, 0xE7, 0x0E, 0xE1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xCF, 0x9F, 0x7F, 0xDF, 0xFC, 0xF8, 0xFC,
  0x38, 0x3E, 0x1C, 0x1F, 0x0E, 0x0F, 0x87, 0x07, 0xC3, 0x83, 0xE1, 0xC1,
  0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x38, 0x30, 0xCF, 0xB7, 0xFF, 0x1F, 0x87,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x1F, 0x87,
  0xF9, 0xC7, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xEE, 0x3C,
  0xFF, 0x0F, 0xC0, 0xCF, 0x1B, 0xF3, 0xC7, 0x70, 0xEE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xDE, 0x3B, 0xFE, 0x6F, 0x8E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x00, 0x3E, 0x6F, 0xFD, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0xCF, 0xBF, 0xEF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x00, 0x3F, 0xBF, 0xB8, 0x5C, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x03,
  0xC1, 0xFF, 0xDF, 0xC0, 0x18, 0x18, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xE1, 0xF8, 0xFF, 0xFD, 0xFB, 0xE0, 0x76,
  0x06, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0xE0, 0xE1, 0xD8, 0x78, 0x77, 0x1E, 0x19, 0xC7,
  0xCE, 0x73, 0xB3, 0x8C, 0xCC, 0xC3, 0xB3, 0x30, 0xEC, 0xFC, 0x1F, 0x1F,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0xF0, 0xF7, 0x0E, 0x39, 0xC1,
  0xDC, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0xC3, 0x9C, 0x70, 0xEF,
  0x07, 0xE0, 0x76, 0x07, 0x70, 0xE7, 0x0E, 0x38, 0xC3, 0x9C, 0x19, 0xC1,
  0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1E, 0x07,
  0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x03, 0x0F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0xF0, 0xF8, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE1, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x38, 0x3C, 0x79, 0xC3, 0x06, 0x0C, 0x18, 0x31, 0xE3, 0xC0, 0xFC,
  0x7F, 0xFE, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 14, 16, 14, 0, -16 },
  { 43, 11, 18, 13, 1, -17 },
  { 68, 17, 16, 19, 1, -16 },
  { 102, 15, 16, 16, 1, -16 },
  { 132, 3, 6, 6, 1, -16 },
  { 135, 5, 19, 7, 1, -16 },
  { 147, 5, 19, 7, 1, -16 },
  { 159, 10, 10, 12, 1, -17 },
  { 172, 11, 11, 13, 1, -13 },
  { 188, 4, 6, 6, 1, -3 },
  { 191, 5, 2, 7, 1, -7 },
  { 193, 4, 3, 6, 1, -3 },
  { 195, 9, 16, 9, 0, -16 },
  { 213, 11, 16, 13, 1, -16 },
  { 235, 7, 16, 13, 2, -16 },
  { 249, 11, 16, 13, 1, -16 },
  { 271, 11, 16, 13, 1, -16 },
  { 293, 12, 16, 13, 0, -16 },
  { 317, 10, 16, 13, 1, -16 },
  { 337, 11, 16, 13, 1, -16 },
  { 359, 11, 16, 13, 1, -16 },
  { 381, 11, 16, 13, 1, -16 },
  { 403, 11, 16, 13, 1, -16 },
  { 425, 4, 12, 6, 1, -12 },
  { 431, 4, 15, 6, 1, -12 },
  { 439, 11, 12, 13, 1, -14 },
  { 456, 11, 6, 13, 1, -11 },
  { 465, 11, 12, 13, 1, -14 },
  { 482, 10, 16, 10, 0, -16 },
  { 502, 18, 18, 20, 1, -16 },
  { 543, 15, 16, 15, 0, -16 },
  { 573, 11, 16, 15, 2, -16 },
  { 595, 12, 16, 14, 1, -16 },
  { 619, 13, 16, 16, 2, -16 },
  { 645, 9, 16, 12, 2, -16 },
  { 663, 9, 16, 12, 2, -16 },
  { 681, 13, 16, 16, 1, -16 },
  { 707, 13, 16, 17, 2, -16 },
  { 733, 6, 16, 8, 1, -16 },
  { 745, 7, 20, 7, -2, -16 },
  { 763, 12, 16, 14, 2, -16 },
  { 787, 9, 16, 12, 2, -16 },
  { 805, 16, 16, 20, 2, -16 },
  { 837, 13, 16, 17, 2, -16 },
  { 863, 15, 16, 17, 1, -16 },
  { 893, 11, 16, 14, 2, -16 },
  { 915, 15, 20, 17, 1, -16 },
  { 953, 12, 16, 14, 2, -16 },
  { 977, 10, 16, 12, 1, -16 },
  { 997, 12, 16, 13, 0, -16 },
  { 1021, 13, 16, 16, 2, -16 },
  { 1047, 14, 16, 14, 0, -16 },
  { 1075, 21, 16, 21, 0, -16 },
  { 1117, 14, 16, 14, 0, -16 },
  { 1145, 13, 16, 13, 0, -16 },
  { 1171, 11, 16, 13, 1, -16 },
  { 1193, 5, 19, 7, 2, -16 },
  { 1205, 9, 16, 9, 0, -16 },
  { 1223, 5, 19, 7, 1, -16 },
  { 1235, 11, 10, 13, 1, -16 },
  { 1249, 9, 1, 9, 0, 2 },
  { 1251, 5, 4, 7, 1, -17 },
  { 1254, 10, 12, 13, 1, -12 },
  { 1269, 11, 17, 14, 2, -17 },
  { 1293, 9, 12, 11, 1, -12 },
  { 1307, 11, 17, 14, 1, -17 },
  { 1331, 11, 12, 13, 1, -12 },
  { 1348, 9, 17, 8, 0, -17 },
  { 1368, 11, 17, 14, 1, -12 },
  { 1392, 10, 17, 14, 2, -17 },
  { 1414, 3, 17, 6, 2, -17 },
  { 1421, 6, 22, 6, -1, -17 },
  { 1438, 11, 17, 13, 2, -17 },
  { 1462, 3, 17, 6, 2, -17 },
  { 1469, 17, 12, 21, 2, -12 },
  { 1495, 10, 12, 14, 2, -12 },
  { 1510, 11, 12, 14, 1, -12 },
  { 1527, 11, 17, 14, 2, -12 },
  { 1551, 11, 17, 14, 1, -12 },
  { 1575, 7, 12, 10, 2, -12 },
  { 1586, 9, 12, 11, 1, -12 },
  { 1600, 8, 15, 9, 0, -15 },
  { 1615, 10, 12, 14, 2, -12 },
  { 1630, 12, 12, 12, 0, -12 },
  { 1648, 18, 12, 18, 0, -12 },
  { 1675, 12, 12, 12, 0, -12 },
  { 1693, 12, 17, 12, 0, -12 },
  { 1719, 9, 12, 11, 1, -12 },
  { 1733, 8, 19, 9, 0, -16 },
  { 1752, 2, 22, 12, 5, -17 },
  { 1758, 7, 19, 9, 1, -16 },
  { 1775, 11, 3, 13, 1, -9 },
};

const GFXfont NotoSans_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMIBOLD22PT7B_H_
