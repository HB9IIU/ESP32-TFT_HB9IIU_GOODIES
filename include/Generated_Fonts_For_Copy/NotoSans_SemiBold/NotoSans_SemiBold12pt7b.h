#ifndef _NOTOSANS_SEMIBOLD12PT7B_H_
#define _NOTOSANS_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xA2, 0xC0, 0xBB, 0xBA, 0x14, 0x28, 0xD3, 0xF2, 0x45, 0xBF,
  0x94, 0x48, 0x27, 0xEB, 0x4F, 0x1C, 0xBF, 0x21, 0x00, 0x61, 0x14, 0xCD,
  0x23, 0x58, 0x55, 0xCA, 0x90, 0xA4, 0x4D, 0x31, 0x80, 0x30, 0xF8, 0xC8,
  0x50, 0x61, 0xF2, 0x9E, 0xCC, 0xFF, 0xF0, 0x32, 0x44, 0x4C, 0x44, 0x46,
  0x30, 0xC9, 0x92, 0x49, 0x2F, 0x00, 0x12, 0x5F, 0xCC, 0x68, 0x21, 0x3E,
  0x42, 0x10, 0x6B, 0x00, 0xE0, 0xB0, 0x18, 0x84, 0x62, 0x31, 0x08, 0xC0,
  0x39, 0xF4, 0x51, 0xC5, 0x14, 0x5B, 0x38, 0x37, 0xF3, 0x33, 0x33, 0x30,
  0x77, 0xC2, 0x31, 0x19, 0x98, 0xF8, 0x39, 0xF0, 0x43, 0x30, 0x30, 0x63,
  0xF8, 0x0C, 0x38, 0x71, 0x66, 0xC9, 0xBF, 0x86, 0x0C, 0xFF, 0xE1, 0x0F,
  0x8C, 0x33, 0xF0, 0x3B, 0xE1, 0x4F, 0xC6, 0x39, 0x70, 0xFF, 0xF0, 0xC2,
  0x08, 0x61, 0x0C, 0x60, 0x39, 0xB4, 0x5B, 0x39, 0xBC, 0x51, 0x7C, 0x31,
  0xF4, 0x71, 0x4D, 0xD0, 0x43, 0x78, 0xB0, 0x2C, 0x4C, 0x00, 0x52, 0x80,
  0x1B, 0xB1, 0xC3, 0x84, 0xF8, 0x3E, 0x83, 0x06, 0x7C, 0x40, 0x77, 0xC2,
  0x33, 0x10, 0x04, 0x60, 0x0C, 0x39, 0xB0, 0x73, 0xDA, 0x6D, 0x36, 0xDB,
  0x36, 0x42, 0x1F, 0x00, 0x18, 0x18, 0x3C, 0x34, 0x24, 0x7E, 0x7E, 0x42,
  0xC3, 0xF3, 0xFC, 0xF3, 0xFB, 0x3C, 0x73, 0xF8, 0x39, 0xFC, 0x20, 0x82,
  0x0C, 0x39, 0x7C, 0xF1, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE6, 0xF8, 0xFF,
  0xF1, 0x8F, 0xE3, 0x18, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC0, 0x1C,
  0xFF, 0x04, 0x08, 0xF1, 0xF1, 0xF3, 0x7E, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8,
  0xF1, 0xE3, 0xC6, 0xF7, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xE0, 0xC7, 0x9B, 0x67, 0x8F, 0x1A, 0x36, 0x66, 0xC6, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xF8, 0xC1, 0xF0, 0xE8, 0xB4, 0x5B, 0x6E, 0xA7, 0x53,
  0xB9, 0xC8, 0x80, 0xC3, 0xC6, 0x8D, 0x99, 0x3B, 0x73, 0xE3, 0xC6, 0x38,
  0x7E, 0xC2, 0x83, 0x83, 0x83, 0xC3, 0xC6, 0x7C, 0xF3, 0xEC, 0xF3, 0xDB,
  0xCC, 0x30, 0xC0, 0x38, 0x7E, 0xC2, 0x83, 0x83, 0x83, 0xC3, 0xC6, 0x7C,
  0x0C, 0x07, 0xF1, 0xF3, 0x36, 0x6F, 0x9E, 0x36, 0x66, 0xC6, 0x77, 0xE1,
  0x87, 0x1C, 0x33, 0xF0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7C, 0xC3, 0xC2, 0x46, 0x66,
  0x64, 0x2C, 0x38, 0x38, 0x18, 0xC4, 0x38, 0xC5, 0x39, 0xA5, 0x36, 0xB4,
  0xD2, 0x8E, 0x71, 0x8E, 0x31, 0x80, 0xC2, 0x66, 0x2C, 0x38, 0x18, 0x38,
  0x2C, 0x66, 0xC3, 0xC2, 0x8D, 0x91, 0x63, 0x82, 0x04, 0x08, 0x10, 0xFD,
  0xF8, 0x30, 0xC1, 0x06, 0x18, 0x20, 0xFE, 0xFE, 0x49, 0x24, 0x93, 0x80,
  0xC6, 0x10, 0xC2, 0x10, 0xC2, 0x18, 0xFC, 0x92, 0x49, 0x27, 0x80, 0x10,
  0x60, 0xA3, 0x44, 0x58, 0xC0, 0xF8, 0xE3, 0x39, 0xF0, 0x5F, 0x47, 0x37,
  0x40, 0x82, 0x09, 0x3E, 0xCE, 0x3C, 0xF3, 0xB8, 0x3F, 0xA1, 0x08, 0x65,
  0xE0, 0x0C, 0x36, 0xFF, 0x8E, 0x38, 0xF3, 0x7C, 0x37, 0xE3, 0xF8, 0x65,
  0xE0, 0x3B, 0x1D, 0xE6, 0x31, 0x8C, 0x60, 0x6F, 0xF8, 0xE3, 0x8F, 0x37,
  0xC3, 0x9B, 0xC0, 0x82, 0x09, 0x3F, 0xCE, 0x38, 0xE3, 0x8C, 0xEA, 0xAA,
  0x80, 0x32, 0x22, 0x22, 0x22, 0x22, 0x2E, 0x82, 0x08, 0xE6, 0xB3, 0x8F,
  0x26, 0x8C, 0xFF, 0x80, 0xB1, 0x3F, 0xEC, 0xCE, 0x33, 0x8C, 0xE3, 0x38,
  0xCC, 0x93, 0xFC, 0xE3, 0x8E, 0x38, 0xC0, 0x33, 0xE8, 0xE3, 0x8F, 0x27,
  0x80, 0x93, 0xEC, 0xE3, 0xCF, 0x3B, 0xA0, 0x82, 0x00, 0x6F, 0xF8, 0xE3,
  0x8F, 0x37, 0xC3, 0x0C, 0x30, 0x9F, 0xC8, 0x88, 0x80, 0x6F, 0x8E, 0x39,
  0xF0, 0x23, 0xBC, 0xC6, 0x31, 0x87, 0x8E, 0x38, 0xE3, 0x8F, 0x3F, 0xC0,
  0xC7, 0x89, 0x33, 0x42, 0x87, 0x0C, 0x00, 0xCC, 0xF3, 0x34, 0xC9, 0x7A,
  0x73, 0x8C, 0xC3, 0x30, 0xC4, 0xD8, 0xE1, 0x83, 0x8D, 0xB1, 0x80, 0xC7,
  0x89, 0x33, 0x42, 0x87, 0x0C, 0x18, 0x21, 0xC0, 0x7B, 0xC6, 0x62, 0x23,
  0xE0, 0x13, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF, 0xF0, 0x8E, 0x22, 0x23,
  0x22, 0x26, 0xC0, 0xEC, 0xC0,
};

const GFXglyph NotoSans_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 5, 1, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 5, 10, 7, 1, -9 },
  { 21, 10, 9, 11, 0, -9 },
  { 33, 8, 9, 9, 1, -9 },
  { 42, 1, 4, 3, 1, -9 },
  { 43, 4, 11, 4, 0, -9 },
  { 49, 3, 11, 4, 0, -9 },
  { 54, 6, 5, 7, 0, -9 },
  { 58, 5, 6, 7, 1, -7 },
  { 62, 3, 3, 3, 0, -1 },
  { 64, 3, 1, 4, 0, -4 },
  { 65, 2, 2, 3, 1, -2 },
  { 66, 5, 9, 5, 0, -9 },
  { 72, 6, 9, 7, 0, -9 },
  { 79, 4, 9, 7, 1, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 6, 9, 7, 0, -9 },
  { 97, 7, 9, 7, 0, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 6, 9, 7, 0, -9 },
  { 124, 6, 9, 7, 0, -9 },
  { 131, 6, 9, 7, 0, -9 },
  { 138, 2, 7, 3, 1, -7 },
  { 140, 3, 9, 3, 0, -7 },
  { 144, 5, 6, 7, 1, -7 },
  { 148, 5, 3, 7, 1, -6 },
  { 150, 5, 6, 7, 1, -7 },
  { 154, 5, 9, 6, 0, -9 },
  { 160, 9, 10, 11, 1, -9 },
  { 172, 8, 9, 8, 0, -9 },
  { 181, 6, 9, 8, 1, -9 },
  { 188, 6, 9, 8, 1, -9 },
  { 195, 7, 9, 9, 1, -9 },
  { 203, 5, 9, 7, 1, -9 },
  { 209, 5, 9, 6, 1, -9 },
  { 215, 7, 9, 9, 1, -9 },
  { 223, 7, 9, 9, 1, -9 },
  { 231, 4, 9, 4, 0, -9 },
  { 236, 4, 11, 4, -1, -9 },
  { 242, 7, 9, 8, 1, -9 },
  { 250, 5, 9, 7, 1, -9 },
  { 256, 9, 9, 11, 1, -9 },
  { 267, 7, 9, 10, 1, -9 },
  { 275, 8, 9, 9, 1, -9 },
  { 284, 6, 9, 7, 1, -9 },
  { 291, 8, 11, 9, 1, -9 },
  { 302, 7, 9, 8, 1, -9 },
  { 310, 5, 9, 7, 1, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 7, 9, 9, 1, -9 },
  { 332, 8, 9, 8, 0, -9 },
  { 341, 11, 9, 11, 0, -9 },
  { 354, 8, 9, 8, 0, -9 },
  { 363, 7, 9, 7, 0, -9 },
  { 371, 7, 9, 7, 0, -9 },
  { 379, 3, 11, 4, 1, -9 },
  { 384, 5, 9, 5, 0, -9 },
  { 390, 3, 11, 4, 0, -9 },
  { 395, 7, 6, 7, 0, -9 },
  { 401, 5, 1, 5, 0, 1 },
  { 402, 4, 2, 4, 0, -9 },
  { 403, 6, 7, 7, 0, -7 },
  { 409, 6, 9, 8, 1, -9 },
  { 416, 5, 7, 6, 1, -7 },
  { 421, 6, 9, 8, 1, -9 },
  { 428, 5, 7, 7, 1, -7 },
  { 433, 5, 9, 4, 0, -9 },
  { 439, 6, 10, 8, 1, -7 },
  { 447, 6, 9, 8, 1, -9 },
  { 454, 2, 9, 3, 1, -9 },
  { 457, 4, 12, 3, -1, -9 },
  { 463, 6, 9, 7, 1, -9 },
  { 470, 1, 9, 3, 1, -9 },
  { 472, 10, 7, 12, 1, -7 },
  { 481, 6, 7, 8, 1, -7 },
  { 487, 6, 7, 7, 1, -7 },
  { 493, 6, 10, 8, 1, -7 },
  { 501, 6, 10, 8, 1, -7 },
  { 509, 4, 7, 5, 1, -7 },
  { 513, 4, 7, 6, 1, -7 },
  { 517, 5, 8, 5, 0, -8 },
  { 522, 6, 7, 8, 1, -7 },
  { 528, 7, 7, 7, 0, -7 },
  { 535, 10, 7, 10, 0, -7 },
  { 544, 7, 7, 7, 0, -7 },
  { 551, 7, 10, 7, 0, -7 },
  { 560, 5, 7, 6, 0, -7 },
  { 565, 4, 11, 5, 0, -9 },
  { 571, 1, 12, 7, 3, -9 },
  { 573, 4, 11, 5, 0, -9 },
  { 579, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMIBOLD12PT7B_H_
