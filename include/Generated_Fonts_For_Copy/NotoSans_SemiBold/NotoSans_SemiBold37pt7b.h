#ifndef _NOTOSANS_SEMIBOLD37PT7B_H_
#define _NOTOSANS_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0x8F,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xF0, 0x00,
  0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1C, 0x00, 0x70, 0x70, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x83, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00,
  0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xE7, 0x0C, 0xF9, 0xC0, 0x3C, 0x70, 0x0F, 0x9C, 0x03,
  0xF7, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1C, 0xF8, 0x07, 0x1F, 0x01, 0xC7, 0xB0, 0x73,
  0xEF, 0xDF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x3C, 0x03, 0xFE, 0x00, 0xE0, 0x1F, 0x78, 0x07, 0x80, 0x78, 0xF0,
  0x3C, 0x01, 0xC3, 0xC0, 0xF0, 0x0F, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x1E,
  0x00, 0xF0, 0x70, 0xF0, 0x03, 0xC1, 0xC3, 0x80, 0x0F, 0x0F, 0x1E, 0x00,
  0x1C, 0x3C, 0x71, 0xF8, 0x78, 0xF3, 0xCF, 0xF1, 0xF7, 0x9E, 0x7F, 0xE3,
  0xFE, 0x79, 0xE7, 0x87, 0xF3, 0xCF, 0x0F, 0x07, 0x0F, 0x3C, 0x3C, 0x00,
  0x78, 0xF0, 0xF0, 0x01, 0xC3, 0xC3, 0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x38,
  0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0xF0, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x07,
  0x9E, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x7C,
  0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0xF8, 0xFF, 0xE0, 0x7C,
  0xFD, 0xF8, 0x3C, 0xFC, 0x7E, 0x3E, 0x7C, 0x1F, 0x9F, 0x3E, 0x07, 0xFF,
  0x1F, 0x01, 0xFF, 0x8F, 0x80, 0x7F, 0x87, 0xC0, 0x1F, 0x83, 0xF0, 0x1F,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0x9F, 0x83, 0xFF,
  0x07, 0xE0, 0xFF, 0xDE, 0xF7, 0xBD, 0xCE, 0x70, 0x07, 0xC3, 0xE0, 0xF0,
  0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0xC1, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x1C, 0x78, 0x67, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x83,
  0xE1, 0xF0, 0x38, 0x78, 0x02, 0x08, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3E, 0x78,
  0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00,
  0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x9E, 0x03, 0xE7, 0xC1, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x8F,
  0xF7, 0xFF, 0xFB, 0xFE, 0x7B, 0x8F, 0x41, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x3F, 0x1C, 0x07, 0xE2, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0x83, 0xF3, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFB, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xF0, 0x0F, 0x1F, 0x01, 0xE1, 0xF0,
  0x1E, 0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF1, 0x83, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x1F, 0x83, 0xCF, 0xF8, 0xF7, 0xFF,
  0x3F, 0xFF, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xE7, 0xC0, 0xF9, 0xFD,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xF9, 0xFC,
  0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3E,
  0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x03,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xBC, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x3F,
  0xCF, 0xFF, 0xF0, 0xFF, 0xDE, 0x0F, 0xF3, 0xC0, 0x20, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0x8F, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x11, 0xEF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78,
  0x08, 0x79, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF1, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFE, 0x78, 0x3F, 0x20, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC7, 0x80, 0x60, 0x1E, 0x38, 0x1F, 0xFC, 0x73, 0xC1, 0xFF,
  0xC3, 0xDC, 0x1F, 0x9E, 0x0F, 0xE1, 0xF0, 0x70, 0x7F, 0x0F, 0x03, 0x83,
  0xF8, 0xF0, 0x1C, 0x1F, 0x87, 0x80, 0xE0, 0xFC, 0x3C, 0x0F, 0x07, 0xE1,
  0xE0, 0x78, 0x3F, 0x0F, 0x03, 0xC3, 0xFC, 0x38, 0x1E, 0x1D, 0xE1, 0xE1,
  0xF9, 0xEF, 0x0F, 0xFD, 0xFE, 0x38, 0x3F, 0xC7, 0xE1, 0xE0, 0x7C, 0x1E,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x10, 0x03,
  0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x83,
  0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xE1, 0xE3, 0xF8, 0x02, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x21, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF8, 0x07, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8,
  0x03, 0xF3, 0xE0, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE0, 0xF8, 0xFE, 0x00, 0x43, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFD,
  0xFF, 0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x7F, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01,
  0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFB, 0xE0, 0x1F, 0x9F,
  0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0x80,
  0x0F, 0xFF, 0x78, 0x01, 0xEF, 0xFF, 0x80, 0x1E, 0xFF, 0xBC, 0x01, 0xCF,
  0xFB, 0xC0, 0x3C, 0xFF, 0xBC, 0x03, 0xDF, 0xF9, 0xE0, 0x39, 0xFF, 0x9E,
  0x07, 0x9F, 0xF9, 0xE0, 0x79, 0xFF, 0x8F, 0x07, 0x1F, 0xF8, 0xF0, 0xF1,
  0xFF, 0x8F, 0x0F, 0x1F, 0xF8, 0x79, 0xE1, 0xFF, 0x87, 0x9E, 0x1F, 0xF8,
  0x79, 0xE1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83, 0xFC,
  0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF,
  0x80, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0xF8, 0x03, 0xFD, 0xF0, 0x07, 0xF9,
  0xF0, 0x0F, 0xFB, 0xF0, 0x1F, 0xF3, 0xE0, 0x3F, 0xE3, 0xE0, 0x7F, 0xC7,
  0xE0, 0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x0F,
  0x8F, 0xF8, 0x1F, 0x9F, 0xF0, 0x1F, 0x3F, 0xE0, 0x3F, 0x7F, 0xC0, 0x3E,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF1, 0xFF,
  0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xE7, 0xC0, 0x13,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7D,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x01, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0xCF, 0x00,
  0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0x00, 0x7D, 0xF0, 0x0F, 0xE0, 0x0F,
  0x3E, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0x78, 0x07, 0xF8,
  0x0F, 0x8F, 0x81, 0xEF, 0x01, 0xE1, 0xF0, 0x3D, 0xE0, 0x7C, 0x3E, 0x07,
  0xBC, 0x0F, 0x83, 0xC0, 0xF3, 0xC1, 0xF0, 0x7C, 0x3C, 0x78, 0x3C, 0x0F,
  0x87, 0x8F, 0x0F, 0x80, 0xF0, 0xF1, 0xE1, 0xF0, 0x1E, 0x3E, 0x1E, 0x3C,
  0x03, 0xE7, 0x83, 0xC7, 0x80, 0x7C, 0xF0, 0x79, 0xF0, 0x07, 0x9E, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0xF7, 0x80, 0x1E, 0xF0, 0x1E, 0xF0, 0x03, 0xFE,
  0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x7B, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF8, 0x7C, 0x01, 0xF1,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F,
  0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7D, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00,
  0x3E, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0,
  0x0F, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0x78,
  0x78, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x70,
  0x0F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0x83, 0xE1, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFB, 0xDF, 0xF9, 0xE7, 0xF8, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF9, 0xFC, 0x3D, 0xFF, 0x8F, 0x7F, 0xF3, 0xFC, 0xFE, 0xFC, 0x0F,
  0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0x7F, 0xE3, 0xC7, 0xF0, 0x07, 0xFE,
  0x3F, 0xFC, 0xFF, 0xFB, 0xFD, 0xE7, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x01, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0xE3, 0xC7, 0xFE, 0xF3, 0xFF,
  0xFD, 0xFE, 0xFF, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFE, 0xF1, 0xFF,
  0xBC, 0x3F, 0x8F, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x02, 0x3F, 0x87, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC,
  0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xF6, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0xF3, 0xC7, 0xFE, 0xF3, 0xFF, 0xFD, 0xFC, 0xFF, 0x7C, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xF0,
  0x3F, 0x7F, 0x3F, 0xCF, 0xFE, 0xF1, 0xFF, 0xBC, 0x3F, 0x8F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x70, 0x1F, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF9, 0xFE, 0x3D, 0xFF, 0xCF, 0x7F, 0xFB, 0xFC, 0xFE, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x77, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xBF, 0xEF, 0xFB,
  0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0xDF, 0x03, 0xF3, 0xE0, 0xFC, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF1, 0xF0,
  0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xCF, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0x1F, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xFC, 0x1F, 0xE3, 0xDF, 0xFC, 0xFF, 0xCF,
  0xFF, 0xF7, 0xFF, 0xBF, 0xCF, 0xFE, 0xFE, 0xFC, 0x0F, 0xE0, 0xFF, 0xE0,
  0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F,
  0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0,
  0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07,
  0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF,
  0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF1, 0xFE, 0x3D, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFE, 0xFE, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F,
  0x8F, 0xC7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xF0, 0x7F,
  0xF8, 0x03, 0xFE, 0x00, 0xF1, 0xFC, 0x3D, 0xFF, 0xCF, 0x7F, 0xF3, 0xFC,
  0xFE, 0xFC, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0x7F, 0xE3, 0xE7,
  0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF3,
  0xC7, 0xFE, 0xF3, 0xFF, 0xFD, 0xFC, 0xFF, 0x7C, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3F, 0x7F, 0xBF,
  0xCF, 0xFE, 0xF1, 0xFF, 0xBC, 0x3F, 0x8F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0xF1, 0xFF, 0x9F, 0xBD, 0xFD, 0xFF, 0xEF, 0xF0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x1F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7, 0xC1, 0xCF, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0, 0xFD, 0xFF, 0xFB, 0xFF,
  0xE3, 0xFF, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF9, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xDF, 0xFF, 0xF7, 0xFF,
  0x3C, 0x7F, 0x8F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F,
  0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3D, 0xE0, 0x3F, 0x01,
  0xF7, 0xC0, 0xFE, 0x07, 0xDF, 0x03, 0xF8, 0x1E, 0x3C, 0x0E, 0xE0, 0xF8,
  0xF8, 0x7B, 0x83, 0xE3, 0xE1, 0xEF, 0x0F, 0x07, 0x87, 0x3C, 0x3C, 0x1E,
  0x3C, 0xF1, 0xF0, 0x7C, 0xF1, 0xE7, 0xC1, 0xF3, 0xC7, 0x9E, 0x03, 0xCE,
  0x1E, 0x78, 0x0F, 0x78, 0x7B, 0xE0, 0x3D, 0xE0, 0xEF, 0x00, 0xFF, 0x83,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF3, 0xE0,
  0x3E, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x0F, 0x8F, 0x80, 0xFD, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x0F, 0x8F, 0x81, 0xF8, 0xF8,
  0x1F, 0x07, 0xC3, 0xE0, 0x7E, 0x7E, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xDE, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xF0,
  0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x1F,
  0x03, 0xF8, 0x3F, 0xC3, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x0F, 0xF0, 0x7F, 0x03, 0xF0,
  0x1E, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xF0,
};

const GFXglyph NotoSans_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 12, 9, 17, 2, -26 },
  { 35, 22, 26, 24, 1, -26 },
  { 107, 18, 30, 21, 2, -28 },
  { 175, 30, 27, 32, 1, -27 },
  { 277, 25, 27, 27, 2, -27 },
  { 362, 5, 9, 9, 2, -26 },
  { 368, 10, 32, 12, 1, -26 },
  { 408, 10, 32, 12, 1, -26 },
  { 448, 18, 17, 20, 1, -28 },
  { 487, 17, 18, 21, 2, -22 },
  { 526, 7, 9, 10, 1, -4 },
  { 534, 10, 4, 12, 1, -12 },
  { 539, 6, 5, 10, 2, -5 },
  { 543, 15, 27, 15, 0, -27 },
  { 594, 18, 27, 21, 2, -27 },
  { 655, 11, 26, 21, 3, -26 },
  { 691, 18, 27, 21, 2, -27 },
  { 752, 17, 27, 21, 2, -27 },
  { 810, 20, 26, 21, 1, -26 },
  { 875, 17, 26, 21, 2, -26 },
  { 931, 18, 27, 21, 2, -27 },
  { 992, 19, 26, 21, 1, -26 },
  { 1054, 19, 27, 21, 1, -27 },
  { 1119, 19, 27, 21, 1, -27 },
  { 1184, 6, 21, 10, 2, -21 },
  { 1200, 7, 26, 10, 1, -21 },
  { 1223, 17, 19, 21, 2, -23 },
  { 1264, 17, 10, 21, 2, -18 },
  { 1286, 17, 19, 21, 2, -23 },
  { 1327, 16, 27, 17, 0, -27 },
  { 1381, 29, 30, 33, 2, -27 },
  { 1490, 25, 27, 25, 0, -27 },
  { 1575, 20, 26, 24, 3, -26 },
  { 1640, 20, 27, 24, 2, -27 },
  { 1708, 22, 26, 27, 3, -26 },
  { 1780, 15, 26, 21, 3, -26 },
  { 1829, 15, 26, 20, 3, -26 },
  { 1878, 22, 27, 27, 2, -27 },
  { 1953, 22, 26, 28, 3, -26 },
  { 2025, 11, 26, 14, 1, -26 },
  { 2061, 11, 33, 11, -3, -26 },
  { 2107, 21, 26, 24, 3, -26 },
  { 2176, 16, 26, 20, 3, -26 },
  { 2228, 28, 26, 34, 3, -26 },
  { 2319, 23, 26, 29, 3, -26 },
  { 2394, 25, 27, 29, 2, -27 },
  { 2479, 18, 26, 23, 3, -26 },
  { 2538, 25, 33, 29, 2, -27 },
  { 2642, 21, 26, 24, 3, -26 },
  { 2711, 17, 27, 20, 2, -27 },
  { 2769, 19, 26, 21, 1, -26 },
  { 2831, 21, 26, 28, 3, -26 },
  { 2900, 23, 26, 23, 0, -26 },
  { 2975, 35, 26, 35, 0, -26 },
  { 3089, 23, 26, 24, 0, -26 },
  { 3164, 22, 26, 22, 0, -26 },
  { 3236, 19, 26, 21, 1, -26 },
  { 3298, 8, 32, 12, 3, -26 },
  { 3330, 15, 27, 15, 0, -27 },
  { 3381, 8, 32, 12, 1, -26 },
  { 3413, 19, 17, 21, 1, -27 },
  { 3454, 16, 3, 16, 0, 3 },
  { 3460, 10, 6, 12, 1, -28 },
  { 3468, 17, 20, 22, 2, -20 },
  { 3511, 18, 28, 23, 3, -28 },
  { 3574, 15, 20, 19, 2, -20 },
  { 3612, 18, 28, 23, 2, -28 },
  { 3675, 18, 20, 22, 2, -20 },
  { 3720, 14, 28, 14, 1, -28 },
  { 3769, 18, 29, 23, 2, -20 },
  { 3835, 18, 28, 24, 3, -28 },
  { 3898, 5, 28, 10, 3, -28 },
  { 3916, 10, 37, 10, -2, -28 },
  { 3963, 19, 28, 22, 3, -28 },
  { 4030, 5, 28, 10, 3, -28 },
  { 4048, 30, 20, 36, 3, -20 },
  { 4123, 18, 20, 24, 3, -20 },
  { 4168, 19, 20, 23, 2, -20 },
  { 4216, 18, 29, 23, 3, -20 },
  { 4282, 18, 29, 23, 2, -20 },
  { 4348, 13, 20, 16, 3, -20 },
  { 4381, 15, 20, 18, 2, -20 },
  { 4419, 13, 24, 15, 1, -24 },
  { 4458, 18, 20, 24, 3, -20 },
  { 4503, 20, 20, 20, 0, -20 },
  { 4553, 30, 20, 31, 0, -20 },
  { 4628, 20, 20, 21, 0, -20 },
  { 4678, 20, 29, 20, 0, -20 },
  { 4751, 16, 20, 18, 1, -20 },
  { 4791, 12, 32, 14, 1, -26 },
  { 4839, 4, 37, 20, 8, -28 },
  { 4858, 13, 32, 14, 1, -26 },
  { 4910, 17, 6, 21, 2, -16 },
};

const GFXfont NotoSans_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMIBOLD37PT7B_H_
