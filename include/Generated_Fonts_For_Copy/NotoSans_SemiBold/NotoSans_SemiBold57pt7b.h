#ifndef _NOTOSANS_SEMIBOLD57PT7B_H_
#define _NOTOSANS_SEMIBOLD57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xEF, 0xF7, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0x0E,
  0x00, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0x78, 0xFE, 0x7F, 0x8F, 0x01, 0x8F, 0xE1,
  0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xF0, 0xF0, 0x00,
  0xFF, 0x1E, 0x00, 0x1F, 0xFB, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0x1F, 0xF0, 0x01, 0xE1, 0xFE, 0x00, 0x3C, 0x1F, 0xC0,
  0x07, 0x83, 0xF8, 0x00, 0xF0, 0x7F, 0x80, 0x1E, 0x1F, 0xFE, 0x03, 0xC7,
  0xFF, 0xFE, 0x7B, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x01, 0xF0, 0x3F, 0x0F, 0xC7,
  0xFE, 0x07, 0xE0, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0x87, 0xE1, 0xF1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x3F, 0x8F,
  0xE1, 0xFF, 0xF1, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0x8F, 0xC3, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0x83, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0xFC, 0x01, 0xFC,
  0x3F, 0xF7, 0xFC, 0x03, 0xF8, 0x7F, 0x87, 0xFC, 0x0F, 0xF1, 0xFF, 0x03,
  0xFC, 0x1F, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0xFE,
  0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0x80,
  0x03, 0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFB,
  0xFE, 0x07, 0xFF, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x02, 0x00, 0xF8, 0x02, 0x78, 0x1F, 0x03, 0xCF, 0xF3, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3E, 0x03, 0xF0, 0x01, 0xC0,
  0x78, 0x00, 0x08, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0xDF,
  0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0xDF, 0xF7, 0xFF, 0xF9, 0xFD, 0xF8, 0x7F, 0x3C, 0x1F, 0xC6, 0x07, 0xF1,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0,
  0x7F, 0xC1, 0xF0, 0x03, 0xFE, 0x1C, 0x00, 0x1F, 0xE0, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0x00,
  0x7F, 0xC1, 0xC0, 0x03, 0xFE, 0x10, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE,
  0xF0, 0x00, 0x7F, 0xEF, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xD0, 0x00,
  0x0F, 0xFB, 0xC0, 0x03, 0xFE, 0x7F, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x16, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x1F, 0xFE, 0x07, 0xE7, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0x87,
  0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3,
  0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFE,
  0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7,
  0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0x7F, 0x07,
  0xFF, 0xE7, 0xF0, 0x1F, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x01, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x1F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFF, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xDF, 0xEF, 0xFF, 0xFB, 0xFD,
  0xFE, 0x7E, 0x1E, 0x00, 0x04, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0x87, 0xE1,
  0xF8, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xF8, 0x03,
  0xFC, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0xF8, 0x07, 0xE1, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0xF8, 0xF8, 0x07,
  0xFF, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xC7, 0xF0, 0x3F, 0x7E, 0x07, 0xF0,
  0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0xC0, 0xF8, 0x01, 0xF8,
  0x0F, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFF,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7D, 0xF0,
  0x1F, 0x80, 0x7F, 0x03, 0xEF, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0x7E, 0x07,
  0xF0, 0x7F, 0xE3, 0xF3, 0xF0, 0x1F, 0xFF, 0xDF, 0xFF, 0x8F, 0x80, 0xFF,
  0xFE, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xE3, 0xFF, 0x83, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFF, 0x3F, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x03, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x18, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x04, 0x0F, 0xFE, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x34, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xF8, 0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFC, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0x00, 0x0F, 0xFE, 0x3F, 0x80, 0x3F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xDF, 0xC0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0x1F, 0xF0, 0x00, 0x1F, 0xC7, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xE0,
  0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFF, 0x07, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x08, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xF0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xBF, 0x80, 0x00, 0xFD, 0xFF, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0xFF, 0x7E,
  0x00, 0x03, 0xF7, 0xFF, 0xEF, 0xE0, 0x00, 0xFC, 0xFF, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0xFF, 0x9F, 0x80, 0x03, 0xF3, 0xFF, 0xF3, 0xF8, 0x00, 0xFC,
  0x7F, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xFF, 0xC7, 0xE0, 0x03, 0xF1, 0xFF,
  0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0xFF, 0x0F, 0xC0, 0x1F, 0x87, 0xFF, 0xE1,
  0xF8, 0x07, 0xE0, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0x83, 0xF0,
  0x1F, 0x83, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFC, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x3F,
  0xFF, 0x03, 0xF8, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0xFC,
  0x07, 0xE7, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xDF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0xC0, 0x01, 0xFF,
  0xF7, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xE7, 0xF8, 0x00,
  0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xF1, 0xFF,
  0x00, 0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0xC0, 0x3F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0xF0, 0x0F, 0xF0,
  0x7F, 0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xF8, 0x01,
  0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0xFC,
  0x00, 0x3F, 0xCF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0xBF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xBF, 0x81, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0xF0,
  0x7F, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0xF1, 0xFE,
  0x00, 0x18, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xEF, 0x80, 0x0F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xFB, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0x80, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xEF, 0xFC, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xEF, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFB, 0xF3, 0xFF,
  0xFE, 0x7E, 0x3F, 0xFF, 0x8F, 0xC1, 0xFF, 0xC0, 0xF8, 0x03, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F,
  0x9F, 0xFF, 0x03, 0xFD, 0xFF, 0xFC, 0x1F, 0xDF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xFE,
  0x03, 0xFE, 0x7F, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xDF, 0xFF,
  0xF0, 0xFE, 0x7F, 0xFF, 0x87, 0xE1, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0,
  0x0C, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x01, 0x3F, 0xE0, 0x06, 0x3F, 0xFC, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFF,
  0x87, 0xF0, 0x7F, 0xFE, 0x7F, 0x0F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0x83, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC3, 0xFF, 0x80, 0x7C, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0x06, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x3F, 0x0F, 0xFF, 0xF3, 0xF1,
  0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xFF, 0x7F, 0xC0,
  0x3F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F, 0x01, 0xFF,
  0x87, 0xF0, 0x03, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x40, 0x00, 0x1F, 0xF3, 0x00,
  0x03, 0xFE, 0x3F, 0x80, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF3, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFA, 0x1F, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC,
  0x7F, 0xE0, 0x3E, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0,
  0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFD,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xFC,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x7F, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x8F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x40, 0x00, 0xFC, 0x0F, 0xFC, 0x07, 0xF1, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF,
  0xE1, 0xFD, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xF3,
  0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00,
  0x3F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0xE7, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFD, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xF0, 0x7F,
  0x9F, 0xFF, 0x03, 0xFC, 0x7F, 0xF0, 0x1F, 0xE0, 0x10, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x83, 0xF0, 0x7F, 0xFE, 0x3F, 0x0F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F, 0x01, 0xFF, 0x87, 0xF0, 0x03,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x2F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0x3F,
  0x80, 0x04, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFD, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00,
  0xB0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x38, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x14, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x3F,
  0xF7, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF3, 0xF0, 0xFF, 0xFE, 0x3F, 0x03, 0xFF, 0x83, 0xF0, 0x05, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xC7, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x7E, 0x01, 0xFC,
  0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x83,
  0xFC, 0x0F, 0x8F, 0x80, 0xFE, 0x07, 0xF0, 0x3E, 0x3F, 0x03, 0xF0, 0x1F,
  0xC1, 0xF8, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0x87, 0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF0, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x00, 0x7E, 0x3E,
  0x03, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0,
  0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0xFD, 0xFC, 0x00, 0x3F, 0x7C, 0x01,
  0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x07, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x2F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xE4, 0x00,
  0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiBold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 42, 16, 3, -41 },
  { 49, 18, 15, 26, 4, -41 },
  { 83, 34, 41, 37, 1, -41 },
  { 258, 27, 46, 33, 3, -43 },
  { 414, 46, 42, 50, 2, -41 },
  { 656, 39, 42, 42, 3, -41 },
  { 861, 7, 15, 14, 4, -41 },
  { 875, 15, 50, 18, 2, -41 },
  { 969, 14, 50, 18, 2, -41 },
  { 1057, 27, 26, 31, 2, -43 },
  { 1145, 27, 28, 33, 3, -34 },
  { 1240, 10, 14, 16, 2, -7 },
  { 1258, 14, 6, 18, 2, -18 },
  { 1269, 9, 9, 16, 3, -8 },
  { 1280, 22, 41, 23, 0, -41 },
  { 1393, 28, 42, 33, 2, -41 },
  { 1540, 18, 41, 33, 4, -41 },
  { 1633, 28, 41, 33, 2, -41 },
  { 1777, 28, 42, 33, 2, -41 },
  { 1924, 31, 41, 33, 1, -41 },
  { 2083, 27, 42, 33, 3, -41 },
  { 2225, 28, 42, 33, 2, -41 },
  { 2372, 28, 41, 33, 2, -41 },
  { 2516, 28, 42, 33, 2, -41 },
  { 2663, 28, 42, 33, 2, -41 },
  { 2810, 9, 33, 16, 3, -32 },
  { 2848, 10, 39, 16, 2, -32 },
  { 2897, 27, 29, 33, 3, -35 },
  { 2995, 27, 16, 33, 3, -28 },
  { 3049, 27, 29, 33, 3, -35 },
  { 3147, 25, 42, 26, 0, -41 },
  { 3279, 45, 46, 51, 3, -41 },
  { 3538, 38, 41, 38, 0, -41 },
  { 3733, 30, 41, 38, 5, -41 },
  { 3887, 32, 42, 36, 3, -41 },
  { 4055, 33, 41, 42, 5, -41 },
  { 4225, 23, 41, 32, 5, -41 },
  { 4343, 23, 41, 31, 5, -41 },
  { 4461, 34, 42, 41, 3, -41 },
  { 4640, 33, 41, 43, 5, -41 },
  { 4810, 17, 41, 21, 2, -41 },
  { 4898, 16, 53, 18, -4, -41 },
  { 5004, 32, 41, 37, 5, -41 },
  { 5168, 24, 41, 31, 5, -41 },
  { 5291, 43, 41, 53, 5, -41 },
  { 5512, 35, 41, 45, 5, -41 },
  { 5692, 39, 42, 45, 3, -41 },
  { 5897, 27, 41, 35, 5, -41 },
  { 6036, 39, 51, 45, 3, -41 },
  { 6285, 31, 41, 37, 5, -41 },
  { 6444, 26, 42, 31, 3, -41 },
  { 6581, 31, 41, 32, 1, -41 },
  { 6740, 33, 42, 43, 5, -41 },
  { 6914, 36, 41, 36, 0, -41 },
  { 7099, 54, 41, 54, 0, -41 },
  { 7376, 36, 41, 36, 0, -41 },
  { 7561, 34, 41, 34, 0, -41 },
  { 7736, 29, 41, 33, 2, -41 },
  { 7885, 13, 50, 19, 4, -41 },
  { 7967, 22, 41, 23, 0, -41 },
  { 8080, 14, 50, 19, 1, -41 },
  { 8168, 29, 26, 33, 2, -41 },
  { 8263, 24, 4, 24, 0, 5 },
  { 8275, 15, 9, 19, 2, -44 },
  { 8292, 27, 32, 33, 2, -31 },
  { 8400, 29, 44, 36, 4, -43 },
  { 8560, 24, 32, 29, 3, -31 },
  { 8656, 28, 44, 36, 3, -43 },
  { 8810, 28, 32, 33, 3, -31 },
  { 8922, 23, 44, 21, 1, -44 },
  { 9049, 28, 45, 36, 3, -31 },
  { 9207, 28, 43, 36, 4, -43 },
  { 9358, 8, 43, 16, 4, -43 },
  { 9401, 15, 57, 16, -3, -43 },
  { 9508, 28, 43, 34, 5, -43 },
  { 9659, 8, 43, 16, 4, -43 },
  { 9702, 46, 31, 55, 4, -31 },
  { 9881, 28, 31, 36, 4, -31 },
  { 9990, 29, 32, 35, 3, -31 },
  { 10106, 29, 45, 36, 4, -31 },
  { 10270, 28, 45, 36, 3, -31 },
  { 10428, 20, 31, 25, 4, -31 },
  { 10506, 23, 32, 28, 3, -31 },
  { 10598, 21, 39, 23, 1, -38 },
  { 10701, 28, 32, 36, 4, -31 },
  { 10813, 31, 31, 31, 0, -31 },
  { 10934, 46, 31, 47, 1, -31 },
  { 11113, 30, 31, 32, 1, -31 },
  { 11230, 31, 45, 31, 0, -31 },
  { 11405, 24, 31, 28, 2, -31 },
  { 11498, 19, 50, 22, 1, -41 },
  { 11617, 5, 56, 31, 13, -43 },
  { 11652, 19, 50, 22, 2, -41 },
  { 11771, 27, 8, 33, 3, -24 },
};

const GFXfont NotoSans_SemiBold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMIBOLD57PT7B_H_
