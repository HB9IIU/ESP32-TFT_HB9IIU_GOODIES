#ifndef _NOTOSANS_SEMIBOLD9PT7B_H_
#define _NOTOSANS_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF8, 0x29, 0xF3, 0x3E, 0x51, 0x40, 0x23, 0xF8, 0xC3, 0xDD,
  0x84, 0x40, 0xA4, 0xA8, 0xAE, 0x55, 0x25, 0x26, 0x20, 0xA1, 0x41, 0x05,
  0x59, 0x9F, 0x80, 0xC0, 0x6A, 0x48, 0x98, 0xC9, 0x14, 0xB0, 0x25, 0x5C,
  0xA0, 0x27, 0xC8, 0x40, 0x60, 0xE0, 0x80, 0x32, 0x44, 0x48, 0x22, 0xB3,
  0x9C, 0xAD, 0xC0, 0xFD, 0xB6, 0xC0, 0x26, 0x86, 0x22, 0x23, 0xE0, 0x26,
  0x86, 0xE1, 0x8F, 0xC0, 0x31, 0x95, 0x2F, 0x88, 0x72, 0x1C, 0x31, 0xF8,
  0x13, 0x51, 0x6C, 0xA5, 0xC0, 0xF8, 0x84, 0x42, 0x30, 0x22, 0x96, 0xE5,
  0xC5, 0xC0, 0x22, 0xA3, 0xB6, 0x89, 0xC0, 0x88, 0x40, 0x60, 0x09, 0xB0,
  0xC1, 0x80, 0xFF, 0xC0, 0x83, 0x06, 0x6C, 0x00, 0x6B, 0x12, 0x40, 0x40,
  0x3E, 0x5E, 0xA5, 0xA5, 0x5E, 0x40, 0x3C, 0x30, 0xC4, 0x9E, 0x4A, 0x10,
  0xF9, 0xE9, 0x9F, 0x2D, 0x88, 0x88, 0x70, 0xF4, 0x63, 0x19, 0xF8, 0xF3,
  0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x26, 0xE1, 0x78, 0xC5, 0xE0, 0x8C, 0x7F,
  0x18, 0xC4, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4E, 0x9D, 0x31, 0x4B, 0x4C,
  0x88, 0x88, 0x8F, 0xC7, 0x9F, 0x3D, 0x7B, 0x76, 0xC0, 0xCE, 0x6B, 0x79,
  0xC4, 0x23, 0x68, 0xA3, 0x8E, 0x27, 0x00, 0xF9, 0xBE, 0x88, 0x23, 0x68,
  0xA3, 0x8E, 0x27, 0x04, 0x08, 0xF4, 0xAD, 0xC9, 0x4C, 0x22, 0xB0, 0xC1,
  0x0F, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x8C, 0x63, 0x18, 0xF8, 0x8D, 0x24,
  0x94, 0x30, 0xC0, 0x99, 0xAC, 0x95, 0x4A, 0xE6, 0x61, 0x30, 0xCD, 0xC3,
  0x0C, 0x5B, 0x30, 0xCA, 0x8C, 0x42, 0x10, 0xF8, 0x88, 0xC4, 0x7C, 0xEA,
  0xAC, 0x84, 0x42, 0x23, 0xD5, 0x5C, 0x22, 0x95, 0x10, 0xF0, 0xC4, 0x70,
  0xDF, 0xB6, 0x80, 0x88, 0xE9, 0x99, 0xF0, 0x74, 0xC4, 0x70, 0x08, 0x5E,
  0x9C, 0xA5, 0xE0, 0x72, 0x7E, 0x87, 0x80, 0x74, 0xE4, 0x44, 0x40, 0x7A,
  0x72, 0x97, 0x85, 0xC0, 0x88, 0xF9, 0x99, 0x90, 0xBE, 0x45, 0x55, 0xC0,
  0x88, 0xBA, 0xCA, 0x90, 0xFE, 0xFF, 0x26, 0x4C, 0x99, 0x20, 0xF9, 0x99,
  0x90, 0x72, 0x72, 0x97, 0x00, 0xF9, 0x99, 0xF8, 0x80, 0x7A, 0x72, 0x97,
  0x84, 0x20, 0xF2, 0x48, 0x7C, 0x61, 0xF0, 0x5D, 0x24, 0xC0, 0x99, 0x99,
  0xF0, 0x8A, 0x94, 0xA2, 0x00, 0x93, 0xB5, 0xAB, 0x66, 0x40, 0xDA, 0x88,
  0xAD, 0x80, 0x8A, 0x94, 0xA2, 0x13, 0x00, 0xF3, 0x24, 0xF0, 0x69, 0x44,
  0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0x6C, 0x80,
};

const GFXglyph NotoSans_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 3, 1, -6 },
  { 2, 3, 2, 4, 1, -6 },
  { 3, 6, 6, 6, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 8, 7, 8, 0, -7 },
  { 20, 7, 7, 7, 0, -7 },
  { 27, 1, 2, 2, 1, -6 },
  { 28, 3, 7, 3, 0, -6 },
  { 31, 3, 7, 3, 0, -6 },
  { 34, 5, 4, 5, 0, -7 },
  { 37, 5, 4, 5, 0, -5 },
  { 40, 2, 2, 3, 0, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 1, 1, 2, 1, -1 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 5, 7, 5, 0, -7 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 1, 5, 2, 1, -5 },
  { 92, 2, 6, 3, 0, -5 },
  { 94, 5, 5, 5, 0, -6 },
  { 98, 5, 2, 5, 0, -4 },
  { 100, 5, 5, 5, 0, -6 },
  { 104, 4, 7, 4, 0, -7 },
  { 108, 8, 7, 8, 0, -6 },
  { 115, 6, 6, 6, 0, -6 },
  { 120, 4, 6, 6, 1, -6 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 5, 6, 7, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 5, 7, 7, 1, -7 },
  { 142, 5, 6, 7, 1, -6 },
  { 146, 3, 6, 3, 0, -6 },
  { 149, 3, 8, 3, -1, -6 },
  { 152, 5, 6, 6, 1, -6 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 7, 6, 8, 1, -6 },
  { 165, 5, 6, 7, 1, -6 },
  { 169, 6, 7, 7, 1, -7 },
  { 175, 4, 6, 6, 1, -6 },
  { 178, 6, 9, 7, 1, -7 },
  { 185, 5, 6, 6, 1, -6 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 5, 6, 5, 0, -6 },
  { 198, 5, 6, 7, 1, -6 },
  { 202, 6, 6, 6, 0, -6 },
  { 207, 9, 6, 9, 0, -6 },
  { 214, 6, 6, 6, 0, -6 },
  { 219, 5, 6, 5, 0, -6 },
  { 223, 5, 6, 5, 0, -6 },
  { 227, 2, 7, 3, 1, -6 },
  { 229, 4, 6, 4, 0, -6 },
  { 232, 2, 7, 3, 0, -6 },
  { 234, 5, 4, 5, 0, -6 },
  { 237, 4, 1, 4, 0, 1 },
  { 238, 3, 2, 3, 0, -7 },
  { 239, 5, 5, 5, 0, -5 },
  { 243, 4, 7, 6, 1, -7 },
  { 247, 4, 5, 5, 0, -5 },
  { 250, 5, 7, 6, 0, -7 },
  { 255, 5, 5, 5, 0, -5 },
  { 259, 4, 7, 3, 0, -7 },
  { 263, 5, 7, 6, 0, -5 },
  { 268, 4, 7, 6, 1, -7 },
  { 272, 1, 7, 3, 1, -7 },
  { 273, 2, 9, 3, 0, -7 },
  { 276, 4, 7, 5, 1, -7 },
  { 280, 1, 7, 3, 1, -7 },
  { 281, 7, 5, 9, 1, -5 },
  { 286, 4, 5, 6, 1, -5 },
  { 289, 5, 5, 6, 0, -5 },
  { 293, 4, 7, 6, 1, -5 },
  { 297, 5, 7, 6, 0, -5 },
  { 302, 3, 5, 4, 1, -5 },
  { 304, 4, 5, 4, 0, -5 },
  { 307, 3, 6, 4, 0, -6 },
  { 310, 4, 5, 6, 1, -5 },
  { 313, 5, 5, 5, 0, -5 },
  { 317, 7, 5, 7, 0, -5 },
  { 322, 5, 5, 5, 0, -5 },
  { 326, 5, 7, 5, 0, -5 },
  { 331, 4, 5, 4, 0, -5 },
  { 334, 3, 7, 4, 0, -6 },
  { 337, 1, 9, 5, 2, -7 },
  { 339, 3, 7, 4, 0, -6 },
  { 342, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMIBOLD9PT7B_H_
