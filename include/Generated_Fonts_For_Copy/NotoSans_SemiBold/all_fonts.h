#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiBold
// Headers: 67

#include "NotoSans_SemiBold6pt7b.h"
#include "NotoSans_SemiBold7pt7b.h"
#include "NotoSans_SemiBold8pt7b.h"
#include "NotoSans_SemiBold9pt7b.h"
#include "NotoSans_SemiBold10pt7b.h"
#include "NotoSans_SemiBold11pt7b.h"
#include "NotoSans_SemiBold12pt7b.h"
#include "NotoSans_SemiBold13pt7b.h"
#include "NotoSans_SemiBold14pt7b.h"
#include "NotoSans_SemiBold15pt7b.h"
#include "NotoSans_SemiBold16pt7b.h"
#include "NotoSans_SemiBold17pt7b.h"
#include "NotoSans_SemiBold18pt7b.h"
#include "NotoSans_SemiBold19pt7b.h"
#include "NotoSans_SemiBold20pt7b.h"
#include "NotoSans_SemiBold21pt7b.h"
#include "NotoSans_SemiBold22pt7b.h"
#include "NotoSans_SemiBold23pt7b.h"
#include "NotoSans_SemiBold24pt7b.h"
#include "NotoSans_SemiBold25pt7b.h"
#include "NotoSans_SemiBold26pt7b.h"
#include "NotoSans_SemiBold27pt7b.h"
#include "NotoSans_SemiBold28pt7b.h"
#include "NotoSans_SemiBold29pt7b.h"
#include "NotoSans_SemiBold30pt7b.h"
#include "NotoSans_SemiBold31pt7b.h"
#include "NotoSans_SemiBold32pt7b.h"
#include "NotoSans_SemiBold33pt7b.h"
#include "NotoSans_SemiBold34pt7b.h"
#include "NotoSans_SemiBold35pt7b.h"
#include "NotoSans_SemiBold36pt7b.h"
#include "NotoSans_SemiBold37pt7b.h"
#include "NotoSans_SemiBold38pt7b.h"
#include "NotoSans_SemiBold39pt7b.h"
#include "NotoSans_SemiBold40pt7b.h"
#include "NotoSans_SemiBold41pt7b.h"
#include "NotoSans_SemiBold42pt7b.h"
#include "NotoSans_SemiBold43pt7b.h"
#include "NotoSans_SemiBold44pt7b.h"
#include "NotoSans_SemiBold45pt7b.h"
#include "NotoSans_SemiBold46pt7b.h"
#include "NotoSans_SemiBold47pt7b.h"
#include "NotoSans_SemiBold48pt7b.h"
#include "NotoSans_SemiBold49pt7b.h"
#include "NotoSans_SemiBold50pt7b.h"
#include "NotoSans_SemiBold51pt7b.h"
#include "NotoSans_SemiBold52pt7b.h"
#include "NotoSans_SemiBold53pt7b.h"
#include "NotoSans_SemiBold54pt7b.h"
#include "NotoSans_SemiBold55pt7b.h"
#include "NotoSans_SemiBold56pt7b.h"
#include "NotoSans_SemiBold57pt7b.h"
#include "NotoSans_SemiBold58pt7b.h"
#include "NotoSans_SemiBold59pt7b.h"
#include "NotoSans_SemiBold60pt7b.h"
#include "NotoSans_SemiBold61pt7b.h"
#include "NotoSans_SemiBold62pt7b.h"
#include "NotoSans_SemiBold63pt7b.h"
#include "NotoSans_SemiBold64pt7b.h"
#include "NotoSans_SemiBold65pt7b.h"
#include "NotoSans_SemiBold66pt7b.h"
#include "NotoSans_SemiBold67pt7b.h"
#include "NotoSans_SemiBold68pt7b.h"
#include "NotoSans_SemiBold69pt7b.h"
#include "NotoSans_SemiBold70pt7b.h"
#include "NotoSans_SemiBold71pt7b.h"
#include "NotoSans_SemiBold72pt7b.h"
