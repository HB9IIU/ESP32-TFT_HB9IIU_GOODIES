#ifndef _NOTOSANS_SEMIBOLD62PT7B_H_
#define _NOTOSANS_SEMIBOLD62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE1, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0xE7, 0xF8, 0xFF, 0x87,
  0x81, 0xE3, 0xFC, 0x1E, 0x00, 0x8F, 0xF0, 0x78, 0x00, 0x3F, 0xC1, 0xE0,
  0x00, 0xFF, 0x07, 0x80, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xFC, 0x78, 0x00,
  0x1F, 0xF9, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1E, 0xFF, 0xE0, 0x00, 0x78, 0xFF, 0x80, 0x01, 0xE1,
  0xFF, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x78, 0x3F,
  0xE0, 0x01, 0xE1, 0xFE, 0xF0, 0x07, 0x87, 0xFB, 0xFC, 0x1E, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0xFF, 0x01,
  0xF8, 0x1F, 0xC3, 0xF0, 0xFF, 0xE0, 0x7E, 0x07, 0xF1, 0xFC, 0x7F, 0xFC,
  0x1F, 0xC1, 0xF8, 0x7E, 0x3F, 0xFF, 0x83, 0xF9, 0xFE, 0x3F, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xC7, 0xF1, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1, 0xF8,
  0x3F, 0x83, 0xFF, 0xE3, 0xF8, 0x7E, 0x07, 0xE0, 0x7F, 0xE0, 0xFC, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x3F, 0xC0, 0x0F, 0xFD, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x60, 0x0F, 0xC0, 0x19, 0xF0,
  0x3E, 0x03, 0xE7, 0xFC, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xF7, 0xF7, 0xFE, 0x7F, 0xFF,
  0xC7, 0xF7, 0xF8, 0xFF, 0x3F, 0x0F, 0xF1, 0xC0, 0xFF, 0x08, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0x70, 0x00,
  0x3F, 0xC0, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xFC, 0x3C, 0x00, 0x1F, 0xF0, 0x40,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x80, 0x00, 0x0F, 0xFB, 0x00, 0x00, 0x7F, 0xEF,
  0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xEE, 0x00, 0x03, 0xFF, 0x7F, 0x00,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x9E, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xF8, 0x0F,
  0xE1, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xE3, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFF,
  0x80, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x7F, 0x9F, 0xF8, 0x01, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x8F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7D, 0x00, 0x00, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0x87, 0x80, 0x0F, 0xC3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8,
  0xFF, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xF8, 0x03, 0xFF, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0x0F,
  0xFF, 0xFC, 0x0F, 0xC3, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7E, 0x3F, 0x01, 0xFF, 0x03, 0xF0, 0x1F, 0x9F, 0x80,
  0xFF, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xF9, 0xF8,
  0x1F, 0xC0, 0x0F, 0xC0, 0x3E, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xBF,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFF,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x3E, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xBF, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x00, 0x7F, 0x01,
  0xFB, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0x3F, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0xFF,
  0x03, 0xF1, 0xF8, 0x0F, 0xE0, 0x7F, 0xE1, 0xF8, 0x7E, 0x03, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0x07, 0xE0, 0x0F, 0xFF,
  0xC7, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x7F, 0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x3F, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x0F, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0x06, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xC0,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0x00,
  0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xCF,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0x8F,
  0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0x81, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF8,
  0x00, 0x0F, 0xF1, 0xFF, 0xE0, 0x00, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3F, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xD8, 0x3F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFD, 0xFC, 0x00, 0x00, 0xFD, 0xFF, 0xF7, 0xF0, 0x00, 0x07, 0xF7,
  0xFF, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xFF, 0xBF, 0x80, 0x00, 0x7E, 0x7F,
  0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFF, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xFF,
  0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0xFF, 0x9F, 0xC0, 0x01, 0xFC, 0xFF, 0xFE,
  0x3F, 0x00, 0x07, 0xE3, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xFF, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0x87, 0xE0, 0x03, 0xF0, 0xFF, 0xFE, 0x1F,
  0xC0, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xFF, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0xFF, 0x83, 0xF8, 0x07, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0xFE, 0x03, 0xF0, 0x7E,
  0x03, 0xFF, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x8F, 0xE0,
  0x3F, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xEF, 0xF0,
  0x00, 0x1F, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0x00, 0x07, 0xFF,
  0xE7, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0x80,
  0x0F, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xF0,
  0x7F, 0x80, 0x1F, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFC, 0x00, 0x7F,
  0x87, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0xF8,
  0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xF9,
  0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F,
  0xFF, 0xDF, 0xE0, 0x07, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0xEF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFC, 0x01, 0xF8, 0x7F, 0xC0, 0x01, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xEC, 0x00, 0x00, 0xFF,
  0x7C, 0x00, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0x83, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x00,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0xFF, 0xFD, 0xFD, 0xFF, 0xFF,
  0xCF, 0xE7, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC7,
  0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xC1, 0xFD, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F,
  0xE0, 0x07, 0xFC, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF7, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFC, 0x1F, 0x87,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xC1, 0xF0, 0xFF, 0xC0, 0x04,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x0C, 0xFF, 0xE0, 0x1F, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0xFC, 0x7F, 0x83, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0xF3, 0xFF, 0x00,
  0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFF, 0x8F, 0xE0, 0x7F,
  0xFE, 0x1F, 0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x87, 0xFE, 0x00, 0x1E, 0x1F, 0xFF, 0xBF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x08, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0xFE, 0x03, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xE3,
  0xF8, 0x7F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xEF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFE, 0x0F, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0x7F, 0xC0, 0x07, 0xFE,
  0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x7F, 0x83, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xC3,
  0xFC, 0x00, 0x30, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x30, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF, 0xF0, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x0C, 0x3F, 0x9F, 0xEF,
  0xFF, 0xFB, 0xFD, 0xFE, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0x00, 0x18, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xBF,
  0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFD, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC3, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x07, 0xFC, 0x01,
  0xFC, 0x3F, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0x0F,
  0xEF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x7F,
  0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F,
  0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x03, 0xFC, 0x03, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFE, 0x03, 0xFF,
  0xE1, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8, 0x7F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF,
  0xEF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x9F, 0xF0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xFC, 0xFF, 0x03, 0xFF,
  0xF1, 0xFE, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x30, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFE, 0x00, 0xF9, 0xFE, 0x00, 0x08, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xEF, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x41, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0D, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xDF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xE1, 0xFC,
  0x1F, 0xFE, 0x07, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xC7, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x3F, 0x7E, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x83,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x7E, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x7E, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x03, 0xFC, 0x3F, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x3F,
  0x1F, 0xC0, 0x07, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x7E, 0xFF, 0x00, 0x0F, 0xEF, 0xC0,
  0x1F, 0xBF, 0x80, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x7F, 0xF0, 0x00,
  0x37, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x80,
  0x01, 0xFF, 0xE2, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiBold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 45, 17, 4, -44 },
  { 52, 20, 16, 28, 4, -44 },
  { 92, 38, 44, 40, 1, -44 },
  { 301, 30, 51, 35, 3, -47 },
  { 493, 50, 46, 54, 2, -45 },
  { 781, 43, 46, 46, 3, -45 },
  { 1029, 8, 16, 16, 4, -44 },
  { 1045, 16, 54, 20, 2, -44 },
  { 1153, 16, 54, 20, 2, -44 },
  { 1261, 30, 28, 34, 2, -47 },
  { 1366, 30, 30, 35, 3, -37 },
  { 1479, 11, 15, 17, 2, -7 },
  { 1500, 16, 7, 20, 2, -20 },
  { 1514, 9, 10, 17, 4, -9 },
  { 1526, 24, 45, 25, 0, -45 },
  { 1661, 30, 46, 35, 3, -45 },
  { 1834, 20, 44, 35, 4, -44 },
  { 1944, 30, 45, 35, 3, -45 },
  { 2113, 30, 46, 35, 3, -45 },
  { 2286, 33, 44, 35, 1, -44 },
  { 2468, 29, 45, 35, 3, -44 },
  { 2632, 30, 46, 35, 3, -45 },
  { 2805, 31, 44, 35, 2, -44 },
  { 2976, 31, 46, 35, 2, -45 },
  { 3155, 31, 46, 35, 2, -45 },
  { 3334, 9, 35, 17, 4, -34 },
  { 3374, 11, 42, 17, 2, -34 },
  { 3432, 30, 31, 35, 3, -38 },
  { 3549, 29, 18, 35, 3, -31 },
  { 3615, 30, 31, 35, 3, -38 },
  { 3732, 27, 46, 29, 0, -45 },
  { 3888, 50, 49, 56, 3, -44 },
  { 4195, 42, 44, 42, 0, -44 },
  { 4426, 32, 44, 41, 6, -44 },
  { 4602, 34, 46, 40, 4, -45 },
  { 4798, 36, 44, 45, 6, -44 },
  { 4996, 25, 44, 35, 6, -44 },
  { 5134, 25, 44, 33, 6, -44 },
  { 5272, 36, 46, 45, 4, -45 },
  { 5479, 35, 44, 47, 6, -44 },
  { 5672, 19, 44, 23, 2, -44 },
  { 5777, 19, 57, 19, -5, -44 },
  { 5913, 34, 44, 40, 6, -44 },
  { 6100, 26, 44, 34, 6, -44 },
  { 6243, 46, 44, 58, 6, -44 },
  { 6496, 37, 44, 49, 6, -44 },
  { 6700, 41, 46, 49, 4, -45 },
  { 6936, 29, 44, 38, 6, -44 },
  { 7096, 41, 56, 49, 4, -45 },
  { 7383, 34, 44, 40, 6, -44 },
  { 7570, 29, 46, 34, 3, -45 },
  { 7737, 33, 44, 35, 1, -44 },
  { 7919, 36, 45, 46, 5, -44 },
  { 8122, 39, 44, 39, 0, -44 },
  { 8337, 59, 44, 59, 0, -44 },
  { 8662, 39, 44, 40, 0, -44 },
  { 8877, 37, 44, 37, 0, -44 },
  { 9081, 32, 44, 36, 2, -44 },
  { 9257, 14, 54, 20, 5, -44 },
  { 9352, 24, 45, 25, 0, -45 },
  { 9487, 14, 54, 20, 2, -44 },
  { 9582, 32, 29, 35, 2, -45 },
  { 9698, 26, 4, 26, 0, 6 },
  { 9711, 16, 9, 21, 2, -47 },
  { 9729, 29, 35, 36, 3, -34 },
  { 9856, 31, 48, 39, 5, -47 },
  { 10042, 26, 35, 31, 3, -34 },
  { 10156, 31, 48, 39, 3, -47 },
  { 10342, 30, 35, 36, 3, -34 },
  { 10474, 25, 47, 23, 1, -47 },
  { 10621, 31, 49, 39, 3, -34 },
  { 10811, 30, 47, 40, 5, -47 },
  { 10988, 9, 47, 18, 4, -47 },
  { 11041, 16, 62, 18, -3, -47 },
  { 11165, 31, 47, 36, 5, -47 },
  { 11348, 8, 47, 18, 5, -47 },
  { 11395, 50, 34, 60, 5, -34 },
  { 11608, 30, 34, 40, 5, -34 },
  { 11736, 32, 35, 38, 3, -34 },
  { 11876, 31, 49, 39, 5, -34 },
  { 12066, 31, 49, 39, 3, -34 },
  { 12256, 21, 34, 27, 5, -34 },
  { 12346, 25, 35, 31, 3, -34 },
  { 12456, 22, 42, 25, 1, -41 },
  { 12572, 30, 35, 40, 5, -34 },
  { 12704, 34, 34, 34, 0, -34 },
  { 12849, 50, 34, 51, 1, -34 },
  { 13062, 33, 34, 35, 1, -34 },
  { 13203, 34, 49, 34, 0, -34 },
  { 13412, 26, 34, 30, 2, -34 },
  { 13523, 21, 54, 24, 1, -44 },
  { 13665, 6, 61, 34, 14, -47 },
  { 13711, 21, 54, 24, 2, -44 },
  { 13853, 30, 10, 35, 3, -27 },
};

const GFXfont NotoSans_SemiBold62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMIBOLD62PT7B_H_
