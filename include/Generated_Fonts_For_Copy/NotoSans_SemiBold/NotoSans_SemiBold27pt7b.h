#ifndef _NOTOSANS_SEMIBOLD27PT7B_H_
#define _NOTOSANS_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x06, 0xFF, 0xF0, 0xE7,
  0xF3, 0xB9, 0xDC, 0xEE, 0x77, 0x1B, 0x8C, 0x07, 0x1C, 0x07, 0x18, 0x07,
  0x18, 0x06, 0x38, 0x06, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C,
  0x70, 0x0C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x18,
  0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x31, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x3F, 0xE7, 0xFF, 0xBF, 0xFB, 0xCC, 0x1E, 0x60, 0xF3, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x01, 0xFC, 0x0C, 0xE0, 0x67, 0xC3,
  0x7F, 0xFF, 0xBF, 0xF8, 0x3F, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x08,
  0x00, 0x40, 0xF8, 0x0E, 0x07, 0xF0, 0x38, 0x39, 0xC1, 0xC0, 0xE3, 0x86,
  0x03, 0x8E, 0x38, 0x0E, 0x38, 0xC0, 0x38, 0xE7, 0x00, 0xE3, 0xB8, 0xE3,
  0x9C, 0xEF, 0xC7, 0xF7, 0x3F, 0x8F, 0x9D, 0xC6, 0x08, 0xE7, 0x1C, 0x03,
  0x1C, 0x70, 0x1C, 0x71, 0xC0, 0x61, 0xC7, 0x03, 0x87, 0x18, 0x1C, 0x1C,
  0xE0, 0x70, 0x3F, 0x83, 0x80, 0x7C, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x1E, 0x78, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0F, 0x1C, 0x00, 0xEF,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x0F, 0x3F, 0xE1, 0xE7, 0x9E,
  0x39, 0xE1, 0xEF, 0x3C, 0x1F, 0xC7, 0x81, 0xF8, 0xF8, 0x3E, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF1, 0xF0, 0xFF, 0xFF, 0xF8, 0x1E, 0x38, 0xE1,
  0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x70,
  0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x80, 0xE0, 0xE0, 0xE1, 0xC3, 0x83, 0x87,
  0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xC7,
  0x8E, 0x38, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0C, 0x61, 0x7F,
  0xFF, 0xFF, 0xE1, 0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x70, 0x71, 0xC0, 0x88,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x7B,
  0x9C, 0xEE, 0x70, 0xFF, 0xFF, 0xF8, 0x6F, 0xFF, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x00, 0x02,
  0x00, 0xFE, 0x0F, 0xF8, 0xF9, 0xE7, 0x07, 0x38, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xEE,
  0x0F, 0x78, 0x71, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0x07, 0x8F, 0xCF, 0xEF,
  0xFF, 0x7B, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x02, 0x01, 0xFF, 0x1F, 0xFD, 0xF1,
  0xE6, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x01, 0xFF, 0x3F, 0xFC, 0xE1, 0xE4, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x03, 0xE0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xBF, 0xFC, 0xFF, 0x80,
  0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3B, 0x81, 0xCE,
  0x07, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0F,
  0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x00, 0x40, 0x3F, 0x87, 0xFC, 0x7C, 0x13,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF7, 0xE7, 0x7F, 0xBF, 0x3F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x78, 0x79, 0xFF, 0x8F, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x02, 0x00, 0xFF,
  0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0xB8, 0x3D, 0xC1, 0xEF, 0x1E, 0x3F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7B, 0xE7, 0x87, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x3B, 0xC7, 0xDF, 0xFC, 0x3F, 0x80, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xF3,
  0xEF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xDF, 0xFE,
  0xFF, 0x71, 0xF3, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF3, 0x7F, 0x1F,
  0xF0, 0xFE, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x73,
  0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xB9, 0xDE, 0xE7, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x04, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x80, 0x07,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x01,
  0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x02, 0x07, 0xFC,
  0xFF, 0xE7, 0x1F, 0x40, 0xF0, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x7C,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0xC1, 0xFC, 0x67, 0x1F, 0xF1, 0xDC, 0x71,
  0xC7, 0x63, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x30, 0x71, 0xF8, 0xC1, 0xC7,
  0xE3, 0x87, 0x19, 0x8E, 0x3C, 0xE6, 0x1F, 0xFF, 0x1C, 0x3C, 0x78, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x18, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xB8,
  0x01, 0xCE, 0x00, 0x73, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x81,
  0xE0, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x80, 0x71, 0xE0,
  0x1E, 0x78, 0x03, 0x9C, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xE3, 0xFF, 0xEF,
  0xFF, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x3E, 0xFF, 0xE3,
  0xFF, 0xCF, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x80, 0x3F, 0xF1, 0xFF, 0xCF,
  0xCF, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x04,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0,
  0x7C, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x40, 0x07, 0xFE, 0x1F,
  0xFE, 0x3F, 0x1E, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x78, 0xFF,
  0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xBE, 0xFE, 0xFC, 0xE0, 0x3F, 0x81, 0xEE, 0x0F, 0x38,
  0x78, 0xE3, 0xC3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x39, 0xE0, 0xE3, 0xC3, 0x87, 0x8E, 0x1E, 0x38, 0x3C, 0xE0, 0x7B,
  0x80, 0xEE, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFD, 0xC0, 0x7F, 0xDC, 0x07, 0xFF, 0xC0, 0x7F,
  0xEE, 0x0E, 0xFE, 0xE0, 0xEF, 0xEE, 0x0E, 0xFE, 0x71, 0xCF, 0xE7, 0x1C,
  0xFE, 0x71, 0xCF, 0xE3, 0xB8, 0xFE, 0x3B, 0x8F, 0xE3, 0xB0, 0xFE, 0x1F,
  0x0F, 0xE1, 0xF0, 0xFE, 0x1E, 0x0F, 0xE0, 0xE0, 0xF0, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x07, 0xDE, 0x07, 0xEF, 0x07, 0xE7,
  0x87, 0xE7, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1, 0xE7, 0xE0, 0xF7, 0xE0,
  0xF7, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x01,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFD, 0xFC, 0x78, 0x0F, 0x3C, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xE0, 0x1E, 0x7C,
  0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF,
  0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF,
  0xBF, 0xF9, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFD, 0xFC,
  0x78, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xEF, 0x00,
  0x7B, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0x3C,
  0x0E, 0x78, 0x3C, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0x8F, 0x0F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0x78,
  0x02, 0x00, 0xFF, 0x8F, 0xFC, 0xF9, 0xE7, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0xC0, 0x77, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0,
  0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x70,
  0xF0, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xDC, 0x07, 0x80, 0xE7, 0x03,
  0xE0, 0x79, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x0E, 0x0D, 0xC1, 0xC3,
  0x87, 0x70, 0xF0, 0xE1, 0xCE, 0x3C, 0x3C, 0x73, 0x8E, 0x07, 0x3C, 0xE3,
  0x81, 0xCE, 0x38, 0xE0, 0x73, 0x87, 0x78, 0x1E, 0xE1, 0xDC, 0x03, 0xF0,
  0x77, 0x00, 0xFC, 0x0D, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01,
  0xE0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x9C, 0x07, 0x8F, 0x07,
  0x83, 0xC3, 0x80, 0xE3, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0x71, 0xE0,
  0x78, 0xF0, 0x78, 0x3C, 0x38, 0x0E, 0x3C, 0x07, 0xBC, 0x01, 0xE0, 0xF0,
  0x0F, 0x78, 0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E,
  0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F,
  0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0xC0, 0x63,
  0x03, 0x8E, 0x0E, 0x18, 0x70, 0x71, 0xC0, 0xCE, 0x03, 0xB8, 0x07, 0xFF,
  0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0xC1, 0xFF, 0x8F, 0xFC,
  0x40, 0xF0, 0x07, 0x80, 0x3C, 0x3F, 0xE7, 0xFF, 0x78, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x9F, 0xBF, 0xDC, 0xFC, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3C, 0x3B, 0xF8, 0xFF, 0xF3,
  0xE1, 0xEF, 0x07, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0E,
  0xF0, 0x3B, 0xC1, 0xEF, 0xFF, 0xBB, 0xFC, 0xE7, 0xE0, 0x07, 0xC1, 0xFF,
  0x3F, 0xE7, 0x82, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x81, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF3, 0xCF, 0xFF, 0x3F, 0xFD,
  0xE1, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0x70, 0x3D, 0xE0, 0xF7, 0xFF, 0xCF, 0xF7, 0x1F, 0x9C, 0x07, 0xC0, 0x7F,
  0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x78, 0xFF, 0xE0, 0xFF, 0x00,
  0x01, 0x81, 0xFC, 0x7F, 0x8F, 0x01, 0xC0, 0x38, 0x0F, 0xF7, 0xFE, 0xFF,
  0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x0F, 0x1C, 0xFF, 0x73, 0xFF, 0xDE, 0x1F,
  0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x03,
  0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE7, 0x8F, 0x9F, 0xFC, 0x7F, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xCF, 0x1D, 0xFE, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDE,
  0xFD, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x07, 0xBC, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xEF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0F, 0x3C,
  0x1E, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE7, 0xC1, 0xE3, 0xBF, 0xDF, 0xEF, 0xFF, 0xFF, 0xBE, 0x3F,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xC0, 0xE3, 0xC7, 0x7F, 0xBF,
  0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xE0, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x77, 0x03, 0xDE, 0x0F, 0x3E, 0xF8, 0x7F, 0xC0, 0xFE, 0x00,
  0xE3, 0xC3, 0xBF, 0xCF, 0xFF, 0x3E, 0x1E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xFF, 0xF3, 0xBF,
  0xCE, 0x7E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x1C, 0xFF, 0x73, 0xFF, 0xDE, 0x1F, 0x70, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x7F, 0xFC,
  0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0xE3, 0xF7, 0xFB, 0xFF, 0x8F, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F, 0x8F, 0xFD, 0xFF, 0x78,
  0x2F, 0x01, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x3C, 0x03, 0xC0, 0x7F,
  0x3F, 0xFF, 0x9F, 0xE0, 0x18, 0x1C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0x3F, 0x8F,
  0xC0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFC, 0xE0, 0xF0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xE3, 0x83, 0x87,
  0x0F, 0x0F, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x3D, 0xC0, 0x3B, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x1D, 0xC1, 0xE0,
  0xF7, 0x07, 0xC3, 0xDE, 0x3F, 0x0E, 0x78, 0xEC, 0x38, 0xE3, 0xB9, 0xE3,
  0x8C, 0xE7, 0x0F, 0x73, 0x9C, 0x1D, 0xC6, 0x70, 0x77, 0x1B, 0xC1, 0xD8,
  0x7E, 0x07, 0x61, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C,
  0x00, 0x70, 0x1E, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xEF, 0x01, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC0, 0xE3, 0x83,
  0xC7, 0x8F, 0x07, 0xBC, 0x07, 0x00, 0xF0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3,
  0xC1, 0xE3, 0x83, 0x87, 0x0F, 0x0F, 0x1E, 0x0E, 0x38, 0x1C, 0xF0, 0x1D,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x8F, 0xC7, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x3E, 0x1C, 0x0F, 0x81, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE0, 0x71, 0xF8, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x87, 0x87, 0xC3, 0xC0, 0x10, 0x0B, 0xF8,
  0x7F, 0xFF, 0x87, 0xF8, 0x06, 0x00,
};

const GFXglyph NotoSans_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 19, 7, 2, -19 },
  { 11, 9, 7, 12, 2, -19 },
  { 19, 16, 19, 17, 1, -19 },
  { 57, 13, 23, 15, 1, -21 },
  { 95, 22, 20, 24, 1, -20 },
  { 150, 19, 20, 20, 1, -20 },
  { 198, 3, 7, 7, 2, -19 },
  { 201, 7, 23, 9, 1, -19 },
  { 222, 7, 23, 9, 1, -19 },
  { 243, 13, 13, 15, 1, -21 },
  { 265, 13, 13, 15, 1, -16 },
  { 287, 5, 6, 8, 1, -3 },
  { 291, 7, 3, 9, 1, -9 },
  { 294, 4, 4, 7, 2, -4 },
  { 296, 11, 19, 11, 0, -19 },
  { 323, 13, 20, 15, 1, -20 },
  { 356, 9, 19, 15, 2, -19 },
  { 378, 13, 20, 15, 1, -20 },
  { 411, 13, 20, 15, 1, -20 },
  { 444, 14, 19, 15, 1, -19 },
  { 478, 13, 19, 15, 1, -19 },
  { 509, 13, 20, 15, 1, -20 },
  { 542, 13, 19, 15, 1, -19 },
  { 573, 13, 20, 15, 1, -20 },
  { 606, 13, 20, 15, 1, -20 },
  { 639, 4, 15, 7, 2, -15 },
  { 647, 5, 18, 8, 1, -15 },
  { 659, 13, 14, 15, 1, -17 },
  { 682, 13, 7, 15, 1, -13 },
  { 694, 13, 14, 15, 1, -17 },
  { 717, 12, 20, 12, 0, -20 },
  { 747, 22, 21, 24, 1, -19 },
  { 805, 18, 19, 18, 0, -19 },
  { 848, 14, 19, 18, 2, -19 },
  { 882, 14, 20, 17, 2, -20 },
  { 917, 16, 19, 20, 2, -19 },
  { 955, 10, 19, 15, 3, -19 },
  { 979, 10, 19, 15, 3, -19 },
  { 1003, 16, 20, 20, 2, -20 },
  { 1043, 15, 19, 20, 3, -19 },
  { 1079, 8, 19, 10, 1, -19 },
  { 1098, 8, 24, 8, -2, -19 },
  { 1122, 14, 19, 17, 3, -19 },
  { 1156, 12, 19, 15, 2, -19 },
  { 1185, 20, 19, 25, 3, -19 },
  { 1233, 16, 19, 21, 3, -19 },
  { 1271, 18, 20, 21, 2, -20 },
  { 1316, 13, 19, 17, 2, -19 },
  { 1347, 18, 25, 21, 2, -20 },
  { 1404, 15, 19, 17, 2, -19 },
  { 1440, 13, 20, 15, 1, -20 },
  { 1473, 15, 19, 15, 0, -19 },
  { 1509, 16, 19, 20, 2, -19 },
  { 1547, 17, 19, 17, 0, -19 },
  { 1588, 26, 19, 26, 0, -19 },
  { 1650, 17, 19, 17, 0, -19 },
  { 1691, 16, 19, 16, 0, -19 },
  { 1729, 14, 19, 16, 1, -19 },
  { 1763, 6, 23, 9, 2, -19 },
  { 1781, 11, 19, 11, 0, -19 },
  { 1808, 6, 23, 9, 1, -19 },
  { 1826, 14, 12, 15, 1, -19 },
  { 1847, 11, 2, 11, 0, 2 },
  { 1850, 7, 5, 9, 1, -21 },
  { 1855, 13, 15, 16, 1, -15 },
  { 1880, 14, 21, 17, 2, -21 },
  { 1917, 12, 15, 14, 1, -15 },
  { 1940, 14, 21, 17, 1, -21 },
  { 1977, 14, 15, 16, 1, -15 },
  { 2004, 11, 21, 10, 0, -21 },
  { 2033, 14, 21, 17, 1, -15 },
  { 2070, 13, 21, 17, 2, -21 },
  { 2105, 4, 20, 8, 2, -20 },
  { 2115, 7, 26, 8, -1, -20 },
  { 2138, 14, 21, 16, 2, -21 },
  { 2175, 4, 21, 8, 2, -21 },
  { 2186, 22, 15, 26, 2, -15 },
  { 2228, 13, 15, 17, 2, -15 },
  { 2253, 14, 15, 17, 1, -15 },
  { 2280, 14, 21, 17, 2, -15 },
  { 2317, 14, 21, 17, 1, -15 },
  { 2354, 9, 15, 12, 2, -15 },
  { 2371, 11, 15, 13, 1, -15 },
  { 2392, 9, 18, 11, 1, -18 },
  { 2413, 13, 15, 17, 2, -15 },
  { 2438, 15, 15, 15, 0, -15 },
  { 2467, 22, 15, 22, 0, -15 },
  { 2509, 15, 15, 15, 0, -15 },
  { 2538, 15, 21, 15, 0, -15 },
  { 2578, 11, 15, 13, 1, -15 },
  { 2599, 9, 23, 11, 1, -19 },
  { 2625, 3, 26, 15, 6, -20 },
  { 2635, 9, 23, 11, 1, -19 },
  { 2661, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMIBOLD27PT7B_H_
