#ifndef _NOTOSANS_SEMIBOLD26PT7B_H_
#define _NOTOSANS_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x06, 0xEF, 0xE0, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0x07, 0x18, 0x0E, 0x70, 0x18, 0xE0,
  0x31, 0x80, 0xE3, 0x01, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x70, 0x18,
  0xC0, 0x71, 0x87, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x1C, 0x60,
  0x38, 0xC0, 0x63, 0x80, 0xC7, 0x00, 0x02, 0x00, 0x10, 0x01, 0xE0, 0x7F,
  0xE7, 0xFF, 0x79, 0x13, 0xC8, 0x1E, 0x40, 0x7A, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x01, 0x3C, 0x09, 0xF8, 0x4F, 0xFF, 0xF7, 0xFF, 0x0F,
  0xE0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x1C, 0x03, 0x83, 0xF0, 0x18, 0x1D,
  0xC1, 0xC1, 0xCE, 0x1C, 0x0E, 0x30, 0xE0, 0x71, 0x8E, 0x03, 0x8C, 0x60,
  0x1C, 0x67, 0x00, 0xE7, 0x33, 0xE3, 0xBB, 0xBF, 0x9F, 0x99, 0x8C, 0x79,
  0xCC, 0x70, 0x1C, 0xE3, 0x80, 0xE7, 0x1C, 0x0E, 0x38, 0xE0, 0x70, 0xC7,
  0x07, 0x07, 0x30, 0x30, 0x3F, 0x83, 0x80, 0xF8, 0x07, 0x80, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0xCE, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0xE7, 0xFC, 0x39, 0xE7, 0x9E, 0xF0,
  0xF7, 0x3C, 0x1F, 0xCF, 0x03, 0xE3, 0xC0, 0xF8, 0x7F, 0xFF, 0x1F, 0xFD,
  0xE1, 0xFC, 0x3C, 0xFF, 0xFF, 0xF0, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC3,
  0x83, 0x87, 0x80, 0xE1, 0x87, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x71, 0xCE, 0x00, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xE6, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0x9C,
  0x79, 0xE1, 0x88, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0x7B, 0x9C, 0xCE, 0x70, 0xFF, 0xF0, 0x4E, 0xFE, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x00, 0x0F, 0x81, 0xFE,
  0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x39, 0xC1, 0xCE, 0x1E, 0x7D,
  0xE1, 0xFF, 0x07, 0xF0, 0x07, 0x0F, 0x1F, 0x3F, 0xF7, 0xE7, 0x47, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x81, 0xFF, 0x3F, 0xF8, 0xE1, 0xE2, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xC1,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x1F, 0xC0, 0xFC, 0x07, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1E, 0xF3, 0xF7, 0xFF, 0x1F,
  0xF0, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1D, 0xC0,
  0x67, 0x03, 0x9C, 0x1C, 0x70, 0x61, 0xC3, 0x87, 0x1C, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0xE0,
  0x7F, 0xE3, 0xFF, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xD0,
  0x1E, 0xFF, 0xF7, 0xFF, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x87, 0xFC, 0x78,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0xF8, 0xEF, 0xE7, 0xFF, 0xBC, 0x1F,
  0xE0, 0xFE, 0x03, 0xF0, 0x1D, 0xC1, 0xEE, 0x0E, 0x7D, 0xF1, 0xFF, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xC7, 0xBC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xF8, 0xF1, 0xEF, 0x07, 0x70, 0x1F, 0x80, 0xFE, 0x0F, 0x78, 0xF3,
  0xFF, 0x07, 0xF0, 0x0F, 0x01, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xF0, 0x7B, 0xCF, 0xDF, 0xEE, 0x7E, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x4F, 0xE3, 0xFE, 0x1F, 0xC0, 0xEF, 0xE4,
  0x00, 0x00, 0x00, 0x4E, 0xFE, 0x73, 0xDC, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xE7, 0x3B, 0x9C, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xE0, 0x0C, 0x00,
  0x00, 0x1F, 0x1F, 0xF9, 0xFF, 0xB0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0x07, 0x1C, 0x3E, 0x19, 0xC7, 0xFC, 0xEE, 0x38,
  0xC7, 0x63, 0x86, 0x1F, 0x18, 0x30, 0xF9, 0xC1, 0x87, 0xCE, 0x0C, 0x7E,
  0x30, 0xE3, 0xF1, 0xC7, 0x19, 0x8F, 0xEF, 0xCE, 0x3E, 0x7C, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B,
  0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x3C, 0x0F, 0x0E, 0x07, 0x07, 0x03,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x07,
  0xB8, 0x03, 0xFC, 0x00, 0xE0, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xBC, 0x3E,
  0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF,
  0xBC, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x63, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB, 0xFF, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0xFC, 0xFF, 0xF3, 0xF0, 0x67, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xBC, 0x07, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x38, 0xFF,
  0xFF, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3C, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0xFE, 0xFC, 0xF8, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xE7,
  0x87, 0x8F, 0x0E, 0x1E, 0x38, 0x3C, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xDE, 0x0F, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x38,
  0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0x78, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xEC, 0x03, 0x7E, 0xE0, 0x77,
  0xEE, 0x07, 0x7E, 0x60, 0x67, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE3, 0x0C,
  0x7E, 0x39, 0xC7, 0xE3, 0x9C, 0x7E, 0x19, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x70, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEF, 0x07, 0xE7, 0x07, 0xE7,
  0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0,
  0x77, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x3C, 0x78, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x78, 0xF0, 0x3E, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFC, 0x07, 0xFF, 0x3F, 0xFD, 0xE1,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0xFF, 0xBF, 0xF9,
  0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x3C, 0x78, 0x07,
  0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7,
  0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x78, 0xF0,
  0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0x87,
  0x8F, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x0F, 0x1C, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x38, 0xF0,
  0x79, 0xE0, 0x7B, 0xC0, 0xF8, 0x0F, 0x83, 0xFF, 0x7F, 0xF7, 0x86, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x07,
  0xBC, 0x0F, 0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x70, 0x0E, 0x78, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C,
  0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xE0, 0x1C,
  0x07, 0xF8, 0x1E, 0x03, 0x9C, 0x0F, 0x81, 0xCE, 0x07, 0xC0, 0xE7, 0x03,
  0xE0, 0xF3, 0xC3, 0xB0, 0x70, 0xE1, 0xDC, 0x38, 0x70, 0xEE, 0x1C, 0x38,
  0x67, 0x1E, 0x1E, 0x71, 0x8E, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x73, 0x81,
  0xDC, 0x3B, 0xC0, 0xFE, 0x0D, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0x81, 0xF8, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F,
  0x78, 0x0E, 0x38, 0x1E, 0x3C, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x70,
  0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x70,
  0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78,
  0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xF0, 0x1C, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x38,
  0x03, 0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x06, 0x1C, 0x70, 0x63,
  0x83, 0x98, 0x0D, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xF0,
  0x3F, 0xC3, 0xFE, 0x30, 0xF0, 0x07, 0x00, 0x70, 0x3F, 0x3F, 0xF7, 0xC7,
  0xF0, 0x7E, 0x07, 0xF0, 0xFF, 0x9F, 0x7F, 0xF3, 0xF3, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x1F, 0xFC, 0xFD, 0xF7,
  0x83, 0xBC, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0,
  0x77, 0xEF, 0xBF, 0xF9, 0xCF, 0x80, 0x0F, 0xE7, 0xFD, 0xF3, 0xBC, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3F, 0xF3, 0xFE,
  0x3F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x7E, 0xE7, 0xFF, 0x7C, 0xFB, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xEE, 0x07, 0x78, 0x7B, 0xEF, 0xCF, 0xFE, 0x3F, 0x70, 0x1F,
  0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xF7, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x63, 0xFF, 0x07, 0xF8, 0x07, 0xC1,
  0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0xE7, 0xFC, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x1F, 0xB9, 0xFF, 0xDF, 0x3E, 0xE0, 0xF7, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x81, 0xDC, 0x1E, 0xF9, 0xF3, 0xFF, 0x8F,
  0xDC, 0x00, 0xE0, 0x07, 0x40, 0x7B, 0xCF, 0xDF, 0xFC, 0x7F, 0x80, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x9D, 0xFE,
  0xF8, 0xF7, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xF0, 0x4E, 0xFE, 0x00, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x08, 0x38, 0x78, 0xE0, 0x00, 0x07,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x7E, 0xFD, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x81, 0xFC, 0x1C, 0xE1, 0xC7, 0x1C, 0x39, 0xE1, 0xDE,
  0x0F, 0xF0, 0x7F, 0x83, 0xDE, 0x1C, 0x78, 0xE1, 0xE7, 0x07, 0x38, 0x3D,
  0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xE7,
  0xE7, 0xFF, 0x7F, 0xBE, 0x7F, 0x3F, 0xE1, 0xF0, 0xFF, 0x07, 0x03, 0xF0,
  0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1C, 0xEF,
  0xE7, 0xFF, 0xBF, 0x3D, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3C, 0x1F, 0xE0,
  0xFF, 0xC7, 0xCF, 0x9C, 0x0E, 0x70, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3D, 0xC0, 0xE7, 0x83, 0x9F, 0x3E, 0x3F, 0xF0, 0x3F, 0x00, 0xE7,
  0xC7, 0xFF, 0x3F, 0x7D, 0xE0, 0xEF, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x83, 0xFC, 0x1D, 0xFB, 0xEF, 0xFE, 0x77, 0xE3, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0xB9, 0xFF, 0xDF,
  0x3E, 0xE0, 0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x81,
  0xDC, 0x1E, 0xFB, 0xF3, 0xFF, 0x8F, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0xE7, 0xF7, 0xFF, 0xFF, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0xCF, 0xFB,
  0xC3, 0x70, 0x0F, 0x00, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xC0, 0x3C, 0x07,
  0xF1, 0xEF, 0xFC, 0xFF, 0x00, 0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xFB, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF2, 0x7F, 0x1F,
  0x80, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xF3, 0xF7, 0xFB, 0x9F, 0x9C,
  0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x70, 0xE1, 0xC1, 0xC7,
  0x07, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x78, 0x3B, 0x83, 0xC1, 0xDC, 0x3E, 0x1E, 0xE1, 0xF8, 0xE3,
  0x8D, 0xC7, 0x1C, 0xEE, 0x38, 0xE7, 0x33, 0x87, 0xB9, 0xDC, 0x1D, 0x8E,
  0xE0, 0xFC, 0x37, 0x07, 0xE1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x07,
  0x81, 0xC0, 0xF8, 0x3C, 0xE1, 0xE3, 0xC7, 0x07, 0xBC, 0x0F, 0xE0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0x7B, 0x81, 0xCF, 0x0F, 0x1E, 0x78,
  0x3B, 0xC0, 0xF0, 0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x78,
  0xE1, 0xC1, 0xC7, 0x07, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x02, 0x78, 0x07, 0xE0,
  0x1F, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x0F,
  0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xE0, 0xF8, 0x38,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x78, 0x3E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1E, 0x07, 0xE0, 0xF0, 0xF8, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x87, 0xC3, 0xC0, 0x7C, 0x0F, 0xFF, 0xF1, 0xFF, 0x03,
  0xC0,
};

const GFXglyph NotoSans_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 19, 7, 2, -19 },
  { 11, 8, 7, 12, 2, -19 },
  { 18, 15, 19, 17, 1, -19 },
  { 54, 13, 22, 15, 1, -20 },
  { 90, 21, 19, 23, 1, -19 },
  { 140, 18, 19, 19, 1, -19 },
  { 183, 3, 7, 7, 2, -19 },
  { 186, 7, 23, 8, 1, -19 },
  { 207, 6, 23, 8, 1, -19 },
  { 225, 12, 12, 14, 1, -20 },
  { 243, 13, 13, 15, 1, -16 },
  { 265, 5, 6, 7, 1, -3 },
  { 269, 6, 2, 8, 1, -8 },
  { 271, 4, 4, 7, 2, -4 },
  { 273, 10, 19, 10, 0, -19 },
  { 297, 13, 19, 15, 1, -19 },
  { 328, 8, 19, 15, 2, -19 },
  { 347, 13, 19, 15, 1, -19 },
  { 378, 13, 19, 15, 1, -19 },
  { 409, 14, 19, 15, 0, -19 },
  { 443, 13, 19, 15, 1, -19 },
  { 474, 13, 19, 15, 1, -19 },
  { 505, 13, 19, 15, 1, -19 },
  { 536, 13, 19, 15, 1, -19 },
  { 567, 13, 19, 15, 1, -19 },
  { 598, 4, 14, 7, 2, -14 },
  { 605, 5, 17, 7, 1, -14 },
  { 616, 13, 13, 15, 1, -16 },
  { 638, 13, 8, 15, 1, -13 },
  { 651, 13, 13, 15, 1, -16 },
  { 673, 11, 19, 12, 0, -19 },
  { 700, 21, 21, 23, 1, -19 },
  { 756, 17, 19, 17, 0, -19 },
  { 797, 14, 19, 17, 2, -19 },
  { 831, 15, 19, 17, 1, -19 },
  { 867, 16, 19, 19, 2, -19 },
  { 905, 11, 19, 15, 2, -19 },
  { 932, 11, 19, 14, 2, -19 },
  { 959, 15, 19, 19, 2, -19 },
  { 995, 15, 19, 20, 2, -19 },
  { 1031, 8, 19, 10, 1, -19 },
  { 1050, 8, 24, 8, -2, -19 },
  { 1074, 15, 19, 17, 2, -19 },
  { 1110, 11, 19, 14, 2, -19 },
  { 1137, 20, 19, 24, 2, -19 },
  { 1185, 16, 19, 21, 2, -19 },
  { 1223, 18, 19, 20, 1, -19 },
  { 1266, 13, 19, 16, 2, -19 },
  { 1297, 18, 23, 20, 1, -19 },
  { 1349, 15, 19, 17, 2, -19 },
  { 1385, 12, 19, 14, 1, -19 },
  { 1414, 14, 19, 15, 0, -19 },
  { 1448, 15, 19, 19, 2, -19 },
  { 1484, 16, 19, 16, 0, -19 },
  { 1522, 25, 19, 25, 0, -19 },
  { 1582, 16, 19, 17, 0, -19 },
  { 1620, 16, 19, 16, 0, -19 },
  { 1658, 13, 19, 15, 1, -19 },
  { 1689, 6, 23, 9, 2, -19 },
  { 1707, 10, 19, 10, 0, -19 },
  { 1731, 6, 23, 9, 1, -19 },
  { 1749, 13, 12, 15, 1, -19 },
  { 1769, 11, 2, 11, 0, 2 },
  { 1772, 7, 4, 9, 1, -20 },
  { 1776, 12, 14, 15, 1, -14 },
  { 1797, 13, 20, 16, 2, -20 },
  { 1830, 11, 14, 13, 1, -14 },
  { 1850, 13, 20, 16, 1, -20 },
  { 1883, 13, 14, 15, 1, -14 },
  { 1906, 11, 20, 10, 0, -20 },
  { 1934, 13, 20, 16, 1, -14 },
  { 1967, 13, 20, 17, 2, -20 },
  { 2000, 4, 20, 7, 2, -20 },
  { 2010, 7, 26, 7, -1, -20 },
  { 2033, 13, 20, 15, 2, -20 },
  { 2066, 3, 20, 7, 2, -20 },
  { 2074, 21, 14, 25, 2, -14 },
  { 2111, 13, 14, 17, 2, -14 },
  { 2134, 14, 14, 16, 1, -14 },
  { 2159, 13, 20, 16, 2, -14 },
  { 2192, 13, 20, 16, 1, -14 },
  { 2225, 9, 14, 11, 2, -14 },
  { 2241, 11, 14, 13, 1, -14 },
  { 2261, 9, 17, 11, 1, -17 },
  { 2281, 13, 14, 17, 2, -14 },
  { 2304, 14, 14, 14, 0, -14 },
  { 2329, 21, 14, 22, 0, -14 },
  { 2366, 14, 14, 15, 0, -14 },
  { 2391, 14, 20, 14, 0, -14 },
  { 2426, 11, 14, 13, 1, -14 },
  { 2446, 8, 23, 10, 1, -19 },
  { 2469, 2, 26, 14, 6, -20 },
  { 2476, 9, 23, 10, 1, -19 },
  { 2502, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMIBOLD26PT7B_H_
