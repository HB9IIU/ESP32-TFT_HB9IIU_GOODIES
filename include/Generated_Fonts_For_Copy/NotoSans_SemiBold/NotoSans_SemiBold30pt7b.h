#ifndef _NOTOSANS_SEMIBOLD30PT7B_H_
#define _NOTOSANS_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x00, 0x0F, 0xFF, 0xF0,
  0xF3, 0xFC, 0xFE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0x06, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x9E, 0x62, 0x78, 0xC0,
  0x71, 0x80, 0xFB, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xCF, 0x01, 0x9F, 0x03, 0x3D, 0xE7, 0xF3, 0xFF, 0xE7, 0xFF,
  0x00, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x3F,
  0x00, 0xE0, 0x7F, 0x81, 0xE0, 0x73, 0x81, 0xC0, 0xE1, 0xC3, 0x80, 0xE1,
  0xC3, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xCE, 0x00, 0xE1,
  0xCE, 0x7C, 0x73, 0x9C, 0xFE, 0x7F, 0xBD, 0xEE, 0x3F, 0x39, 0xC7, 0x0E,
  0x71, 0xC7, 0x00, 0x73, 0xC7, 0x00, 0xE3, 0x87, 0x00, 0xE3, 0xC7, 0x01,
  0xC1, 0xC7, 0x01, 0xC1, 0xC7, 0x03, 0x81, 0xCE, 0x07, 0x80, 0xFE, 0x07,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7C, 0xF8,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xCF, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xE3, 0xFF, 0x0F,
  0x3C, 0x7C, 0xF1, 0xE1, 0xF7, 0x9E, 0x07, 0xF8, 0xF0, 0x1F, 0xC7, 0xC0,
  0x7C, 0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0x07, 0xF8, 0x7C,
  0xFF, 0xEE, 0xEE, 0xE0, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78,
  0x38, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1C,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0xC3, 0x07, 0xED, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x3F, 0x01, 0xEE, 0x0F, 0x3C, 0x3C, 0x78, 0x21, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x7B, 0xDE, 0xE7, 0x73, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x03, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE1, 0xF7, 0xC7, 0x83, 0xCF, 0x07, 0x9C, 0x07, 0x78,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x1C, 0xF0, 0x78, 0xF1, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0xFB, 0xDC, 0xF2,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0xE1, 0xFF,
  0xE7, 0xFF, 0xE7, 0x03, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0xE7, 0xE2, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0x01,
  0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x38, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7A, 0x03, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFC, 0x23, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x71, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xF3,
  0xEF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x70, 0x1E, 0xF0, 0x3D,
  0xF0, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x9E,
  0x0F, 0x3C, 0x1E, 0x3C, 0x78, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x83, 0xEF,
  0x8F, 0x0F, 0x9C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFB,
  0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xE3,
  0xF7, 0xC7, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3D, 0xE0, 0xFB, 0xFF, 0xF3, 0xFF, 0xE3, 0xFB, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x00,
  0x6F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x33, 0xDE, 0xF3,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x73, 0xBD, 0xCE, 0x00, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1E, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0x38, 0x00, 0x40, 0x00, 0x07, 0x03, 0xFF, 0x3F, 0xFC, 0xFB, 0xF4, 0x07,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7C, 0x07, 0x81, 0xE0, 0x03, 0x87, 0x00, 0x03, 0x9C, 0x0F, 0xC7,
  0xB8, 0x7F, 0xC7, 0xE1, 0xFF, 0x8F, 0xC7, 0x87, 0x0F, 0x8E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x3C, 0x70, 0x38, 0x78, 0xE0, 0x71, 0xF0, 0xE1, 0xE3, 0xF1,
  0xC3, 0xC7, 0xE3, 0xFF, 0xFD, 0xC3, 0xFB, 0xF3, 0xC0, 0xC1, 0x83, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x38, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x70, 0x1E, 0x07,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0x78, 0x1E, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7E,
  0x02, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9E, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x78,
  0x7F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0x13, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x03,
  0xBE, 0x01, 0xCF, 0x80, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x78, 0xFF, 0xFF, 0xCF, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x1F, 0xDF, 0xFF, 0xF8, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x3E, 0xFF,
  0x7F, 0x3E, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0,
  0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xF3, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xDF, 0xB8, 0x07, 0x7E, 0xE0, 0x3D,
  0xFB, 0xC0, 0xEF, 0xE7, 0x03, 0xBF, 0x9C, 0x1C, 0xFE, 0x78, 0x73, 0xF8,
  0xE1, 0xCF, 0xE3, 0x8E, 0x3F, 0x8F, 0x38, 0xFE, 0x1C, 0xE3, 0xF8, 0x77,
  0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0x83, 0xF8, 0x3E, 0x0F,
  0xE0, 0x78, 0x3C, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x01, 0xFB, 0xC0, 0x7E, 0xF8, 0x1F, 0x9E, 0x07, 0xE3, 0xC1, 0xF8,
  0xF8, 0x7E, 0x1E, 0x1F, 0x87, 0xC7, 0xE0, 0xF1, 0xF8, 0x1E, 0x7E, 0x07,
  0xDF, 0x80, 0xF7, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7C, 0x07, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E,
  0x3E, 0x07, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7C, 0x07, 0xC7,
  0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1F, 0x03, 0xC0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE, 0x78, 0x09, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFE, 0x07, 0xFF, 0xFE,
  0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0x3E, 0x0F, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0xF0, 0x01,
  0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF7, 0x00, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x81,
  0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE3, 0x81, 0xDC, 0x1E, 0x3C, 0x3D, 0xC1,
  0xE3, 0xC3, 0xDC, 0x1C, 0x3C, 0x39, 0xE3, 0xC1, 0xC3, 0x9E, 0x3C, 0x1E,
  0x78, 0xE3, 0xC1, 0xE7, 0x8E, 0x38, 0x1E, 0x70, 0xF7, 0x80, 0xE7, 0x07,
  0x78, 0x0F, 0xF0, 0x77, 0x80, 0xFE, 0x07, 0x70, 0x07, 0xE0, 0x77, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE7, 0x80, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0xF0, 0x1E, 0x3C,
  0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xDE, 0x01, 0xE3, 0xC0, 0xF8, 0xF0,
  0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x18, 0x70, 0x70, 0x70, 0xE0, 0xE3,
  0x80, 0xE7, 0x01, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C,
  0x3C, 0x0E, 0x07, 0x00, 0x80, 0x7F, 0xC3, 0xFF, 0x87, 0x1F, 0x10, 0x3C,
  0x00, 0xF0, 0x01, 0xC3, 0xFF, 0x3F, 0xFD, 0xFC, 0x77, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xF7, 0xFF, 0xDF, 0xF7, 0x3F, 0x9C, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x30, 0x7B, 0xF8,
  0xFF, 0xF9, 0xFF, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE1, 0xEF, 0xFF,
  0xDF, 0xFF, 0x38, 0xFC, 0x00, 0x01, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x04, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x83, 0x8F, 0xE7,
  0x3F, 0xEE, 0x7F, 0xFD, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xEE, 0x01, 0xFC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xE1, 0xF3, 0xFF,
  0xE3, 0xFD, 0xC3, 0xF3, 0x80, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xF3,
  0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFD,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x8F, 0xFF, 0x0F, 0xFE, 0x07,
  0xFC, 0x07, 0xE3, 0xFC, 0x7F, 0x9F, 0x13, 0xC0, 0x78, 0x0F, 0x07, 0xFE,
  0xFF, 0xDF, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x03, 0x00, 0x3F,
  0x9C, 0xFF, 0xB9, 0xFF, 0xF7, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07,
  0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0xC0, 0x77, 0x81, 0xEF, 0x83, 0xCF,
  0xFF, 0x8F, 0xF7, 0x0F, 0xCE, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF2, 0x03,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x10, 0x7B, 0xFC, 0xFF, 0xFD, 0xFF,
  0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0x80, 0x2F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x02, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFC, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E,
  0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78,
  0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x20, 0x7B, 0xFC, 0xFF,
  0x3F, 0xFE, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0x83, 0xE0, 0xF7, 0xC1, 0xF0,
  0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x38, 0x0F, 0xF0, 0x1C, 0x07, 0xF8, 0x0E,
  0x03, 0xFC, 0x07, 0x01, 0xFE, 0x03, 0x80, 0xFF, 0x01, 0xC0, 0x7F, 0x80,
  0xE0, 0x3F, 0xC0, 0x70, 0x1F, 0xE0, 0x38, 0x0F, 0xF0, 0x1C, 0x07, 0x80,
  0x00, 0x41, 0xCF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x80, 0x0F, 0xF0,
  0x1F, 0xFC, 0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E,
  0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0xC1, 0xEF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x87, 0xBF, 0xFF, 0x7F, 0xFC,
  0xF3, 0xF1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x02, 0x00, 0x3F, 0x9C, 0xFF, 0xB9, 0xFF, 0xF7, 0xC1,
  0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B,
  0xC0, 0x77, 0x81, 0xEF, 0x83, 0xCF, 0xFF, 0x8F, 0xF7, 0x0F, 0xCE, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0xDC, 0x7F, 0xDF, 0x7F, 0xEF, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00,
  0x02, 0x01, 0xFF, 0x9F, 0xFC, 0xF0, 0xCF, 0x00, 0x78, 0x01, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0xE0, 0x3B, 0xFF,
  0xDF, 0xFC, 0x7F, 0xC0, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xF1, 0xFC, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x87, 0xEF, 0xFF, 0xDF, 0xFF, 0x8F, 0xC7, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1C,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xBC, 0x1F,
  0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x0E, 0xE1, 0xE3, 0x87, 0x70, 0xE1, 0xE3,
  0xB8, 0xF0, 0xF3, 0xDC, 0x78, 0x79, 0xC7, 0x38, 0x1C, 0xE3, 0xBC, 0x0F,
  0x71, 0xDE, 0x07, 0xB8, 0xEF, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x1E,
  0x0F, 0x0F, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE3,
  0xC1, 0xE0, 0xF1, 0xF0, 0x79, 0xF0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x38, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x3C, 0x0E,
  0x78, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7C, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC3, 0xF1, 0xF8, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC3, 0xF0, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x3F, 0x0F, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0x0F, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x3F, 0x03, 0xC3, 0xF1, 0xF0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC3, 0xF0, 0xF8, 0x30,
  0x00, 0x3E, 0x02, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xE8, 0x07, 0x00,
};

const GFXglyph NotoSans_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 10, 7, 14, 2, -21 },
  { 21, 18, 21, 19, 1, -21 },
  { 69, 15, 25, 17, 1, -23 },
  { 116, 24, 22, 26, 1, -22 },
  { 182, 21, 22, 22, 1, -22 },
  { 240, 4, 7, 8, 2, -21 },
  { 244, 8, 26, 10, 1, -21 },
  { 270, 8, 26, 10, 1, -21 },
  { 296, 14, 14, 16, 1, -23 },
  { 321, 15, 15, 17, 1, -18 },
  { 350, 5, 7, 8, 1, -3 },
  { 355, 8, 4, 10, 1, -10 },
  { 359, 4, 4, 8, 2, -4 },
  { 361, 12, 22, 12, 0, -22 },
  { 394, 15, 22, 17, 1, -22 },
  { 436, 10, 21, 17, 2, -21 },
  { 463, 15, 22, 17, 1, -22 },
  { 505, 15, 22, 17, 1, -22 },
  { 547, 16, 21, 17, 1, -21 },
  { 589, 14, 21, 17, 2, -21 },
  { 626, 15, 22, 17, 1, -22 },
  { 668, 15, 21, 17, 1, -21 },
  { 708, 15, 22, 17, 1, -22 },
  { 750, 15, 22, 17, 1, -22 },
  { 792, 4, 17, 8, 2, -17 },
  { 801, 5, 21, 8, 1, -17 },
  { 815, 15, 16, 17, 1, -19 },
  { 845, 15, 9, 17, 1, -15 },
  { 862, 15, 16, 17, 1, -19 },
  { 892, 13, 22, 14, 0, -22 },
  { 928, 23, 25, 27, 2, -22 },
  { 1000, 20, 22, 20, 0, -22 },
  { 1055, 15, 21, 20, 3, -21 },
  { 1095, 16, 22, 19, 2, -22 },
  { 1139, 17, 21, 22, 3, -21 },
  { 1184, 12, 21, 17, 3, -21 },
  { 1216, 12, 21, 16, 3, -21 },
  { 1248, 17, 22, 22, 2, -22 },
  { 1295, 17, 21, 23, 3, -21 },
  { 1340, 9, 21, 11, 1, -21 },
  { 1364, 9, 27, 9, -2, -21 },
  { 1395, 16, 21, 19, 3, -21 },
  { 1437, 12, 21, 16, 3, -21 },
  { 1469, 22, 21, 28, 3, -21 },
  { 1527, 18, 21, 24, 3, -21 },
  { 1575, 20, 22, 24, 2, -22 },
  { 1630, 14, 21, 18, 3, -21 },
  { 1667, 20, 27, 24, 2, -22 },
  { 1735, 16, 21, 19, 3, -21 },
  { 1777, 14, 22, 17, 1, -22 },
  { 1816, 17, 21, 17, 0, -21 },
  { 1861, 17, 21, 22, 3, -21 },
  { 1906, 19, 21, 19, 0, -21 },
  { 1956, 28, 21, 29, 0, -21 },
  { 2030, 19, 21, 19, 0, -21 },
  { 2080, 18, 21, 18, 0, -21 },
  { 2128, 15, 21, 17, 1, -21 },
  { 2168, 7, 26, 10, 2, -21 },
  { 2191, 12, 22, 12, 0, -22 },
  { 2224, 7, 26, 10, 1, -21 },
  { 2247, 15, 14, 17, 1, -22 },
  { 2274, 13, 2, 13, 0, 3 },
  { 2278, 8, 5, 10, 1, -23 },
  { 2283, 14, 17, 18, 1, -17 },
  { 2313, 15, 23, 19, 2, -23 },
  { 2357, 13, 17, 15, 1, -17 },
  { 2385, 15, 23, 19, 1, -23 },
  { 2429, 15, 17, 18, 1, -17 },
  { 2461, 11, 23, 11, 1, -23 },
  { 2493, 15, 24, 19, 1, -17 },
  { 2538, 15, 23, 19, 2, -23 },
  { 2582, 4, 23, 8, 2, -23 },
  { 2594, 8, 30, 8, -2, -23 },
  { 2624, 16, 23, 18, 2, -23 },
  { 2670, 4, 23, 8, 2, -23 },
  { 2682, 25, 17, 29, 2, -17 },
  { 2736, 15, 17, 19, 2, -17 },
  { 2768, 16, 17, 19, 1, -17 },
  { 2802, 15, 24, 19, 2, -17 },
  { 2847, 15, 24, 19, 1, -17 },
  { 2892, 11, 17, 13, 2, -17 },
  { 2916, 13, 17, 15, 1, -17 },
  { 2944, 10, 20, 12, 1, -20 },
  { 2969, 15, 16, 19, 2, -16 },
  { 2999, 16, 16, 16, 0, -16 },
  { 3031, 25, 16, 25, 0, -16 },
  { 3081, 17, 16, 17, 0, -16 },
  { 3115, 16, 23, 16, 0, -16 },
  { 3161, 13, 16, 15, 1, -16 },
  { 3187, 10, 26, 12, 1, -21 },
  { 3220, 3, 30, 17, 7, -23 },
  { 3232, 10, 26, 12, 1, -21 },
  { 3265, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMIBOLD30PT7B_H_
