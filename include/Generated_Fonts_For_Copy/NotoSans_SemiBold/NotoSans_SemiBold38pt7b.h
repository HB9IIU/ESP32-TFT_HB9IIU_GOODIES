#ifndef _NOTOSANS_SEMIBOLD38PT7B_H_
#define _NOTOSANS_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF7, 0xC4, 0xF8, 0xFB,
  0xC7, 0xDE, 0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0x79, 0xE1, 0xCF, 0x0E, 0x70,
  0x73, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF3, 0x1C, 0xF8, 0xC0, 0x3E, 0x30, 0x0F, 0x8C, 0x03, 0xF3, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x0D, 0xFC, 0x03, 0x1F, 0x00, 0xC7, 0xC0, 0x31, 0xFC, 0x0C,
  0x7F, 0xFB, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0x00, 0xFF, 0x80, 0x3C, 0x03, 0xFF, 0x80, 0x78, 0x07, 0x8F,
  0x01, 0xE0, 0x0F, 0x1E, 0x03, 0xC0, 0x1C, 0x1E, 0x0F, 0x00, 0x78, 0x3C,
  0x3C, 0x00, 0xF0, 0x78, 0x78, 0x01, 0xE0, 0xF1, 0xE0, 0x03, 0xC1, 0xE3,
  0xC0, 0x03, 0x83, 0xCF, 0x0E, 0x07, 0x8F, 0x1E, 0x7F, 0x0F, 0x1E, 0x79,
  0xFF, 0x0F, 0xFC, 0xF3, 0xFF, 0x1F, 0xF3, 0xCF, 0x1E, 0x1F, 0xCF, 0x1E,
  0x1C, 0x04, 0x1E, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x78, 0x00, 0xF0, 0xE0,
  0xF0, 0x03, 0xC1, 0xC1, 0xE0, 0x07, 0x83, 0x83, 0xC0, 0x1E, 0x07, 0x87,
  0x80, 0x3C, 0x0F, 0x0E, 0x00, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x1F, 0xF8,
  0x07, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xF8, 0xFF, 0xE0, 0x7C,
  0x7E, 0xFC, 0x1F, 0x3F, 0x1F, 0x87, 0xCF, 0x83, 0xF3, 0xE3, 0xE0, 0x3E,
  0xF8, 0xF8, 0x07, 0xFC, 0x3E, 0x00, 0xFF, 0x0F, 0x80, 0x1F, 0x83, 0xF0,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xF1, 0xF8,
  0x3F, 0xF0, 0x3F, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x80, 0x07, 0x87,
  0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1,
  0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x80,
  0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x10, 0x38, 0x17, 0xCE, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xBC, 0x03,
  0xCF, 0x81, 0xF1, 0xE0, 0x7C, 0x7C, 0x0E, 0x0C, 0x00, 0x82, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x1E,
  0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7C, 0x40,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0x7F, 0x1F, 0x07, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFD, 0xF7, 0x1F, 0x61, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9E, 0x07,
  0xE2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0x7F, 0x9C, 0x07, 0xE4, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x03, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF0, 0xF8, 0x1E,
  0x0F, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xEC, 0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x84, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x1F, 0xC3, 0xDF, 0xFC, 0xF7, 0xFF, 0xBF, 0xCF, 0xEF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF,
  0x87, 0xFF, 0xF1, 0xF8, 0x7E, 0x7C, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x79,
  0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x87, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xF8, 0xFC, 0xFC, 0x0F, 0xBE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xDF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E,
  0x00, 0xF3, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x7E, 0xFF, 0x7F, 0xCF, 0xFF, 0x78, 0xFF, 0xDF, 0x0F,
  0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC1, 0xDF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x79, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7C, 0x40, 0x3C, 0x7D, 0xFB, 0xF3, 0xE3,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9,
  0xE7, 0xCF, 0x1E, 0x3C, 0xF1, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x8F, 0x01, 0xFE, 0x1E, 0x78, 0x1F, 0xFC,
  0x39, 0xE0, 0xFF, 0xF0, 0xF7, 0x07, 0xC3, 0xC3, 0xFC, 0x3E, 0x0F, 0x07,
  0xF0, 0xF0, 0x3C, 0x1F, 0xC3, 0xC0, 0xF0, 0x7F, 0x0E, 0x03, 0xC1, 0xFC,
  0x78, 0x0F, 0x0F, 0xF1, 0xE0, 0x3C, 0x3F, 0xC3, 0x81, 0xF0, 0xFF, 0x0F,
  0x07, 0xC7, 0xBC, 0x3E, 0x3F, 0x9E, 0xF0, 0x7F, 0xFF, 0xF1, 0xE0, 0xFF,
  0x3F, 0x87, 0x80, 0xF0, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x08, 0x00, 0xFE, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xE0, 0x18,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x06, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF,
  0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x7E, 0x3E, 0x07, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xF8, 0x03, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0,
  0x07, 0xCF, 0xC0, 0x0F, 0x8F, 0xE0, 0x1F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF, 0x9F, 0xE1, 0xE0, 0x00,
  0xF0, 0x03, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x01,
  0xF8, 0x78, 0x1F, 0x83, 0xC1, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07,
  0x8F, 0x80, 0x3C, 0xFC, 0x01, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xF8, 0xFC, 0x07, 0x83, 0xE0, 0x3C,
  0x1F, 0x81, 0xE0, 0x7E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0xC3, 0xC0, 0x3F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xE7, 0x80, 0x1F, 0xBC, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x78, 0x03,
  0xDF, 0xF7, 0x80, 0x3D, 0xFF, 0x7C, 0x03, 0xDF, 0xF3, 0xC0, 0x79, 0xFF,
  0x3C, 0x07, 0x9F, 0xF3, 0xE0, 0x79, 0xFF, 0x1E, 0x0F, 0x1F, 0xF1, 0xE0,
  0xF1, 0xFF, 0x1F, 0x0F, 0x1F, 0xF0, 0xF1, 0xE1, 0xFF, 0x0F, 0x1E, 0x1F,
  0xF0, 0xF9, 0xE1, 0xFF, 0x07, 0xBC, 0x1F, 0xF0, 0x7B, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x01,
  0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFB, 0xE0, 0x1F, 0xF7, 0xE0, 0x3F, 0xE7, 0xC0,
  0x7F, 0xC7, 0xC0, 0xFF, 0x8F, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x87,
  0xFC, 0x1F, 0x0F, 0xF8, 0x1F, 0x1F, 0xF0, 0x3F, 0x3F, 0xE0, 0x3E, 0x7F,
  0xC0, 0x7E, 0xFF, 0x80, 0x7D, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x0F, 0xBE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xF8,
  0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7E, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF,
  0xE7, 0xFF, 0xF7, 0xE0, 0x1B, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x03,
  0xE7, 0xF0, 0x1F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x01, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x80, 0x1F, 0x7C, 0x01, 0xF8,
  0x01, 0xE7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xE3, 0xC0,
  0x3F, 0xC0, 0x3E, 0x3E, 0x03, 0xFC, 0x03, 0xC3, 0xE0, 0x3F, 0xE0, 0x7C,
  0x3E, 0x07, 0x9E, 0x07, 0xC1, 0xE0, 0x79, 0xE0, 0x7C, 0x1F, 0x07, 0x9E,
  0x07, 0x81, 0xF0, 0x79, 0xF0, 0xF8, 0x1F, 0x0F, 0x8F, 0x0F, 0x80, 0xF0,
  0xF0, 0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0,
  0x0F, 0x9E, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x07,
  0x9E, 0x00, 0x7D, 0xE0, 0x3D, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03,
  0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07,
  0xBC, 0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1E,
  0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x07, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xEF, 0xF0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xEF, 0xFE, 0xF3, 0xFC,
  0x38, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFC, 0x1F, 0x7F,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x0F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x79, 0xFF, 0x8F, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x06, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x07,
  0xE3, 0xE3, 0xFF, 0x7C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xE0, 0xFE, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0x7E, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC, 0xF0, 0xFF,
  0x1E, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F,
  0x9F, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x8F, 0xF3, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC1,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xE1, 0xE3, 0xFF,
  0x3C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xE0, 0xFE, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x07,
  0xEF, 0xF7, 0xFC, 0xFF, 0xFF, 0x8F, 0xFD, 0xF0, 0xFF, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xCE, 0x01, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0xFC, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xC0, 0x27, 0xFF, 0xFF, 0x90, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x01, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0x40, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C,
  0x1F, 0x8F, 0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xF9,
  0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xE0,
  0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0xFC, 0x07, 0xE1, 0xE7, 0xFE, 0x3F, 0xE3, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xE1, 0xFF, 0x0F, 0xDF, 0x81, 0xFC, 0x0F,
  0xBE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F,
  0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF,
  0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC,
  0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0xF0,
  0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x0F, 0xC7,
  0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0xF0, 0xFC, 0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7D, 0xFF, 0x8F, 0x9F, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xE3, 0xFF, 0x3C, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF7, 0xE0, 0xFE, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFD, 0xF0, 0xFF, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0x80,
  0xDE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xF1,
  0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xEC, 0x7F, 0xE1, 0xFF, 0x07, 0xF8,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xEF, 0x1F, 0xE3, 0xC0,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xC0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3C, 0x03, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x80, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0xF8, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x7F, 0x01, 0xE3,
  0xC0, 0xFF, 0x07, 0xC7, 0xC1, 0xDE, 0x0F, 0x8F, 0x87, 0xBC, 0x1E, 0x1F,
  0x0F, 0x38, 0x7C, 0x1E, 0x1E, 0x78, 0xF8, 0x3E, 0x38, 0xF1, 0xF0, 0x7C,
  0xF1, 0xE3, 0xC0, 0xF9, 0xE3, 0xCF, 0x80, 0xF3, 0xC3, 0xDF, 0x01, 0xE7,
  0x07, 0xBC, 0x03, 0xFE, 0x0F, 0x78, 0x03, 0xFC, 0x0E, 0xF0, 0x07, 0xF8,
  0x1D, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x8F,
  0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x1F, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF1, 0xF0,
  0x1F, 0x87, 0xC0, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xEF, 0xC0,
  0x1F, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0x78, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0,
  0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0xFF, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7F,
  0x07, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xF8,
  0x1F, 0xC1, 0xFC, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0x80,
  0x7F, 0xA0, 0x03, 0x00,
};

const GFXglyph NotoSans_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 28, 11, 2, -27 },
  { 22, 13, 10, 17, 2, -27 },
  { 39, 23, 27, 25, 1, -27 },
  { 117, 18, 31, 22, 2, -29 },
  { 187, 31, 28, 33, 1, -28 },
  { 296, 26, 28, 28, 2, -28 },
  { 387, 5, 10, 10, 2, -27 },
  { 394, 9, 33, 12, 2, -27 },
  { 432, 10, 33, 12, 1, -27 },
  { 474, 18, 18, 21, 1, -29 },
  { 515, 18, 19, 22, 2, -23 },
  { 558, 7, 9, 11, 1, -4 },
  { 566, 10, 4, 12, 1, -12 },
  { 571, 6, 6, 10, 2, -5 },
  { 576, 15, 27, 15, 0, -27 },
  { 627, 18, 28, 22, 2, -28 },
  { 690, 12, 27, 22, 3, -27 },
  { 731, 18, 28, 22, 2, -28 },
  { 794, 18, 28, 22, 2, -28 },
  { 857, 20, 27, 22, 1, -27 },
  { 925, 18, 27, 22, 2, -27 },
  { 986, 18, 27, 22, 2, -27 },
  { 1047, 19, 27, 22, 1, -27 },
  { 1112, 18, 27, 22, 2, -27 },
  { 1173, 19, 27, 22, 1, -27 },
  { 1238, 6, 22, 10, 2, -21 },
  { 1255, 7, 26, 11, 1, -21 },
  { 1278, 18, 20, 22, 2, -24 },
  { 1323, 18, 11, 22, 2, -19 },
  { 1348, 18, 20, 22, 2, -24 },
  { 1393, 17, 29, 18, 0, -28 },
  { 1455, 30, 30, 34, 2, -27 },
  { 1568, 26, 27, 26, 0, -27 },
  { 1656, 20, 27, 25, 3, -27 },
  { 1724, 21, 28, 24, 2, -28 },
  { 1798, 23, 27, 28, 3, -27 },
  { 1876, 15, 27, 21, 4, -27 },
  { 1927, 15, 27, 20, 4, -27 },
  { 1978, 23, 28, 28, 2, -28 },
  { 2059, 21, 27, 29, 4, -27 },
  { 2130, 12, 27, 14, 1, -27 },
  { 2171, 11, 35, 12, -3, -27 },
  { 2220, 21, 27, 25, 4, -27 },
  { 2291, 17, 27, 21, 3, -27 },
  { 2349, 28, 27, 35, 4, -27 },
  { 2444, 23, 27, 30, 4, -27 },
  { 2522, 26, 28, 30, 2, -28 },
  { 2613, 19, 27, 23, 3, -27 },
  { 2678, 26, 34, 30, 2, -28 },
  { 2789, 21, 27, 24, 3, -27 },
  { 2860, 17, 28, 21, 2, -28 },
  { 2920, 20, 27, 22, 1, -27 },
  { 2988, 22, 27, 28, 3, -27 },
  { 3063, 24, 27, 24, 0, -27 },
  { 3144, 36, 27, 36, 0, -27 },
  { 3266, 24, 27, 24, 0, -27 },
  { 3347, 23, 27, 23, 0, -27 },
  { 3425, 20, 27, 22, 1, -27 },
  { 3493, 9, 33, 13, 3, -27 },
  { 3531, 15, 27, 15, 0, -27 },
  { 3582, 9, 33, 13, 1, -27 },
  { 3620, 20, 17, 22, 1, -27 },
  { 3663, 16, 3, 16, 0, 3 },
  { 3669, 9, 6, 13, 2, -29 },
  { 3676, 17, 21, 22, 2, -21 },
  { 3721, 19, 29, 24, 3, -29 },
  { 3790, 16, 21, 19, 2, -21 },
  { 3832, 19, 29, 24, 2, -29 },
  { 3901, 18, 21, 22, 2, -21 },
  { 3949, 15, 29, 14, 1, -29 },
  { 4004, 19, 30, 24, 2, -21 },
  { 4076, 18, 29, 24, 3, -29 },
  { 4142, 5, 29, 11, 3, -29 },
  { 4161, 10, 38, 11, -2, -29 },
  { 4209, 19, 29, 22, 3, -29 },
  { 4278, 5, 29, 11, 3, -29 },
  { 4297, 31, 21, 36, 3, -21 },
  { 4379, 18, 21, 24, 3, -21 },
  { 4427, 20, 21, 23, 2, -21 },
  { 4480, 19, 30, 24, 3, -21 },
  { 4552, 19, 30, 24, 2, -21 },
  { 4624, 13, 21, 16, 3, -21 },
  { 4659, 15, 21, 19, 2, -21 },
  { 4699, 13, 25, 15, 1, -25 },
  { 4740, 18, 21, 24, 3, -21 },
  { 4788, 21, 21, 21, 0, -21 },
  { 4844, 31, 21, 32, 0, -21 },
  { 4926, 21, 21, 21, 0, -21 },
  { 4982, 21, 30, 21, 0, -21 },
  { 5061, 16, 21, 18, 1, -21 },
  { 5103, 12, 33, 15, 1, -27 },
  { 5153, 3, 38, 21, 9, -29 },
  { 5168, 13, 33, 15, 1, -27 },
  { 5222, 18, 6, 22, 2, -16 },
};

const GFXfont NotoSans_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMIBOLD38PT7B_H_
