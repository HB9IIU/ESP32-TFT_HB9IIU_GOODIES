#ifndef _NOTOSANS_SEMIBOLD10PT7B_H_
#define _NOTOSANS_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB4, 0x28, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x23, 0xFA, 0xC3,
  0x95, 0x66, 0x20, 0x66, 0x94, 0x98, 0x6F, 0x15, 0x15, 0x23, 0x78, 0x91,
  0xE3, 0x95, 0xF9, 0x9F, 0x80, 0xC0, 0x69, 0x6D, 0x92, 0x20, 0xC9, 0x92,
  0x5A, 0x80, 0x21, 0x3E, 0x65, 0x80, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0,
  0x80, 0x32, 0x26, 0x44, 0x80, 0x7A, 0x73, 0x9C, 0xA5, 0xC0, 0x74, 0x92,
  0x48, 0xFA, 0x42, 0x22, 0x23, 0xE0, 0xF8, 0x46, 0xE0, 0x87, 0xE0, 0x18,
  0xE3, 0x96, 0xFC, 0x61, 0x80, 0xF8, 0x8F, 0x11, 0xE0, 0x3A, 0x15, 0xFC,
  0xA5, 0xE0, 0xF8, 0x46, 0x23, 0x11, 0x80, 0x7A, 0x5E, 0xE4, 0xE5, 0xE0,
  0x7E, 0x72, 0xF0, 0x8D, 0xC0, 0xC4, 0x50, 0x1C, 0x09, 0xB0, 0x60, 0x80,
  0xF8, 0x3E, 0xC1, 0x82, 0xE8, 0x00, 0xF1, 0x12, 0x40, 0x60, 0x7D, 0x06,
  0xEF, 0x5A, 0xB6, 0xF0, 0x1E, 0x30, 0x50, 0xA3, 0x47, 0xC8, 0xB1, 0x80,
  0xF4, 0x67, 0xE8, 0xC7, 0xC0, 0x7E, 0x21, 0x08, 0x61, 0xE0, 0xF2, 0x28,
  0xE3, 0x8E, 0x2F, 0x00, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80,
  0x7E, 0x21, 0x38, 0xE5, 0xE0, 0x8E, 0x38, 0xFF, 0x8E, 0x38, 0xC0, 0xE9,
  0x24, 0xB8, 0x24, 0x92, 0x49, 0xE0, 0x9C, 0xA9, 0xCB, 0x4A, 0x20, 0x88,
  0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x9D, 0x5A, 0xB7, 0x64, 0x80, 0xC7, 0x9A,
  0x6D, 0x96, 0x38, 0xC0, 0x7A, 0x38, 0x61, 0x87, 0x37, 0x80, 0xF4, 0xE7,
  0xE8, 0x42, 0x00, 0x7A, 0x38, 0x61, 0x87, 0x37, 0x86, 0x0C, 0xF4, 0xE7,
  0xEB, 0x4A, 0x20, 0x7A, 0x10, 0x60, 0xC7, 0xC0, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x00, 0x8E, 0x38, 0xE3, 0x8E, 0x27, 0x80, 0xC5, 0x34, 0x9A, 0x38,
  0xC3, 0x00, 0x8C, 0xE6, 0x57, 0x2A, 0xB5, 0x31, 0x98, 0x8C, 0xCD, 0xA3,
  0x0C, 0x39, 0x2C, 0x40, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x00, 0xF8, 0xC4,
  0x46, 0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0xC4, 0x46, 0x22, 0x10, 0xED, 0xB6,
  0xDB, 0xE0, 0x21, 0x95, 0x90, 0xF0, 0xC4, 0x32, 0xC2, 0xFC, 0xBC, 0x84,
  0x29, 0xE9, 0xCE, 0x7E, 0x13, 0xD1, 0x84, 0x3C, 0x08, 0x4A, 0xF4, 0xE5,
  0x2F, 0x13, 0xD3, 0xF4, 0x3C, 0x37, 0x4F, 0x44, 0x44, 0x23, 0xD3, 0x94,
  0xBC, 0x2F, 0x84, 0x29, 0xE9, 0xCE, 0x73, 0xDF, 0x24, 0x12, 0x49, 0x3C,
  0x84, 0x23, 0x6E, 0x72, 0xD3, 0xFF, 0x22, 0xFF, 0x99, 0x91, 0x91, 0x91,
  0x27, 0xA7, 0x39, 0xCC, 0x11, 0xE4, 0xF3, 0x49, 0xE0, 0x27, 0xA7, 0x39,
  0xFA, 0x10, 0x23, 0xD3, 0x94, 0xBC, 0x21, 0x3E, 0x49, 0x00, 0x26, 0x90,
  0x61, 0xF8, 0x44, 0xF4, 0x44, 0x70, 0x9C, 0xE7, 0x3F, 0x80, 0xCA, 0xD4,
  0xE3, 0x00, 0xD9, 0x5B, 0x56, 0x66, 0x66, 0xD9, 0xC3, 0x14, 0xCC, 0xCA,
  0x54, 0x63, 0x13, 0x80, 0xF1, 0x88, 0x8F, 0x80, 0x36, 0x64, 0xC6, 0x66,
  0x10, 0xFF, 0xC0, 0xC4, 0x46, 0x34, 0x44, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 5, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 5, 9, 6, 0, -8 },
  { 15, 8, 7, 9, 0, -7 },
  { 22, 7, 7, 7, 0, -7 },
  { 29, 1, 2, 3, 1, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 3, 9, 3, 0, -7 },
  { 38, 5, 5, 5, 0, -8 },
  { 42, 5, 5, 6, 0, -6 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 5, 7, 6, 0, -7 },
  { 58, 3, 7, 6, 1, -7 },
  { 61, 5, 7, 6, 0, -7 },
  { 66, 5, 7, 6, 0, -7 },
  { 71, 6, 7, 6, 0, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 0, -7 },
  { 86, 5, 7, 6, 0, -7 },
  { 91, 5, 7, 6, 0, -7 },
  { 96, 5, 7, 6, 0, -7 },
  { 101, 1, 6, 3, 1, -6 },
  { 102, 2, 7, 3, 0, -6 },
  { 104, 5, 5, 6, 0, -6 },
  { 108, 5, 3, 6, 0, -5 },
  { 110, 5, 5, 6, 0, -6 },
  { 114, 4, 7, 5, 0, -7 },
  { 118, 7, 8, 9, 1, -7 },
  { 125, 7, 7, 7, 0, -7 },
  { 132, 5, 7, 7, 1, -7 },
  { 137, 5, 7, 6, 1, -7 },
  { 142, 6, 7, 7, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 5, 7, 7, 1, -7 },
  { 161, 6, 7, 8, 1, -7 },
  { 167, 3, 7, 4, 0, -7 },
  { 170, 3, 9, 3, -1, -7 },
  { 174, 5, 7, 6, 1, -7 },
  { 179, 4, 7, 5, 1, -7 },
  { 183, 7, 7, 9, 1, -7 },
  { 190, 6, 7, 8, 1, -7 },
  { 196, 6, 7, 8, 1, -7 },
  { 202, 5, 7, 6, 1, -7 },
  { 207, 6, 9, 8, 1, -7 },
  { 214, 5, 7, 6, 1, -7 },
  { 219, 5, 7, 6, 0, -7 },
  { 224, 6, 7, 6, 0, -7 },
  { 230, 6, 7, 7, 1, -7 },
  { 236, 6, 7, 6, 0, -7 },
  { 242, 9, 7, 10, 0, -7 },
  { 250, 6, 7, 6, 0, -7 },
  { 256, 6, 7, 6, 0, -7 },
  { 262, 5, 7, 6, 0, -7 },
  { 267, 2, 9, 3, 1, -7 },
  { 270, 4, 7, 4, 0, -7 },
  { 274, 3, 9, 3, 0, -7 },
  { 278, 5, 4, 6, 0, -7 },
  { 281, 4, 1, 4, 0, 1 },
  { 282, 3, 2, 3, 0, -8 },
  { 283, 5, 6, 6, 0, -6 },
  { 287, 5, 8, 6, 1, -8 },
  { 292, 5, 6, 5, 0, -6 },
  { 296, 5, 8, 6, 0, -8 },
  { 301, 5, 6, 6, 0, -6 },
  { 305, 4, 8, 4, 0, -8 },
  { 309, 5, 8, 6, 0, -6 },
  { 314, 5, 8, 6, 1, -8 },
  { 319, 1, 8, 3, 1, -8 },
  { 320, 3, 10, 3, -1, -8 },
  { 324, 5, 8, 6, 1, -8 },
  { 329, 1, 8, 3, 1, -8 },
  { 330, 8, 6, 10, 1, -6 },
  { 336, 5, 6, 6, 1, -6 },
  { 340, 6, 6, 6, 0, -6 },
  { 345, 5, 8, 6, 1, -6 },
  { 350, 5, 8, 6, 0, -6 },
  { 355, 3, 6, 4, 1, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 4, 7, 4, 0, -7 },
  { 366, 5, 5, 6, 1, -5 },
  { 370, 5, 5, 5, 0, -5 },
  { 374, 8, 5, 8, 0, -5 },
  { 379, 6, 5, 6, 0, -5 },
  { 383, 5, 7, 5, 0, -5 },
  { 388, 5, 5, 5, 0, -5 },
  { 392, 4, 9, 4, 0, -7 },
  { 397, 1, 10, 6, 2, -8 },
  { 399, 4, 9, 4, 0, -7 },
  { 404, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMIBOLD10PT7B_H_
