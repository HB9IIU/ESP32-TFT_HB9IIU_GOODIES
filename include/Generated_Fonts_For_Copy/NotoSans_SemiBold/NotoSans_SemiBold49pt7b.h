#ifndef _NOTOSANS_SEMIBOLD49PT7B_H_
#define _NOTOSANS_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E,
  0x18, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0x3C, 0x3C, 0x7E, 0x3C, 0x04, 0xFE, 0x3C, 0x00, 0xFE, 0x3C,
  0x00, 0x7E, 0x3C, 0x00, 0x7F, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE, 0x00, 0x3C,
  0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x80, 0x3C, 0x3F, 0xE0, 0x3C,
  0x7E, 0xFE, 0x3D, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC3, 0xE0, 0x20, 0x3E, 0x0F, 0x87, 0xC7, 0xF8, 0x7C,
  0x1F, 0x1F, 0x1F, 0xF8, 0x7C, 0x7E, 0x7C, 0x7F, 0xF8, 0xFF, 0xF8, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF3, 0xE3, 0xE1, 0xF0, 0xFF, 0xC7, 0xC7, 0xC3, 0xE0,
  0xFF, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0xF8, 0x03, 0xF0, 0xFF, 0xFF,
  0x01, 0xFC, 0x7F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0x87, 0xE0,
  0x3F, 0xCF, 0xE3, 0xF8, 0x07, 0xFB, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x3F,
  0x80, 0x1F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFE,
  0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF,
  0x7D, 0xF7, 0x9E, 0x78, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x20, 0x1E, 0x01, 0x7C, 0x3C, 0x1E, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7E, 0x18, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC,
  0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0xFF, 0x3F, 0x7E, 0x3F, 0x3C,
  0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0x01, 0xFC, 0x3C, 0x00, 0xFE, 0x18, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3C, 0x01, 0xFC, 0x30, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x80, 0x00,
  0xFE, 0xE0, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE8, 0x00, 0x1F,
  0xDC, 0x00, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0xE0,
  0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xF7, 0xFE,
  0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8,
  0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x7F, 0x81, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0x01, 0xFF,
  0x7F, 0xC7, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F,
  0x07, 0xFE, 0x3E, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x3D, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE,
  0x7E, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x18, 0x3E, 0x3F,
  0x9F, 0xCF, 0xF7, 0xF3, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9E, 0x01, 0xFC, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0xC0,
  0x7C, 0x1F, 0x01, 0xFF, 0xF8, 0x3C, 0x3E, 0x03, 0xFF, 0xF8, 0x3E, 0x3E,
  0x07, 0xFF, 0xF8, 0x3E, 0x3C, 0x0F, 0xE0, 0xF8, 0x1E, 0x7C, 0x0F, 0x80,
  0xF8, 0x1E, 0x7C, 0x1F, 0x00, 0xF8, 0x1E, 0x7C, 0x1F, 0x00, 0xF8, 0x1E,
  0x78, 0x3E, 0x00, 0xF8, 0x1F, 0x78, 0x3E, 0x00, 0xF8, 0x1E, 0x78, 0x3E,
  0x00, 0xF8, 0x1E, 0xF8, 0x3E, 0x00, 0xF8, 0x1E, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x78, 0x3E, 0x01, 0xF8, 0x3E, 0x78, 0x1F, 0x01, 0xF8, 0x3C, 0x78,
  0x1F, 0x03, 0xF8, 0x7C, 0x7C, 0x1F, 0xCF, 0xFC, 0xF8, 0x7C, 0x0F, 0xFF,
  0xBF, 0xF8, 0x7C, 0x07, 0xFF, 0x3F, 0xF0, 0x3E, 0x03, 0xFE, 0x1F, 0xE0,
  0x3E, 0x00, 0x30, 0x02, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x06,
  0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xE0,
  0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xF8, 0x07, 0xFC, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0x07, 0xF8, 0x00, 0x21, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x04, 0x3F,
  0xF0, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0x1F, 0xC0, 0x03,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0xCF, 0xE0, 0x07, 0xFC, 0x7F, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x00,
  0xF0, 0x7F, 0xC0, 0x00, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x0F, 0xDF, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x03, 0xF3, 0xFE, 0x00, 0x1F,
  0x8F, 0xFC, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x67, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x7F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF3, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0xFB, 0xFF,
  0xBE, 0x00, 0x0F, 0xBF, 0xFB, 0xF0, 0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x1F,
  0x3F, 0xF9, 0xF0, 0x01, 0xF3, 0xFF, 0x9F, 0x80, 0x1F, 0x3F, 0xF8, 0xF8,
  0x03, 0xE3, 0xFF, 0x8F, 0x80, 0x3E, 0x3F, 0xF8, 0xFC, 0x03, 0xE3, 0xFF,
  0x87, 0xC0, 0x7C, 0x3F, 0xF8, 0x7C, 0x07, 0xC3, 0xFF, 0x87, 0xE0, 0xFC,
  0x3F, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F,
  0x1F, 0x83, 0xFF, 0x81, 0xF1, 0xF0, 0x3F, 0xF8, 0x1F, 0x1F, 0x03, 0xFF,
  0x81, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFB, 0xF0, 0x00, 0xFF, 0xDF, 0xC0, 0x07, 0xFE, 0x7F, 0x00,
  0x3F, 0xF3, 0xF8, 0x01, 0xFF, 0x8F, 0xE0, 0x0F, 0xFC, 0x3F, 0x00, 0x7F,
  0xE1, 0xFC, 0x03, 0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0x80, 0xFF, 0xC0,
  0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0x1F, 0xC1, 0xFF, 0x80, 0x7F,
  0x0F, 0xFC, 0x03, 0xF8, 0x7F, 0xE0, 0x0F, 0xE3, 0xFF, 0x00, 0x3F, 0x9F,
  0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x07, 0xF7, 0xFE, 0x00, 0x3F, 0xBF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFE, 0x07, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFC, 0x07, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F,
  0x1F, 0xC0, 0x02, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x7F, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x80, 0x0F, 0xE3,
  0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xEF, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x1F, 0xC0,
  0x7C, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xC7, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xF8,
  0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x83,
  0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x00, 0x3F, 0x3F, 0x01, 0xF1,
  0xF8, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x0F, 0xBF,
  0x00, 0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFB, 0xF0,
  0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xE0, 0x3F, 0x82, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0x9F, 0xBF, 0xC0, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF,
  0x3E, 0x7F, 0xFC, 0x7C, 0x3F, 0xF0, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFF, 0x00, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xF9, 0xFF, 0xF8, 0xF8, 0xFF, 0xF0, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xF0, 0x78, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x9F, 0xE0, 0x1C, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFD, 0xF8, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0x3F,
  0x80, 0x7F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0x81,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xF7, 0xE0, 0xFF,
  0xF3, 0xF0, 0x3F, 0xE0, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F,
  0x80, 0x7E, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x06, 0x1F,
  0xF0, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x83, 0xFF, 0x8F,
  0xC3, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x07,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF9,
  0xFC, 0x03, 0xFC, 0xFF, 0xDF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF,
  0x83, 0xFF, 0xCF, 0xC0, 0xFF, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x30, 0x00,
  0xFF, 0x1F, 0x81, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7B,
  0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F,
  0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xCF, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0xEF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC1, 0xF1, 0xFF, 0xE0, 0xFF, 0xE3, 0xE7, 0xFF, 0xE7,
  0xFF, 0xE7, 0xDF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0xF8,
  0x3F, 0xC0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFF, 0x3F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0xF8, 0x3F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFF, 0x00, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFD, 0xFF, 0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0x81, 0xFF, 0x8F, 0xC3, 0xFF, 0xF7, 0xE3, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xDF, 0x83, 0xFF, 0xCF, 0xC0, 0xFF, 0x87, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x1F, 0xFC, 0x3F, 0xBE, 0x3F, 0xDF, 0x3F, 0xEF, 0xBF, 0xF7, 0xFF, 0xFB,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE0, 0x0C,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xEF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBE, 0x7F, 0xFE, 0x7C, 0x3F, 0xF0, 0xF8, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x80,
  0x7E, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x3F, 0x81, 0xF7, 0xC0, 0xFC, 0x1F,
  0x81, 0xF7, 0xC0, 0xFC, 0x1F, 0x83, 0xE7, 0xC0, 0xFC, 0x1F, 0x83, 0xE3,
  0xE1, 0xF8, 0x0F, 0xC3, 0xE3, 0xE1, 0xF8, 0x0F, 0xC3, 0xE3, 0xE1, 0xF8,
  0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0x0F, 0xC7, 0xC1, 0xF3, 0xF0, 0x07, 0xE7,
  0xC1, 0xF3, 0xF0, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x07, 0xEF, 0x81, 0xF3,
  0xE0, 0x03, 0xEF, 0x80, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x03,
  0xEF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x03, 0xFB, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x7F, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x80, 0x07, 0xFC,
};

const GFXglyph NotoSans_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 36, 14, 3, -35 },
  { 37, 16, 13, 22, 3, -35 },
  { 63, 29, 35, 32, 1, -35 },
  { 190, 24, 40, 28, 2, -37 },
  { 310, 39, 35, 43, 2, -35 },
  { 481, 34, 35, 36, 2, -35 },
  { 630, 6, 13, 12, 3, -35 },
  { 640, 12, 43, 16, 2, -35 },
  { 705, 13, 43, 16, 1, -35 },
  { 775, 23, 22, 27, 2, -37 },
  { 839, 24, 24, 28, 2, -29 },
  { 911, 8, 12, 14, 2, -6 },
  { 923, 12, 5, 16, 2, -16 },
  { 931, 8, 8, 14, 3, -7 },
  { 939, 19, 35, 20, 0, -35 },
  { 1023, 24, 36, 28, 2, -36 },
  { 1131, 16, 35, 28, 3, -35 },
  { 1201, 24, 35, 28, 2, -35 },
  { 1306, 24, 35, 28, 2, -35 },
  { 1411, 26, 35, 28, 1, -35 },
  { 1525, 23, 35, 28, 3, -35 },
  { 1626, 24, 35, 28, 2, -35 },
  { 1731, 24, 35, 28, 2, -35 },
  { 1836, 24, 35, 28, 2, -35 },
  { 1941, 24, 35, 28, 2, -35 },
  { 2046, 8, 28, 14, 3, -27 },
  { 2074, 9, 33, 14, 2, -27 },
  { 2112, 24, 25, 28, 2, -30 },
  { 2187, 24, 14, 28, 2, -24 },
  { 2229, 24, 25, 28, 2, -30 },
  { 2304, 21, 36, 23, 0, -35 },
  { 2399, 40, 39, 44, 2, -35 },
  { 2594, 33, 35, 33, 0, -35 },
  { 2739, 26, 35, 32, 4, -35 },
  { 2853, 27, 35, 31, 3, -35 },
  { 2972, 29, 35, 36, 4, -35 },
  { 3099, 19, 35, 27, 5, -35 },
  { 3183, 19, 35, 26, 5, -35 },
  { 3267, 29, 35, 36, 3, -35 },
  { 3394, 27, 35, 37, 5, -35 },
  { 3513, 14, 35, 18, 2, -35 },
  { 3575, 15, 45, 15, -4, -35 },
  { 3660, 27, 35, 32, 5, -35 },
  { 3779, 21, 35, 27, 4, -35 },
  { 3871, 36, 35, 46, 5, -35 },
  { 4029, 29, 35, 39, 5, -35 },
  { 4156, 33, 36, 39, 3, -36 },
  { 4305, 24, 35, 30, 4, -35 },
  { 4410, 33, 44, 39, 3, -36 },
  { 4592, 27, 35, 32, 4, -35 },
  { 4711, 23, 35, 27, 2, -35 },
  { 4812, 26, 35, 28, 1, -35 },
  { 4926, 28, 35, 37, 4, -35 },
  { 5049, 31, 35, 31, 0, -35 },
  { 5185, 46, 35, 47, 0, -35 },
  { 5387, 31, 35, 31, 0, -35 },
  { 5523, 30, 35, 30, 0, -35 },
  { 5655, 26, 35, 28, 1, -35 },
  { 5769, 11, 43, 16, 4, -35 },
  { 5829, 19, 35, 20, 0, -35 },
  { 5913, 12, 43, 16, 1, -35 },
  { 5978, 26, 22, 28, 1, -35 },
  { 6050, 21, 4, 21, 0, 4 },
  { 6061, 12, 8, 16, 2, -38 },
  { 6073, 23, 27, 29, 2, -27 },
  { 6151, 24, 37, 31, 4, -37 },
  { 6262, 21, 27, 25, 2, -27 },
  { 6333, 25, 37, 31, 2, -37 },
  { 6449, 24, 27, 29, 2, -27 },
  { 6530, 19, 37, 18, 1, -37 },
  { 6618, 25, 39, 31, 2, -27 },
  { 6740, 24, 37, 31, 4, -37 },
  { 6851, 6, 37, 14, 4, -37 },
  { 6879, 13, 49, 14, -3, -37 },
  { 6959, 25, 37, 29, 4, -37 },
  { 7075, 6, 37, 14, 4, -37 },
  { 7103, 39, 27, 47, 4, -27 },
  { 7235, 24, 27, 31, 4, -27 },
  { 7316, 26, 27, 30, 2, -27 },
  { 7404, 24, 39, 31, 4, -27 },
  { 7521, 25, 39, 31, 2, -27 },
  { 7643, 17, 27, 21, 4, -27 },
  { 7701, 20, 27, 24, 2, -27 },
  { 7769, 18, 32, 20, 1, -32 },
  { 7841, 23, 27, 31, 4, -27 },
  { 7919, 27, 27, 27, 0, -27 },
  { 8011, 40, 27, 41, 0, -27 },
  { 8146, 27, 27, 27, 0, -27 },
  { 8238, 27, 39, 27, 0, -27 },
  { 8370, 20, 27, 24, 2, -27 },
  { 8438, 16, 43, 19, 1, -35 },
  { 8524, 5, 48, 27, 11, -37 },
  { 8554, 16, 43, 19, 2, -35 },
  { 8640, 24, 7, 28, 2, -21 },
};

const GFXfont NotoSans_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMIBOLD49PT7B_H_
