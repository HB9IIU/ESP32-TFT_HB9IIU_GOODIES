#ifndef _NOTOSANS_SEMIBOLD15PT7B_H_
#define _NOTOSANS_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0xB0, 0x09, 0x0C, 0x86, 0xCF, 0xF7,
  0xF8, 0x90, 0xC9, 0xFF, 0x26, 0x12, 0x09, 0x00, 0x10, 0xFF, 0x56, 0x8F,
  0x0F, 0x07, 0x8B, 0x97, 0xF8, 0x40, 0x80, 0x60, 0x8F, 0x18, 0x91, 0x09,
  0x30, 0x96, 0xCF, 0x5E, 0x6D, 0x20, 0x93, 0x19, 0x31, 0x1A, 0x30, 0xE0,
  0x38, 0x1F, 0x04, 0x41, 0xB0, 0x78, 0x1C, 0x3D, 0x9B, 0x3E, 0xC7, 0x3B,
  0xE7, 0xDC, 0xFF, 0x2F, 0x6D, 0x24, 0x9B, 0x26, 0xC6, 0x23, 0x33, 0x11,
  0x33, 0x32, 0xE0, 0x30, 0x63, 0xF9, 0x87, 0x99, 0x92, 0x00, 0x10, 0x20,
  0x47, 0xF1, 0x02, 0x04, 0x00, 0xFA, 0xFF, 0xF0, 0x0C, 0x21, 0x86, 0x10,
  0xC3, 0x18, 0x61, 0x0C, 0x00, 0x39, 0xFB, 0x16, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xD9, 0xE0, 0x19, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x79, 0xFA,
  0x18, 0x30, 0xC1, 0x86, 0x18, 0x61, 0xFF, 0xF8, 0x79, 0xFA, 0x18, 0x20,
  0xCF, 0x03, 0x03, 0x07, 0x1B, 0xE0, 0x06, 0x0E, 0x0E, 0x1E, 0x36, 0x26,
  0x46, 0xFF, 0xFF, 0x06, 0x06, 0xFD, 0xFB, 0x06, 0x0F, 0x9F, 0x81, 0x83,
  0x07, 0xBB, 0xE0, 0x1C, 0xFB, 0x06, 0x0F, 0xDF, 0xF1, 0xE3, 0xC7, 0xDD,
  0xF0, 0xFF, 0xFF, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x79, 0xFB, 0x1E, 0x37, 0xC7, 0x3B, 0x63, 0x87, 0x9D, 0xF0, 0x79, 0xFB,
  0x1C, 0x3C, 0x79, 0xDF, 0x83, 0x0D, 0x3B, 0xE0, 0xF0, 0x0F, 0x6C, 0x00,
  0x1B, 0x58, 0x06, 0x39, 0xC6, 0x0F, 0x03, 0x81, 0x80, 0xFE, 0x03, 0xFF,
  0xF0, 0x81, 0xC0, 0xE0, 0x71, 0xCE, 0x30, 0x00, 0x79, 0xF8, 0x18, 0x20,
  0xC3, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x0F, 0x03, 0xDC, 0x60, 0x6C, 0xFA,
  0xD9, 0x39, 0x13, 0x91, 0x39, 0x12, 0x9E, 0xEC, 0x00, 0x60, 0x83, 0xF8,
  0x0C, 0x07, 0x81, 0xE0, 0x78, 0x33, 0x0C, 0xC3, 0x11, 0xFE, 0x61, 0x98,
  0x7C, 0x0C, 0xFC, 0xFE, 0xC3, 0xC3, 0xC6, 0xFC, 0xC7, 0xC3, 0xC3, 0xFF,
  0xFE, 0x1E, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F,
  0xFC, 0x7F, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x7F, 0xBF,
  0x00, 0xFF, 0xFC, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0xFC,
  0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x00, 0x1F, 0xBF, 0x98, 0x18, 0x0C,
  0x06, 0x3F, 0x1F, 0x83, 0xE1, 0xBD, 0xCF, 0xE0, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0xFF, 0x66, 0x66,
  0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0xE3,
  0xB1, 0x99, 0x8D, 0x87, 0xC3, 0xF1, 0x98, 0xC6, 0x63, 0xB0, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xE0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x0B, 0xD1, 0xBD, 0x9B, 0xD9, 0x3C, 0xB3, 0xCF, 0x3C, 0xE3,
  0xC6, 0x30, 0xE0, 0xF8, 0x3F, 0x0F, 0x63, 0xD8, 0xF3, 0x3C, 0xEF, 0x1B,
  0xC3, 0xF0, 0xFC, 0x1C, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xE1, 0x9F, 0xE3, 0xF0, 0xF8, 0xFE, 0xC6, 0xC3, 0xC6, 0xFE,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE1, 0x9F, 0xE3, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0xF8,
  0x7F, 0x31, 0x98, 0x6C, 0x67, 0xF3, 0xF1, 0x98, 0xC6, 0x63, 0xB0, 0xE0,
  0x7D, 0xFB, 0x06, 0x0E, 0x0F, 0x07, 0x03, 0x07, 0xBB, 0xE0, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xBB, 0x8F, 0x80, 0xC1, 0xE0,
  0xD8, 0x6C, 0x66, 0x31, 0x98, 0xD8, 0x6C, 0x1E, 0x0E, 0x03, 0x00, 0xC3,
  0x0F, 0x0C, 0x36, 0x38, 0xD9, 0xE2, 0x66, 0x99, 0x92, 0x62, 0x4D, 0x8F,
  0x34, 0x3C, 0x70, 0xE1, 0xC1, 0x87, 0x00, 0xE1, 0x98, 0xC3, 0x30, 0xD8,
  0x1E, 0x03, 0x01, 0xE0, 0xD8, 0x33, 0x18, 0xEC, 0x1C, 0xC1, 0xB1, 0x98,
  0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x10, 0x08, 0x04, 0x02, 0x00, 0x7F, 0x7F,
  0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x7F, 0xFF, 0xFF, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xF0, 0xC1, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x18, 0x20,
  0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x08, 0x18, 0x1C, 0x34,
  0x26, 0x62, 0xC3, 0xFC, 0xC4, 0xFC, 0x9C, 0x1B, 0xFC, 0x78, 0xF3, 0xFB,
  0xC0, 0xC0, 0xC0, 0xFC, 0xE6, 0xC3, 0xC3, 0xC3, 0xC6, 0xE6, 0xDC, 0x7F,
  0x9C, 0x30, 0xC3, 0x0E, 0x5F, 0x06, 0x0C, 0x1B, 0xFE, 0x78, 0xF1, 0xE3,
  0xC7, 0xDD, 0xE8, 0x7D, 0x8F, 0x1F, 0xFC, 0x18, 0x39, 0xBF, 0x3C, 0xC2,
  0x3E, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x7B, 0xCF, 0x1E, 0x3C, 0x78,
  0xFB, 0xBF, 0x07, 0x0F, 0xF1, 0x80, 0xC1, 0x83, 0x07, 0xFE, 0x78, 0x70,
  0xE1, 0xC3, 0x87, 0x08, 0xF3, 0xFF, 0xFC, 0x33, 0x03, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0x40, 0xC0, 0xC0, 0xC1, 0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC,
  0xCE, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x73, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xFF, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0x7C, 0xE6, 0xC6, 0xC3, 0xC2, 0xC6, 0xEE, 0x7C, 0xFE, 0xE6, 0xC7, 0xC3,
  0xC3, 0xC6, 0xEE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x7B, 0xCF, 0x1E, 0x3C,
  0x78, 0xFB, 0xBF, 0x06, 0x0C, 0x18, 0x30, 0xDF, 0xF1, 0x8C, 0x63, 0x18,
  0xFF, 0x2C, 0x3C, 0x38, 0x39, 0xFE, 0x20, 0x8F, 0xD8, 0x61, 0x86, 0x18,
  0x74, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBD, 0xC3, 0x63, 0x66,
  0x66, 0x34, 0x3C, 0x1C, 0x18, 0xC6, 0x34, 0x73, 0x6F, 0x36, 0xD6, 0x69,
  0xE2, 0x9E, 0x39, 0xC3, 0x8C, 0xE3, 0x66, 0x3C, 0x1C, 0x1C, 0x3E, 0x66,
  0xE3, 0xC3, 0x63, 0x66, 0x66, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0xF0,
  0xC0, 0x7E, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x7F, 0x09, 0xCC, 0x63, 0x1B,
  0x9E, 0x31, 0x8C, 0x61, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x87, 0x18, 0xC6,
  0x30, 0xEF, 0x63, 0x18, 0xCC, 0x00, 0xFF, 0x38,
};

const GFXglyph NotoSans_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 10, 0, -11 },
  { 20, 7, 12, 9, 1, -11 },
  { 31, 12, 11, 13, 1, -11 },
  { 48, 10, 11, 11, 1, -11 },
  { 62, 2, 4, 4, 1, -11 },
  { 63, 3, 13, 5, 1, -11 },
  { 68, 4, 13, 5, 0, -11 },
  { 75, 7, 7, 8, 1, -11 },
  { 82, 7, 7, 9, 1, -9 },
  { 89, 2, 4, 4, 1, -2 },
  { 90, 4, 2, 5, 0, -5 },
  { 91, 2, 2, 4, 1, -2 },
  { 92, 6, 11, 6, 0, -11 },
  { 101, 7, 11, 9, 1, -11 },
  { 111, 5, 11, 9, 1, -11 },
  { 118, 7, 11, 9, 1, -11 },
  { 128, 7, 11, 9, 1, -11 },
  { 138, 8, 11, 9, 0, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 7, 11, 9, 1, -11 },
  { 169, 8, 11, 9, 0, -11 },
  { 180, 7, 11, 9, 1, -11 },
  { 190, 7, 11, 9, 1, -11 },
  { 200, 2, 8, 4, 1, -8 },
  { 202, 3, 10, 4, 0, -8 },
  { 206, 7, 7, 9, 1, -9 },
  { 213, 7, 4, 9, 1, -7 },
  { 217, 7, 7, 9, 1, -9 },
  { 224, 7, 11, 7, 0, -11 },
  { 234, 12, 12, 13, 1, -11 },
  { 252, 10, 11, 10, 0, -11 },
  { 266, 8, 11, 10, 1, -11 },
  { 277, 8, 11, 10, 1, -11 },
  { 288, 9, 11, 11, 1, -11 },
  { 301, 6, 11, 8, 1, -11 },
  { 310, 6, 11, 8, 1, -11 },
  { 319, 9, 11, 11, 1, -11 },
  { 332, 9, 11, 11, 1, -11 },
  { 345, 4, 11, 6, 1, -11 },
  { 351, 4, 14, 5, -1, -11 },
  { 358, 9, 11, 10, 1, -11 },
  { 371, 7, 11, 8, 1, -11 },
  { 381, 12, 11, 14, 1, -11 },
  { 398, 10, 11, 12, 1, -11 },
  { 412, 10, 11, 12, 1, -11 },
  { 426, 8, 11, 9, 1, -11 },
  { 437, 10, 14, 12, 1, -11 },
  { 455, 9, 11, 10, 1, -11 },
  { 468, 7, 11, 8, 1, -11 },
  { 478, 8, 11, 9, 0, -11 },
  { 489, 9, 11, 11, 1, -11 },
  { 502, 9, 11, 9, 0, -11 },
  { 515, 14, 11, 14, 0, -11 },
  { 535, 10, 11, 10, 0, -11 },
  { 549, 9, 11, 9, 0, -11 },
  { 562, 8, 11, 9, 0, -11 },
  { 573, 4, 13, 5, 1, -11 },
  { 580, 6, 11, 6, 0, -11 },
  { 589, 4, 13, 5, 0, -11 },
  { 596, 8, 7, 9, 0, -11 },
  { 603, 6, 1, 6, 0, 1 },
  { 604, 3, 2, 5, 1, -11 },
  { 605, 7, 8, 9, 1, -8 },
  { 612, 8, 11, 9, 1, -11 },
  { 623, 6, 8, 8, 1, -8 },
  { 629, 7, 11, 9, 1, -11 },
  { 639, 7, 8, 9, 1, -8 },
  { 646, 6, 11, 6, 0, -11 },
  { 655, 7, 12, 9, 1, -8 },
  { 666, 7, 11, 10, 1, -11 },
  { 676, 2, 11, 4, 1, -11 },
  { 679, 4, 15, 4, -1, -11 },
  { 687, 8, 11, 9, 1, -11 },
  { 698, 2, 11, 4, 1, -11 },
  { 701, 12, 8, 14, 1, -8 },
  { 713, 7, 8, 10, 1, -8 },
  { 720, 8, 8, 9, 1, -8 },
  { 728, 8, 12, 9, 1, -8 },
  { 740, 7, 12, 9, 1, -8 },
  { 751, 5, 8, 7, 1, -8 },
  { 756, 6, 8, 7, 1, -8 },
  { 762, 6, 10, 6, 0, -10 },
  { 770, 7, 8, 10, 1, -8 },
  { 777, 8, 8, 8, 0, -8 },
  { 785, 12, 8, 12, 0, -8 },
  { 797, 8, 8, 8, 0, -8 },
  { 805, 8, 12, 8, 0, -8 },
  { 817, 7, 8, 7, 0, -8 },
  { 824, 5, 13, 6, 0, -11 },
  { 833, 2, 14, 8, 3, -11 },
  { 837, 5, 13, 6, 1, -11 },
  { 846, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMIBOLD15PT7B_H_
