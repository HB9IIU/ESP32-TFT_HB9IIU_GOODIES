#ifndef _NOTOSANS_SEMIBOLD45PT7B_H_
#define _NOTOSANS_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xEF, 0xFF, 0xFF, 0x7E, 0x10, 0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7,
  0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x07, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0x7F, 0x71, 0xF3, 0xF1, 0xC0, 0x4F, 0xC7, 0x00, 0x3F, 0x1C, 0x00,
  0xFC, 0x70, 0x01, 0xF9, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xCF, 0xE0, 0x07, 0x1F, 0xC0, 0x1C, 0x3F, 0x00, 0x70, 0xFE,
  0x01, 0xC3, 0xFF, 0x07, 0x1F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x01, 0xF0, 0x07, 0xFF,
  0x80, 0x1E, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x00,
  0xF8, 0x7C, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x0F,
  0x80, 0x0F, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0x00, 0x0F, 0x03,
  0xC3, 0xE0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0xC7, 0xC3, 0xC0,
  0xF8, 0x7C, 0x78, 0xFF, 0x0F, 0x87, 0xCF, 0x9F, 0xF8, 0x7C, 0xF8, 0xF1,
  0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0x3E, 0x3F, 0xF3, 0xE3, 0xC3, 0xE1, 0xFE,
  0x3E, 0x7C, 0x1E, 0x03, 0x07, 0xC7, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x1F,
  0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC1, 0xE0, 0x07,
  0xC0, 0x3C, 0x1E, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x3F, 0x7E,
  0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x01, 0xF0,
  0xFF, 0xFC, 0x07, 0xE3, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x1F,
  0xC0, 0xFE, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF8,
  0x07, 0xFE, 0x07, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0x83, 0xC0, 0xDF, 0xDE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0,
  0x0C, 0x0E, 0x00, 0x20, 0x40, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xFB, 0xFF, 0xFF, 0xDF, 0x84, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xEF, 0xC0,
  0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00,
  0x3E, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xDF, 0xDF, 0xFF, 0x3F, 0x7C, 0x7E, 0x70, 0xFC, 0x41, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFC, 0x3F, 0xC3, 0xC0, 0x3F, 0x0C, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF8,
  0x3F, 0xC3, 0x00, 0x3F, 0x88, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xB0,
  0x00, 0xFE, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x7F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFD, 0xF8, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x41, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x1C, 0x03, 0xF3, 0xFE, 0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0xC7, 0xF8,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xC7,
  0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0,
  0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0xE3, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E,
  0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x7F, 0x07,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x0F, 0xF8, 0xF8,
  0x02, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x20, 0x3F, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x79, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0xDF, 0xFF, 0xFE, 0xFC, 0x20, 0x1E, 0x1F, 0x8F, 0xE7,
  0xF3, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xE0, 0xFE, 0x30, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0xFE,
  0x1E, 0x3E, 0x07, 0xFF, 0xE1, 0xE3, 0xC0, 0xFF, 0xFE, 0x1F, 0x7C, 0x1F,
  0x83, 0xC0, 0xF7, 0x83, 0xE0, 0x3C, 0x0F, 0x78, 0x3E, 0x03, 0xC0, 0xF7,
  0x83, 0xC0, 0x3C, 0x0F, 0xF8, 0x7C, 0x03, 0xC0, 0xFF, 0x87, 0xC0, 0x3C,
  0x0F, 0xF8, 0x7C, 0x03, 0xC0, 0xFF, 0x87, 0xC0, 0x7C, 0x0F, 0xF8, 0x7C,
  0x07, 0xC1, 0xEF, 0x83, 0xC0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0xE3, 0xE7,
  0x83, 0xFF, 0xFF, 0xFC, 0x78, 0x1F, 0xFC, 0xFF, 0x87, 0xC0, 0xFF, 0x8F,
  0xF0, 0x3C, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7E,
  0x3F, 0xC0, 0x06, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x06, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0x3F,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x07,
  0xE1, 0xFE, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x3F,
  0x1F, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x3F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0xFB, 0xE0, 0x01, 0xEF, 0xFE, 0xF8,
  0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x0F, 0x3F, 0xF9,
  0xF0, 0x07, 0xCF, 0xFE, 0x3E, 0x01, 0xF3, 0xFF, 0x8F, 0x80, 0x78, 0xFF,
  0xE3, 0xE0, 0x3E, 0x3F, 0xF8, 0x7C, 0x0F, 0x8F, 0xFE, 0x1F, 0x07, 0xC3,
  0xFF, 0x87, 0xC1, 0xF0, 0xFF, 0xE0, 0xF8, 0x7C, 0x3F, 0xF8, 0x3E, 0x3E,
  0x0F, 0xFE, 0x0F, 0x8F, 0x83, 0xFF, 0x81, 0xF3, 0xC0, 0xFF, 0xE0, 0x7D,
  0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xBF, 0x00, 0x3F, 0xFB, 0xF8, 0x03, 0xFF, 0x9F, 0x80, 0x3F, 0xF9,
  0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xF0,
  0x3F, 0xF8, 0x3F, 0x03, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF,
  0x80, 0xFC, 0x3F, 0xF8, 0x0F, 0xE3, 0xFF, 0x80, 0x7E, 0x3F, 0xF8, 0x07,
  0xF3, 0xFF, 0x80, 0x3F, 0x3F, 0xF8, 0x01, 0xFB, 0xFF, 0x80, 0x1F, 0xDF,
  0xF8, 0x00, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0,
  0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x3F, 0xE3, 0xF1, 0xF8, 0x01, 0x8F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x07, 0xEF, 0xF1, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xEF, 0x80,
  0x07, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFF, 0x80,
  0x1F, 0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xDE, 0x00, 0xFC,
  0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x7C, 0x03, 0xE0, 0x7E,
  0x03, 0xEF, 0x80, 0xFC, 0x0F, 0xC0, 0xF9, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x7C,
  0x1F, 0x80, 0x7E, 0x1F, 0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x03,
  0xF3, 0xE0, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x00, 0x1F, 0xFC, 0x01,
  0xEF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7B,
  0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x1E, 0x0F,
  0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF9, 0xF0, 0x00, 0xF7,
  0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFD, 0xFF, 0x06, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFB, 0xE7, 0xFF, 0x9F,
  0x1F, 0xF0, 0x78, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x9F, 0xF8, 0x3E, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFE, 0x03, 0xFB, 0xFE,
  0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0xC3, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0x01, 0x9F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x13, 0xFC, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x1F, 0xF9, 0xF8, 0x7F, 0xFB, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0x7E,
  0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x1F,
  0xE7, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xBF, 0x0F, 0xFE, 0x3E,
  0x07, 0xF8, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xE7, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80,
  0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x02, 0x3F, 0xC0,
  0x78, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xE1, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x7C, 0x3F,
  0xFC, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB,
  0xF8, 0x07, 0xF3, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0x87,
  0xFF, 0x3F, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC4, 0x00, 0x1F, 0x8E, 0x00, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x3E, 0x3F, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x38, 0xFB, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x00, 0x01, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF8, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xFC, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0xBE, 0x01, 0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F,
  0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F,
  0x80, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFE, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0x83, 0xF8, 0x3E,
  0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x8F, 0x80, 0x7F, 0x3E, 0x00,
  0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x1F, 0xFC,
  0x3F, 0xF8, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xE0, 0xFE, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xC3, 0xFE,
  0x0F, 0xBF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x80, 0xFE, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3E, 0xFF,
  0xF0, 0xF8, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xF0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF3, 0xFC, 0x3F, 0xE7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xDF, 0x87, 0xFF, 0x3F, 0x03, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xBF, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFD,
  0xFF, 0xFE, 0x7F, 0x1F, 0xBF, 0x00, 0x4F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC1, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFD, 0xF1, 0xFF, 0xE7, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x0F, 0x9F, 0x80, 0x7F, 0x80,
  0xFC, 0x7C, 0x07, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xE0, 0x3E, 0x1F, 0x81,
  0xEF, 0x01, 0xF0, 0xFC, 0x0F, 0x7C, 0x1F, 0x83, 0xE0, 0xFB, 0xE0, 0xFC,
  0x1F, 0x07, 0xCF, 0x07, 0xC0, 0xFC, 0x3C, 0x7C, 0x3E, 0x03, 0xE1, 0xE3,
  0xE3, 0xF0, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x78, 0xF8, 0x07,
  0xE7, 0x83, 0xE7, 0xC0, 0x1F, 0x3C, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0xFB,
  0xE0, 0x07, 0xDF, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x1E, 0xF8, 0x00, 0xFF,
  0x80, 0xF7, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF1, 0xFC,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0,
  0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x00,
  0x3F, 0xC0, 0x05, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFA, 0x00, 0x7F, 0xC8, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 33, 12, 3, -32 },
  { 30, 15, 11, 20, 3, -32 },
  { 51, 27, 32, 29, 1, -32 },
  { 159, 22, 37, 26, 2, -34 },
  { 261, 36, 33, 39, 2, -33 },
  { 410, 31, 33, 33, 2, -33 },
  { 538, 5, 11, 11, 3, -32 },
  { 545, 11, 39, 15, 2, -32 },
  { 599, 12, 39, 15, 1, -32 },
  { 658, 21, 21, 25, 2, -34 },
  { 714, 22, 22, 26, 2, -27 },
  { 775, 8, 11, 13, 2, -5 },
  { 786, 12, 4, 14, 1, -14 },
  { 792, 7, 7, 12, 3, -6 },
  { 799, 18, 32, 18, 0, -32 },
  { 871, 22, 33, 26, 2, -33 },
  { 962, 15, 32, 26, 3, -32 },
  { 1022, 22, 33, 26, 2, -33 },
  { 1113, 22, 33, 26, 2, -33 },
  { 1204, 24, 32, 26, 1, -32 },
  { 1300, 21, 32, 26, 2, -32 },
  { 1384, 22, 33, 26, 2, -33 },
  { 1475, 23, 32, 26, 1, -32 },
  { 1567, 22, 33, 26, 2, -33 },
  { 1658, 22, 33, 26, 2, -33 },
  { 1749, 7, 26, 12, 3, -25 },
  { 1772, 9, 31, 13, 1, -25 },
  { 1807, 22, 23, 26, 2, -28 },
  { 1871, 22, 13, 26, 2, -22 },
  { 1907, 22, 23, 26, 2, -28 },
  { 1971, 20, 34, 21, 0, -33 },
  { 2056, 36, 36, 40, 2, -32 },
  { 2218, 30, 32, 30, 0, -32 },
  { 2338, 23, 32, 30, 4, -32 },
  { 2430, 24, 33, 29, 3, -33 },
  { 2529, 26, 32, 33, 4, -32 },
  { 2633, 18, 32, 25, 4, -32 },
  { 2705, 18, 32, 24, 4, -32 },
  { 2777, 26, 33, 33, 3, -33 },
  { 2885, 26, 32, 34, 4, -32 },
  { 2989, 13, 32, 17, 2, -32 },
  { 3041, 13, 41, 14, -3, -32 },
  { 3108, 25, 32, 29, 4, -32 },
  { 3208, 19, 32, 25, 4, -32 },
  { 3284, 34, 32, 42, 4, -32 },
  { 3420, 28, 32, 36, 4, -32 },
  { 3532, 30, 33, 35, 3, -33 },
  { 3656, 22, 32, 28, 4, -32 },
  { 3744, 30, 41, 35, 3, -33 },
  { 3898, 25, 32, 29, 4, -32 },
  { 3998, 21, 33, 25, 2, -33 },
  { 4085, 24, 32, 26, 1, -32 },
  { 4181, 26, 32, 34, 4, -32 },
  { 4285, 28, 32, 28, 0, -32 },
  { 4397, 43, 32, 43, 0, -32 },
  { 4569, 29, 32, 29, 0, -32 },
  { 4685, 27, 32, 27, 0, -32 },
  { 4793, 24, 32, 26, 1, -32 },
  { 4889, 11, 39, 15, 3, -32 },
  { 4943, 18, 32, 18, 0, -32 },
  { 5015, 11, 39, 15, 1, -32 },
  { 5069, 23, 20, 26, 1, -32 },
  { 5127, 19, 3, 19, 0, 4 },
  { 5135, 11, 7, 15, 2, -34 },
  { 5145, 21, 25, 26, 2, -25 },
  { 5211, 22, 34, 28, 4, -34 },
  { 5305, 19, 25, 23, 2, -25 },
  { 5365, 23, 34, 28, 2, -34 },
  { 5463, 22, 25, 26, 2, -25 },
  { 5532, 18, 34, 17, 1, -34 },
  { 5609, 23, 36, 28, 2, -25 },
  { 5713, 21, 34, 29, 4, -34 },
  { 5803, 7, 34, 13, 3, -34 },
  { 5833, 12, 45, 13, -2, -34 },
  { 5901, 22, 34, 26, 4, -34 },
  { 5995, 5, 34, 13, 4, -34 },
  { 6017, 36, 25, 43, 4, -25 },
  { 6130, 21, 25, 29, 4, -25 },
  { 6196, 24, 25, 28, 2, -25 },
  { 6271, 22, 36, 28, 4, -25 },
  { 6370, 23, 36, 28, 2, -25 },
  { 6474, 15, 25, 20, 4, -25 },
  { 6521, 18, 25, 22, 2, -25 },
  { 6578, 16, 30, 18, 1, -30 },
  { 6638, 22, 24, 29, 3, -24 },
  { 6704, 25, 24, 25, 0, -24 },
  { 6779, 37, 24, 37, 0, -24 },
  { 6890, 25, 24, 25, 0, -24 },
  { 6965, 25, 35, 25, 0, -24 },
  { 7075, 19, 24, 22, 1, -24 },
  { 7132, 15, 39, 18, 1, -32 },
  { 7206, 5, 44, 25, 10, -34 },
  { 7234, 15, 39, 18, 2, -32 },
  { 7308, 22, 7, 26, 2, -19 },
};

const GFXfont NotoSans_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMIBOLD45PT7B_H_
