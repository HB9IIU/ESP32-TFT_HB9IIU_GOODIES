#ifndef _NOTOSANS_SEMIBOLD31PT7B_H_
#define _NOTOSANS_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF3, 0x9C, 0xE7, 0x39, 0xC0, 0x00,
  0x3D, 0xFF, 0xF8, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x7E, 0x1D,
  0x86, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x01, 0xC3, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xC7, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70,
  0x0E, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x7F, 0xFF,
  0xFF, 0xEF, 0xB3, 0xBC, 0xC0, 0xE3, 0x03, 0xCC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xDF, 0x03, 0x3C, 0x0C, 0xF8, 0x33,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3F, 0x00, 0x70, 0x3F, 0xC0, 0x70, 0x1C, 0xE0, 0x38, 0x1E, 0x38,
  0x38, 0x0E, 0x1C, 0x3C, 0x07, 0x0E, 0x1C, 0x03, 0x87, 0x1E, 0x01, 0xC3,
  0x8E, 0x00, 0xE1, 0xCE, 0x10, 0x78, 0xE7, 0x3F, 0x1C, 0xF7, 0x3F, 0xCF,
  0xF3, 0x9C, 0xE3, 0xF3, 0x9C, 0x78, 0x01, 0xCE, 0x1C, 0x01, 0xC7, 0x0E,
  0x01, 0xE3, 0x87, 0x00, 0xE1, 0xC3, 0x80, 0xE0, 0xE1, 0xC0, 0x70, 0x71,
  0xE0, 0x70, 0x1C, 0xE0, 0x38, 0x0F, 0xF0, 0x38, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x00,
  0xF0, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x07, 0x8F, 0xF8, 0x1E, 0x7D, 0xF0, 0xF1, 0xE3, 0xE3,
  0xC7, 0x87, 0xDE, 0x3E, 0x0F, 0xF8, 0xF8, 0x1F, 0xC1, 0xE0, 0x1F, 0x07,
  0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFC, 0xF0, 0x3F, 0xC1, 0xF0, 0xFF,
  0xFF, 0xEE, 0xE6, 0x0F, 0x0E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78,
  0x38, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1C,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1E, 0x73, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x0F, 0x80, 0x3B, 0x80, 0xF7, 0x83, 0xC7, 0x83, 0x8E, 0x01,
  0x10, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3D, 0xE7, 0x9E, 0x71, 0xCF,
  0x38, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x7C, 0xF0, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xC1,
  0xF0, 0xFC, 0xFF, 0x7F, 0xFE, 0xF6, 0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1F, 0xF0, 0x7F, 0xF3, 0xFF, 0xF3, 0xC1, 0xE2, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xF1,
  0xFF, 0xF1, 0x81, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xB8,
  0x03, 0xB8, 0x07, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x38, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x98, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xFC, 0x0F, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x73, 0xF0, 0xF7, 0xFC, 0xFF, 0xFC, 0xFC,
  0x3E, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xC1,
  0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x9E, 0x1E, 0x3F, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0xFF, 0xC3, 0xEF, 0xCF, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3D, 0xE0, 0x7B, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xF3, 0xFE, 0xE1,
  0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE1, 0xFF,
  0x83, 0xFE, 0x07, 0xF0, 0x00, 0xF7, 0xFF, 0xE6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xF0, 0x79, 0xF7, 0xDE, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0x9E, 0x79, 0xC7, 0x38, 0xE0, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E,
  0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0x40,
  0x00, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF, 0x98, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xE1,
  0xF8, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x70, 0x7F,
  0xCF, 0x70, 0xFF, 0xC7, 0xE1, 0xE1, 0xC7, 0xE3, 0xC3, 0xC7, 0xE3, 0x83,
  0xC7, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83,
  0x87, 0xE3, 0xC7, 0xCE, 0xE1, 0xFF, 0xFE, 0xE0, 0xFC, 0xFC, 0x70, 0x10,
  0x20, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x0E,
  0x78, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0xC1, 0xE0,
  0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x78, 0x00, 0x7C, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF,
  0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xE0, 0x67, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC1, 0xFC, 0xF0, 0x1F, 0x3C,
  0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFC, 0x06, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00,
  0xF3, 0xF0, 0x3C, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0,
  0xFF, 0xFF, 0xDF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x8F, 0xFF, 0xFF,
  0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1F, 0x1F, 0x7F, 0xBF, 0x9F, 0x80, 0xF0, 0x0F, 0xF8,
  0x0F, 0xBC, 0x0F, 0x9E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81,
  0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0x8F, 0x03, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x3C,
  0x0F, 0x9E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0xE0, 0x0F, 0xFD, 0xC0,
  0x3F, 0xFB, 0xC0, 0x77, 0xF3, 0x80, 0xEF, 0xE7, 0x03, 0xDF, 0xCF, 0x07,
  0x3F, 0x8E, 0x0E, 0x7F, 0x1C, 0x3C, 0xFE, 0x3C, 0x71, 0xFC, 0x38, 0xE3,
  0xF8, 0x73, 0xC7, 0xF0, 0xF7, 0x0F, 0xE0, 0xEE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x7F, 0x03, 0xE0, 0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x03, 0xC0,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xDE, 0x03, 0xFB, 0xE0, 0x7F, 0x3C, 0x0F, 0xE3, 0xC1, 0xFC, 0x7C, 0x3F,
  0x87, 0x87, 0xF0, 0xF8, 0xFE, 0x0F, 0x1F, 0xC0, 0xF3, 0xF8, 0x1F, 0x7F,
  0x01, 0xEF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7C, 0x0F, 0xC7, 0xC0, 0x3E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x78,
  0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x03,
  0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0, 0xFB, 0xCF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7C, 0x0F, 0xC7, 0xC0, 0x3E, 0x3C, 0x00,
  0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03,
  0xDF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1E, 0x0F, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x3C, 0x78, 0x3E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0x8F, 0x03, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x0F,
  0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7C, 0x0F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF3, 0xE0, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xC1, 0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xC0, 0xF0,
  0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x9E,
  0x00, 0x7B, 0xC0, 0x03, 0xBC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7B, 0xC0, 0x7C,
  0x03, 0xDE, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x80, 0xE7, 0x80, 0xFC, 0x0F,
  0x1C, 0x0F, 0xE0, 0x78, 0xF0, 0x77, 0x03, 0xC7, 0x83, 0xBC, 0x1C, 0x3C,
  0x3C, 0xE1, 0xE0, 0xE1, 0xE7, 0x0F, 0x07, 0x8E, 0x3C, 0x78, 0x3C, 0x71,
  0xE3, 0x81, 0xE7, 0x87, 0x3C, 0x07, 0x3C, 0x39, 0xE0, 0x3D, 0xC1, 0xEF,
  0x01, 0xEE, 0x0F, 0x70, 0x0F, 0xF0, 0x3B, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xE0,
  0x0F, 0x80, 0x78, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x3E,
  0x07, 0x83, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x00, 0x79, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xE0, 0xF0, 0x3C, 0x3E, 0x03,
  0xC7, 0x80, 0x79, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x1C, 0x70, 0x38,
  0x38, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x1E, 0x07, 0x0F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0xC1, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF, 0x3F,
  0xFE, 0xF8, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0xDF, 0xFF,
  0xBF, 0xE7, 0x3F, 0x8E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC,
  0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC,
  0xF7, 0xFC, 0xF3, 0xF0, 0x0F, 0xF1, 0xFF, 0xDF, 0xFC, 0xF8, 0x6F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x09, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0xCF, 0x3F,
  0xDE, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF,
  0xFF, 0xCF, 0xF7, 0x8F, 0xC7, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC1,
  0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F,
  0xF8, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xF6, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xFC, 0xFF, 0xCF, 0xFC, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x1F, 0x8E, 0x7F, 0xBD, 0xFF, 0xFB, 0xE3, 0xFF, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x07, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0x9E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF4, 0x03, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0xFC, 0xF7, 0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x77, 0xFE, 0xE0, 0x03, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x07, 0x07,
  0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xDF, 0xEF, 0xE7, 0xE0, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xE0,
  0x79, 0xC1, 0xF3, 0x87, 0xC7, 0x1F, 0x0E, 0x7C, 0x1D, 0xF0, 0x3B, 0xC0,
  0x7F, 0xC0, 0xFF, 0x81, 0xF7, 0x83, 0x87, 0x87, 0x0F, 0x8E, 0x0F, 0x1C,
  0x0F, 0x38, 0x1F, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x7E, 0x7B, 0xFE, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x87, 0xF1, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0xF0, 0x3F,
  0xE0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01,
  0xFC, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x3F, 0x80, 0xF0,
  0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03, 0x80, 0xF3,
  0xF9, 0xEF, 0xFB, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x78, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x7F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xF3, 0xF0, 0xF7, 0xFC, 0xFF, 0xFC, 0xFC,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC, 0xF7,
  0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x8E, 0x7F, 0xBD, 0xFF, 0xFB, 0xC3,
  0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xDF, 0xFF, 0x9F, 0xEF, 0x1F,
  0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xF1, 0xFE, 0xFF, 0xDF, 0xFF, 0xFF, 0xC1, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0xDF, 0xFC, 0xF0, 0x6F, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x07, 0xA0,
  0x3D, 0xFF, 0xCF, 0xFE, 0x7F, 0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFC, 0x7F, 0x87, 0xF0, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xEF, 0x07,
  0xDF, 0xFF, 0x9F, 0xF7, 0x1F, 0xCE, 0xF0, 0x07, 0xFC, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x78, 0x1E,
  0x3C, 0x07, 0x1C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x07, 0xBC, 0x1F,
  0x03, 0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0, 0xE3, 0x83, 0xF0, 0xF1, 0xE3,
  0xB8, 0x78, 0xF1, 0xCE, 0x3C, 0x78, 0xE7, 0x1C, 0x1C, 0xF3, 0x9E, 0x0F,
  0x71, 0xEF, 0x07, 0xB8, 0x77, 0x03, 0xDC, 0x3B, 0x80, 0xEE, 0x1F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF8,
  0x00, 0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0,
  0x7B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x01, 0xEF, 0x01, 0xF3, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0xF8, 0x1E, 0xF8,
  0x0F, 0x80, 0xF0, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE3, 0xC1,
  0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x1E, 0x03,
  0xDE, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC3, 0xF0,
  0xFC, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0xFC, 0x3C, 0x0F, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0xC1, 0xF0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF0, 0xFC, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0xFC, 0x3F, 0x0E, 0x00, 0x7F, 0x03, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F,
  0xE0,
};

const GFXglyph NotoSans_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 22, 9, 2, -22 },
  { 15, 10, 8, 14, 2, -22 },
  { 25, 18, 22, 20, 1, -22 },
  { 75, 14, 26, 18, 2, -24 },
  { 121, 25, 22, 27, 1, -22 },
  { 190, 22, 22, 23, 1, -22 },
  { 251, 4, 8, 8, 2, -22 },
  { 255, 8, 27, 10, 1, -22 },
  { 282, 8, 27, 10, 1, -22 },
  { 309, 15, 15, 17, 1, -24 },
  { 338, 15, 15, 18, 1, -18 },
  { 367, 6, 8, 9, 1, -4 },
  { 373, 8, 3, 10, 1, -10 },
  { 376, 5, 4, 9, 2, -4 },
  { 379, 12, 22, 12, 0, -22 },
  { 412, 15, 22, 18, 1, -22 },
  { 454, 10, 22, 18, 2, -22 },
  { 482, 15, 22, 18, 1, -22 },
  { 524, 15, 22, 18, 1, -22 },
  { 566, 16, 22, 18, 1, -22 },
  { 610, 14, 22, 18, 2, -22 },
  { 649, 16, 22, 18, 1, -22 },
  { 693, 16, 22, 18, 1, -22 },
  { 737, 15, 22, 18, 1, -22 },
  { 779, 15, 22, 18, 1, -22 },
  { 821, 5, 17, 9, 2, -17 },
  { 832, 6, 21, 9, 1, -17 },
  { 848, 15, 16, 18, 1, -19 },
  { 878, 15, 9, 18, 1, -15 },
  { 895, 15, 16, 18, 1, -19 },
  { 925, 14, 22, 14, 0, -22 },
  { 964, 24, 25, 28, 2, -22 },
  { 1039, 21, 22, 21, 0, -22 },
  { 1097, 16, 22, 20, 3, -22 },
  { 1141, 17, 22, 20, 2, -22 },
  { 1188, 18, 22, 23, 3, -22 },
  { 1238, 12, 22, 17, 3, -22 },
  { 1271, 12, 22, 17, 3, -22 },
  { 1304, 18, 22, 23, 2, -22 },
  { 1354, 18, 22, 23, 3, -22 },
  { 1404, 9, 22, 11, 1, -22 },
  { 1429, 9, 28, 10, -2, -22 },
  { 1461, 17, 22, 20, 3, -22 },
  { 1508, 13, 22, 17, 3, -22 },
  { 1544, 23, 22, 29, 3, -22 },
  { 1608, 19, 22, 25, 3, -22 },
  { 1661, 21, 22, 24, 2, -22 },
  { 1719, 15, 22, 19, 3, -22 },
  { 1761, 21, 27, 24, 2, -22 },
  { 1832, 17, 22, 20, 3, -22 },
  { 1879, 15, 22, 17, 1, -22 },
  { 1921, 17, 22, 18, 0, -22 },
  { 1968, 17, 22, 23, 3, -22 },
  { 2015, 20, 22, 20, 0, -22 },
  { 2070, 29, 22, 30, 0, -22 },
  { 2150, 20, 22, 20, 0, -22 },
  { 2205, 19, 22, 19, 0, -22 },
  { 2258, 16, 22, 18, 1, -22 },
  { 2302, 7, 27, 10, 2, -22 },
  { 2326, 12, 22, 12, 0, -22 },
  { 2359, 7, 27, 10, 1, -22 },
  { 2383, 16, 14, 18, 1, -22 },
  { 2411, 13, 2, 13, 0, 3 },
  { 2415, 8, 5, 10, 1, -24 },
  { 2420, 15, 17, 18, 1, -17 },
  { 2452, 16, 24, 19, 2, -24 },
  { 2500, 13, 17, 16, 2, -17 },
  { 2528, 15, 24, 19, 2, -24 },
  { 2573, 15, 17, 18, 2, -17 },
  { 2605, 12, 24, 12, 1, -24 },
  { 2641, 15, 24, 19, 2, -17 },
  { 2686, 15, 24, 20, 2, -24 },
  { 2731, 5, 23, 9, 2, -23 },
  { 2746, 9, 30, 9, -2, -23 },
  { 2780, 15, 24, 18, 3, -24 },
  { 2825, 4, 24, 9, 2, -24 },
  { 2837, 25, 17, 30, 2, -17 },
  { 2891, 15, 17, 20, 2, -17 },
  { 2923, 16, 17, 19, 2, -17 },
  { 2957, 16, 24, 19, 2, -17 },
  { 3005, 15, 24, 19, 2, -17 },
  { 3050, 11, 17, 13, 2, -17 },
  { 3074, 13, 17, 15, 1, -17 },
  { 3102, 11, 20, 13, 1, -20 },
  { 3130, 15, 17, 20, 2, -17 },
  { 3162, 17, 17, 17, 0, -17 },
  { 3199, 25, 17, 26, 0, -17 },
  { 3253, 17, 17, 17, 0, -17 },
  { 3290, 17, 24, 17, 0, -17 },
  { 3341, 13, 17, 15, 1, -17 },
  { 3369, 10, 27, 12, 1, -22 },
  { 3403, 3, 31, 17, 7, -24 },
  { 3415, 10, 27, 12, 1, -22 },
  { 3449, 15, 4, 18, 1, -13 },
};

const GFXfont NotoSans_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMIBOLD31PT7B_H_
