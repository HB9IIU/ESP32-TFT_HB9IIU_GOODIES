#ifndef _NOTOSANS_SEMIBOLD16PT7B_H_
#define _NOTOSANS_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0x90, 0x09, 0x86, 0x41, 0x91, 0xFF,
  0x13, 0x04, 0xCF, 0xFB, 0xFE, 0x36, 0x09, 0x82, 0x60, 0x10, 0xFB, 0xFE,
  0x8D, 0x1E, 0x0F, 0x0F, 0x17, 0xAF, 0xF0, 0x81, 0x00, 0x60, 0x0F, 0x0C,
  0x99, 0x89, 0x90, 0x9B, 0x09, 0xAE, 0xF6, 0xB2, 0xD9, 0x0D, 0x91, 0x99,
  0x10, 0xB3, 0x0F, 0x18, 0x0F, 0xC1, 0x98, 0x33, 0x06, 0xC0, 0x70, 0x1E,
  0x36, 0x66, 0xC7, 0x98, 0x73, 0xFE, 0x3E, 0x70, 0xFF, 0x76, 0xCC, 0xCC,
  0x8C, 0xCC, 0xC6, 0x63, 0xE1, 0x0C, 0x61, 0x0C, 0x63, 0x11, 0x8C, 0x66,
  0x60, 0x30, 0x23, 0x5F, 0xF3, 0x8D, 0xBB, 0x00, 0x10, 0x20, 0x40, 0x8F,
  0xE2, 0x04, 0x08, 0xFE, 0xFF, 0xF0, 0x0C, 0x31, 0x86, 0x10, 0xC3, 0x18,
  0x61, 0x8C, 0x00, 0x10, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D,
  0xFB, 0xE0, 0x3B, 0xF6, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x10, 0xFC, 0xC6,
  0x06, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x31, 0xFA, 0x18,
  0x30, 0x6F, 0x9F, 0x03, 0x06, 0x0F, 0x7F, 0xE0, 0x06, 0x07, 0x07, 0x82,
  0xC3, 0x63, 0x31, 0x19, 0xFF, 0xFF, 0x83, 0x01, 0x80, 0xFF, 0x83, 0x06,
  0x0F, 0xCB, 0xC1, 0x83, 0x07, 0xFF, 0xF0, 0x0C, 0x3E, 0x60, 0xC0, 0xC0,
  0xFE, 0xE6, 0xC6, 0xC3, 0xC6, 0x7E, 0x3C, 0xFF, 0x06, 0x06, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x10, 0x7E, 0xC6, 0xC6, 0xE6, 0x7C,
  0x7C, 0xC6, 0xC6, 0xC3, 0xEE, 0x7C, 0x10, 0xFB, 0x1E, 0x3C, 0x78, 0xFF,
  0xBF, 0x06, 0x0E, 0x77, 0xC0, 0xF4, 0x03, 0xC0, 0x6C, 0x80, 0x03, 0x6F,
  0x00, 0x02, 0x0C, 0x73, 0x8C, 0x0F, 0x07, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x81, 0xC1, 0xE0, 0xF0, 0x63, 0xBC, 0x60, 0x39, 0xF9, 0x18, 0x30,
  0x63, 0x86, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x1F, 0xC1, 0x83, 0x18, 0x0D,
  0x9F, 0x2D, 0x89, 0xCC, 0xCE, 0x66, 0x53, 0x32, 0xCE, 0xE6, 0x00, 0x18,
  0x10, 0x7F, 0x80, 0x0E, 0x03, 0xC0, 0x6C, 0x0D, 0x83, 0x30, 0x63, 0x0F,
  0xE3, 0xFC, 0x60, 0xCC, 0x1B, 0x03, 0x80, 0xFF, 0x71, 0xB8, 0xDC, 0x6F,
  0xE7, 0xFB, 0x8F, 0xC3, 0xE3, 0xFF, 0xBF, 0x80, 0x0E, 0x1F, 0xDC, 0x5C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x1F, 0xC7, 0xE0, 0xFF, 0x39,
  0xEE, 0x1B, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x86, 0xE3, 0xBF, 0xCF, 0xE0,
  0xFF, 0xC3, 0x87, 0x0F, 0xFF, 0xF8, 0x70, 0xE1, 0xFF, 0xF8, 0xFF, 0xC3,
  0x87, 0x0E, 0x1F, 0xF8, 0x70, 0xE1, 0xC3, 0x80, 0x06, 0x1F, 0xDC, 0x3C,
  0x0C, 0x06, 0x03, 0x1F, 0x83, 0xC1, 0xB0, 0xDF, 0xE7, 0xF0, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0C,
  0xF6, 0x66, 0x66, 0x66, 0x6E, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x6F, 0x70, 0xE3, 0xF3, 0xB9, 0x9D, 0x8F, 0x87, 0xE3, 0xB1, 0xCC,
  0xE7, 0x71, 0xB8, 0x60, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xFF, 0xF8, 0xF0, 0x7F, 0x07, 0xD0, 0x5D, 0x8F, 0xD8, 0xBC, 0x9B, 0xCD,
  0xBC, 0xD3, 0xC7, 0x3C, 0x73, 0xC6, 0x30, 0xF0, 0xFC, 0x3D, 0x8F, 0x63,
  0xCC, 0xF3, 0xBC, 0x6F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1C, 0x0E, 0x07, 0xF1,
  0xC7, 0x70, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xCC, 0x19, 0xFE,
  0x1F, 0x80, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0,
  0xE0, 0x0E, 0x07, 0xF1, 0xC7, 0x70, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xCC, 0x19, 0xFE, 0x1F, 0x80, 0x30, 0x03, 0x00, 0x30, 0xFE, 0x73,
  0xB8, 0xDC, 0x6E, 0x77, 0xF3, 0xB1, 0xCC, 0xE7, 0x71, 0xB8, 0x60, 0x18,
  0xFF, 0x16, 0x0C, 0x0E, 0x0F, 0x07, 0x06, 0x0F, 0xFF, 0xE0, 0xFF, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x61, 0x9F, 0xE3,
  0xF0, 0xC0, 0xD8, 0x66, 0x19, 0x86, 0x33, 0x0C, 0xC3, 0x30, 0x78, 0x1E,
  0x07, 0x80, 0xC0, 0xC3, 0x86, 0xC7, 0x0D, 0x8E, 0x33, 0x16, 0x66, 0x6C,
  0xC6, 0xD9, 0x8D, 0x9E, 0x1A, 0x3C, 0x3C, 0x78, 0x38, 0x70, 0x60, 0xC0,
  0xE1, 0xCC, 0xE3, 0x30, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0xCC, 0x33, 0x98,
  0x6E, 0x1C, 0xE1, 0xD8, 0xE3, 0x30, 0xDC, 0x1E, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x7F, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x3F, 0xFF, 0xE0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF,
  0xC1, 0x86, 0x08, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC0, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFF, 0x18, 0x0E, 0x0D, 0x06, 0xC2, 0x23, 0x1B, 0x06,
  0xFF, 0xFC, 0xC7, 0x3C, 0xFC, 0x18, 0x37, 0xF8, 0xF1, 0xE7, 0xFA, 0xC0,
  0xC0, 0xC0, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0xDE, 0x3E,
  0xFB, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0x7C, 0x03, 0x03, 0x03, 0x3B, 0x7F,
  0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7B, 0x3C, 0x7E, 0xC6, 0xC3, 0xFF,
  0xC0, 0xC0, 0x76, 0x3E, 0x3E, 0x68, 0xC3, 0xEF, 0xC6, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x80, 0x3B, 0x7F, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xEF, 0x7B,
  0x03, 0x07, 0xFE, 0x7C, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xF3, 0xFF, 0xFF, 0x33, 0x03, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFE, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xD8, 0xF8, 0xFC,
  0xCC, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xDC, 0x77, 0xF7, 0xF9, 0xC7, 0x86,
  0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x18, 0xDE, 0xFF, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC3, 0x66, 0x3C, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0xDE,
  0xC0, 0xC0, 0xC0, 0xC0, 0x3B, 0x7F, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xEF,
  0x7B, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0x7B, 0xFC, 0x38, 0x78, 0x70, 0xF3, 0xF8, 0x30, 0xC7, 0xFF, 0x71, 0xC7,
  0x1C, 0x70, 0xD3, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0x7B, 0xC1, 0xF1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0xD0, 0x38, 0x1C, 0x00,
  0xC7, 0x1E, 0x38, 0xD9, 0x44, 0xCB, 0x66, 0xDB, 0x16, 0xD8, 0xE2, 0x87,
  0x1C, 0x38, 0xE0, 0xE3, 0xB1, 0x8D, 0x87, 0x81, 0xC0, 0xE0, 0xD8, 0xC6,
  0xE3, 0x80, 0xC1, 0xF1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0xD0, 0x38, 0x1C,
  0x0C, 0x06, 0x1E, 0x0E, 0x00, 0xFF, 0xF1, 0x86, 0x31, 0x8E, 0x3F, 0xFC,
  0x1C, 0xC3, 0x0C, 0x30, 0xCC, 0x1C, 0x30, 0xC3, 0x0C, 0x1C, 0x10, 0xFF,
  0xFF, 0xE3, 0x18, 0xC6, 0x38, 0x6E, 0x63, 0x18, 0xCE, 0x40, 0xE3, 0xFE,
  0x10,
};

const GFXglyph NotoSans_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 10, 11, 10, 0, -11 },
  { 21, 7, 13, 9, 1, -12 },
  { 33, 12, 12, 14, 1, -12 },
  { 51, 11, 12, 12, 1, -12 },
  { 68, 2, 4, 4, 1, -11 },
  { 69, 4, 14, 5, 1, -11 },
  { 76, 5, 14, 5, 0, -11 },
  { 85, 7, 7, 9, 1, -12 },
  { 92, 7, 8, 9, 1, -10 },
  { 99, 2, 4, 4, 1, -2 },
  { 100, 4, 2, 5, 1, -5 },
  { 101, 2, 2, 4, 1, -2 },
  { 102, 6, 11, 6, 0, -11 },
  { 111, 7, 12, 9, 1, -12 },
  { 122, 5, 11, 9, 1, -11 },
  { 129, 8, 12, 9, 1, -12 },
  { 141, 7, 12, 9, 1, -12 },
  { 152, 9, 11, 9, 0, -11 },
  { 165, 7, 11, 9, 1, -11 },
  { 175, 8, 12, 9, 1, -12 },
  { 187, 8, 11, 9, 1, -11 },
  { 198, 8, 12, 9, 1, -12 },
  { 210, 7, 12, 9, 1, -12 },
  { 221, 2, 9, 4, 1, -9 },
  { 224, 3, 11, 4, 0, -9 },
  { 229, 7, 8, 9, 1, -10 },
  { 236, 7, 5, 9, 1, -8 },
  { 241, 7, 8, 9, 1, -10 },
  { 248, 7, 12, 7, 0, -12 },
  { 259, 13, 12, 14, 1, -11 },
  { 279, 11, 11, 11, 0, -11 },
  { 295, 9, 11, 11, 1, -11 },
  { 308, 9, 12, 10, 1, -12 },
  { 322, 10, 11, 12, 1, -11 },
  { 336, 7, 11, 9, 1, -11 },
  { 346, 7, 11, 9, 1, -11 },
  { 356, 9, 12, 12, 1, -12 },
  { 370, 10, 11, 12, 1, -11 },
  { 384, 4, 11, 6, 1, -11 },
  { 390, 5, 14, 5, -1, -11 },
  { 399, 9, 11, 10, 1, -11 },
  { 412, 7, 11, 9, 1, -11 },
  { 422, 12, 11, 15, 1, -11 },
  { 439, 10, 11, 13, 1, -11 },
  { 453, 11, 12, 13, 1, -12 },
  { 470, 8, 11, 10, 1, -11 },
  { 481, 11, 15, 13, 1, -12 },
  { 502, 9, 11, 10, 1, -11 },
  { 515, 7, 12, 9, 1, -12 },
  { 526, 9, 11, 9, 0, -11 },
  { 539, 10, 11, 12, 1, -11 },
  { 553, 10, 11, 10, 0, -11 },
  { 567, 15, 11, 15, 0, -11 },
  { 588, 10, 11, 10, 0, -11 },
  { 602, 10, 11, 10, 0, -11 },
  { 616, 9, 11, 9, 0, -11 },
  { 629, 4, 14, 5, 1, -11 },
  { 636, 6, 11, 6, 0, -11 },
  { 645, 4, 14, 5, 0, -11 },
  { 652, 9, 7, 9, 0, -11 },
  { 660, 7, 2, 7, 0, 1 },
  { 662, 4, 2, 5, 1, -12 },
  { 663, 7, 9, 9, 1, -9 },
  { 671, 8, 12, 10, 1, -12 },
  { 683, 7, 9, 8, 1, -9 },
  { 691, 8, 12, 10, 1, -12 },
  { 703, 8, 9, 9, 1, -9 },
  { 712, 7, 12, 6, 0, -12 },
  { 723, 8, 13, 10, 1, -9 },
  { 736, 8, 12, 10, 1, -12 },
  { 748, 2, 12, 5, 1, -12 },
  { 751, 4, 16, 5, -1, -12 },
  { 759, 8, 12, 9, 1, -12 },
  { 771, 2, 12, 5, 1, -12 },
  { 774, 13, 9, 15, 1, -9 },
  { 789, 8, 9, 10, 1, -9 },
  { 798, 8, 9, 10, 1, -9 },
  { 807, 8, 13, 10, 1, -9 },
  { 820, 8, 13, 10, 1, -9 },
  { 833, 6, 9, 7, 1, -9 },
  { 840, 6, 9, 8, 1, -9 },
  { 847, 6, 11, 7, 0, -11 },
  { 856, 8, 9, 10, 1, -9 },
  { 865, 9, 9, 9, 0, -9 },
  { 876, 13, 9, 13, 0, -9 },
  { 891, 9, 9, 9, 0, -9 },
  { 902, 9, 13, 9, 0, -9 },
  { 917, 6, 9, 8, 1, -9 },
  { 924, 6, 14, 6, 0, -11 },
  { 935, 1, 16, 9, 4, -12 },
  { 937, 5, 14, 6, 1, -11 },
  { 946, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMIBOLD16PT7B_H_
