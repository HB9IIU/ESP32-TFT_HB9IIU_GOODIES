#ifndef _NOTOSANS_SEMIBOLD41PT7B_H_
#define _NOTOSANS_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x7C, 0xFF,
  0xFB, 0xF7, 0xC2, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xDE, 0x1E, 0xF0, 0x77, 0x83, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03,
  0x83, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE0, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE, 0xFC,
  0xFC, 0xE0, 0xCF, 0x8E, 0x00, 0xF8, 0xE0, 0x0F, 0xCE, 0x00, 0xFE, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0E, 0xFE, 0x00, 0xE3, 0xE0, 0x0E, 0x3F, 0x00,
  0xE3, 0xF8, 0x0E, 0x3E, 0xF0, 0xE7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x7F,
  0xE0, 0x07, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x00, 0xF0,
  0xF0, 0x1E, 0x00, 0xF0, 0xF8, 0x1E, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0xF8, 0x00, 0xF0,
  0xF8, 0xF0, 0x00, 0xF0, 0xF9, 0xF1, 0xF0, 0xF0, 0xF1, 0xE7, 0xFC, 0xF8,
  0xF3, 0xC7, 0xFE, 0x7F, 0xF3, 0xCF, 0xFE, 0x7F, 0xE7, 0x8F, 0x1F, 0x3F,
  0xC7, 0x9F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x00, 0x1F, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x0F, 0x00, 0x3E, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00,
  0x7C, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x07, 0xFE, 0x03, 0xE0, 0x07, 0xFC, 0x03,
  0xC0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFB, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7E, 0x3F,
  0xFE, 0x07, 0xC7, 0xF7, 0xF0, 0x7C, 0x7E, 0x3F, 0x8F, 0xCF, 0xC1, 0xFC,
  0xF8, 0xF8, 0x0F, 0xFF, 0x8F, 0x80, 0x7F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F,
  0xC0, 0x1F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x07, 0x83, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0x7C, 0xF1, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x1F, 0x0F, 0x80, 0x70,
  0x70, 0x01, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xF9, 0xFF, 0xF7,
  0xEF, 0x84, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x87, 0xE0, 0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xE7, 0xC0,
  0x7E, 0x7C, 0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF,
  0xBF, 0xFF, 0xFB, 0xFF, 0x9F, 0x70, 0xF9, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xC0, 0xFC, 0x30, 0x07, 0xE2, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0x80, 0xFC, 0x20, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x80, 0x07, 0xEE, 0x00, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F,
  0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0xF9, 0xFF, 0x0F,
  0xBF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7,
  0xC0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x7E, 0x07, 0xC3, 0xF1, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xF1, 0xFC, 0x7E, 0x0F, 0xEF, 0xC0,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xF7, 0xFB, 0xFF, 0x7F, 0xFD, 0xF3, 0xFF, 0x9E, 0x0F,
  0xF1, 0xE0, 0x10, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x38, 0xF9, 0xFF, 0xF7, 0xEF, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xF3, 0xFF, 0xEF,
  0xDF, 0x08, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8C, 0x03, 0xF2, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x01,
  0xE0, 0x3C, 0x3C, 0x07, 0xFF, 0x0F, 0x1E, 0x0F, 0xFF, 0x87, 0x9E, 0x0F,
  0xFF, 0xC3, 0xCF, 0x0F, 0x81, 0xE0, 0xF7, 0x87, 0xC0, 0xF0, 0x7F, 0x83,
  0xC0, 0x78, 0x3F, 0xC3, 0xE0, 0x3C, 0x1F, 0xE1, 0xE0, 0x1E, 0x0F, 0xF0,
  0xF0, 0x0F, 0x07, 0xF8, 0x78, 0x0F, 0x83, 0xBC, 0x3C, 0x07, 0xC3, 0xDE,
  0x0F, 0x03, 0xE1, 0xEF, 0x07, 0xC3, 0xF1, 0xE3, 0xC3, 0xFF, 0xFF, 0xF1,
  0xE0, 0xFF, 0xCF, 0xF0, 0xF0, 0x3F, 0xC7, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10,
  0x00, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0xFF,
  0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x1F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xF8, 0x07, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7E, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x03, 0x87, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x78, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xF8, 0xF8, 0x03,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0xFC, 0xF8, 0x01, 0xFC, 0xF8, 0x03, 0xF8, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0x80,
  0x70, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x87, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00,
  0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F,
  0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8,
  0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xF1,
  0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xE0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDE, 0x00, 0x1E,
  0xFF, 0x78, 0x00, 0x7B, 0xFD, 0xF0, 0x03, 0xFF, 0xF3, 0xC0, 0x0F, 0x7F,
  0xCF, 0x00, 0x3D, 0xFF, 0x3E, 0x01, 0xF7, 0xFC, 0x78, 0x07, 0x9F, 0xF9,
  0xE0, 0x1E, 0x7F, 0xE7, 0xC0, 0xF9, 0xFF, 0x8F, 0x03, 0xC7, 0xFE, 0x3C,
  0x1F, 0x1F, 0xF8, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xE1, 0xFF, 0x87, 0x8F,
  0x87, 0xFE, 0x1F, 0x3C, 0x1F, 0xF8, 0x3C, 0xF0, 0x7F, 0xE0, 0xF7, 0xC1,
  0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xE0, 0x7F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8,
  0x0F, 0x80, 0x7C, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0x00,
  0x3F, 0xEF, 0xC0, 0x1F, 0xF3, 0xF0, 0x0F, 0xF9, 0xF8, 0x07, 0xFC, 0x7E,
  0x03, 0xFE, 0x1F, 0x01, 0xFF, 0x0F, 0xC0, 0xFF, 0x83, 0xF0, 0x7F, 0xE1,
  0xF8, 0x3F, 0xF0, 0x7E, 0x1F, 0xF8, 0x1F, 0x0F, 0xFC, 0x0F, 0xC7, 0xFE,
  0x03, 0xF3, 0xFF, 0x01, 0xF9, 0xFF, 0x80, 0x7E, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8,
  0x0F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFC, 0x07,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xDF, 0x01, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0x7F, 0x00, 0x7E, 0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0xF8, 0x01,
  0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xF0, 0x03,
  0xE7, 0xE0, 0x0F, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0xE0, 0x1F, 0x0F, 0x80,
  0x7B, 0xC0, 0x3E, 0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x3F, 0x01, 0xEF, 0x01,
  0xF8, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0xF8,
  0x1E, 0x3C, 0x0F, 0x80, 0xF8, 0x7C, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0xF8,
  0x7C, 0x03, 0xE1, 0xE0, 0xF0, 0xF8, 0x07, 0xC3, 0xC1, 0xE1, 0xF0, 0x07,
  0x8F, 0x83, 0xE3, 0xE0, 0x0F, 0x9F, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x07,
  0x9F, 0x00, 0x3E, 0x78, 0x0F, 0x3E, 0x00, 0x3D, 0xF0, 0x1F, 0x7C, 0x00,
  0x7F, 0xE0, 0x3E, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x87,
  0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xF1, 0xFC, 0x30, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xF3, 0xC7, 0xF8, 0x78,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x18, 0x07,
  0xC7, 0xF8, 0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03,
  0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0xC1, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7D, 0xFF, 0xC3, 0xC3, 0xFC, 0x00, 0x00, 0x30,
  0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF3, 0xF8, 0x09, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x67, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xC1, 0xF0, 0xFF, 0x9F,
  0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x7F, 0x7E, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFE, 0xF1,
  0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0x8F, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x63, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x8F, 0x1F, 0xFC,
  0xF3, 0xFF, 0xEF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF,
  0x07, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF6, 0x00, 0x3F, 0x7F, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x18, 0x0F, 0x8F, 0xF8, 0xFB, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x73, 0xEF,
  0xFF, 0xF8, 0xC0, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x03, 0x80,
  0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE9,
  0xFD, 0xFF, 0xBF, 0xE7, 0xF8, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xBE, 0x01, 0xF9,
  0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x1F,
  0x80, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C,
  0x01, 0xFB, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x18, 0x00, 0xE0, 0x78, 0xFF, 0x83, 0xFE, 0x3E, 0xFF, 0xF3,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC,
  0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x18, 0x0F, 0x0F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x30,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F,
  0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x1C, 0x07, 0xC7, 0xF8, 0x3E, 0xFF, 0xF1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0,
  0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0xC1,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7D, 0xFF, 0xC3, 0xE3, 0xFC, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x8F, 0x1F, 0xFC, 0xF3, 0xFF, 0xEF,
  0x3F, 0xFF, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F,
  0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x07, 0xF9, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x1F, 0xFE, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFC, 0x1E, 0xF8, 0x02, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFC, 0xF0,
  0xFF, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80,
  0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xFC, 0x03, 0xE7,
  0xC0, 0x7F, 0x80, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x3E, 0x07, 0xF8, 0x1F,
  0x0F, 0x81, 0xFE, 0x07, 0xC3, 0xE0, 0xF3, 0xC1, 0xF0, 0x7C, 0x3C, 0xF0,
  0xF8, 0x1F, 0x0F, 0x3C, 0x3E, 0x07, 0xC7, 0xCF, 0x8F, 0x81, 0xF1, 0xE1,
  0xE3, 0xE0, 0x3E, 0x78, 0x79, 0xF0, 0x0F, 0x9E, 0x1E, 0x7C, 0x03, 0xEF,
  0x87, 0xDF, 0x00, 0x7B, 0xC0, 0xF7, 0x80, 0x1E, 0xF0, 0x3D, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F,
  0x80, 0xFC, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x0F, 0xDF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0,
  0x0F, 0x9F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x11, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x1F, 0xF0, 0xFF, 0x07,
  0xC0, 0x3F, 0x81, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0xFE, 0x1F, 0xF0, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3E, 0x00, 0x0C,
  0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8,
  0x07, 0xFC, 0x80, 0x07, 0x00,
};

const GFXglyph NotoSans_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 30, 11, 2, -29 },
  { 28, 13, 10, 19, 3, -29 },
  { 45, 25, 29, 26, 1, -29 },
  { 136, 20, 33, 23, 2, -31 },
  { 219, 32, 30, 36, 2, -30 },
  { 339, 28, 30, 30, 2, -30 },
  { 444, 5, 10, 10, 3, -29 },
  { 451, 10, 35, 13, 2, -29 },
  { 495, 11, 35, 13, 1, -29 },
  { 544, 20, 19, 22, 1, -31 },
  { 592, 20, 19, 23, 2, -24 },
  { 640, 8, 10, 11, 1, -5 },
  { 650, 11, 4, 13, 1, -13 },
  { 656, 7, 7, 11, 2, -6 },
  { 663, 16, 29, 16, 0, -29 },
  { 721, 20, 30, 23, 2, -30 },
  { 796, 13, 29, 23, 3, -29 },
  { 844, 20, 30, 23, 2, -30 },
  { 919, 20, 30, 23, 2, -30 },
  { 994, 22, 29, 23, 1, -29 },
  { 1074, 19, 29, 23, 2, -29 },
  { 1143, 20, 30, 23, 2, -30 },
  { 1218, 21, 29, 23, 1, -29 },
  { 1295, 20, 30, 23, 2, -30 },
  { 1370, 20, 30, 23, 2, -30 },
  { 1445, 7, 24, 11, 2, -23 },
  { 1466, 8, 28, 11, 1, -23 },
  { 1494, 20, 21, 23, 2, -25 },
  { 1547, 19, 11, 23, 2, -20 },
  { 1574, 20, 21, 23, 2, -25 },
  { 1627, 18, 31, 19, 0, -30 },
  { 1697, 33, 32, 37, 2, -29 },
  { 1829, 28, 29, 28, 0, -29 },
  { 1931, 21, 29, 27, 4, -29 },
  { 2008, 23, 30, 26, 2, -30 },
  { 2095, 24, 29, 30, 4, -29 },
  { 2182, 16, 29, 23, 4, -29 },
  { 2240, 16, 29, 22, 4, -29 },
  { 2298, 25, 30, 30, 2, -30 },
  { 2392, 23, 29, 31, 4, -29 },
  { 2476, 13, 29, 15, 1, -29 },
  { 2524, 12, 37, 13, -3, -29 },
  { 2580, 23, 29, 27, 4, -29 },
  { 2664, 17, 29, 22, 4, -29 },
  { 2726, 30, 29, 38, 4, -29 },
  { 2835, 25, 29, 33, 4, -29 },
  { 2926, 28, 30, 32, 2, -30 },
  { 3031, 19, 29, 25, 4, -29 },
  { 3100, 28, 37, 32, 2, -30 },
  { 3230, 22, 29, 26, 4, -29 },
  { 3310, 19, 30, 23, 2, -30 },
  { 3382, 22, 29, 23, 1, -29 },
  { 3462, 23, 29, 31, 4, -29 },
  { 3546, 26, 29, 26, 0, -29 },
  { 3641, 39, 29, 39, 0, -29 },
  { 3783, 26, 29, 26, 0, -29 },
  { 3878, 25, 29, 25, 0, -29 },
  { 3969, 21, 29, 24, 1, -29 },
  { 4046, 10, 35, 14, 3, -29 },
  { 4090, 16, 29, 16, 0, -29 },
  { 4148, 10, 35, 14, 1, -29 },
  { 4192, 21, 18, 23, 1, -29 },
  { 4240, 17, 2, 17, 0, 4 },
  { 4245, 10, 6, 14, 2, -31 },
  { 4253, 19, 23, 24, 2, -23 },
  { 4308, 21, 31, 26, 3, -31 },
  { 4390, 17, 23, 21, 2, -23 },
  { 4439, 20, 31, 26, 2, -31 },
  { 4517, 20, 23, 24, 2, -23 },
  { 4575, 16, 31, 15, 1, -31 },
  { 4637, 20, 33, 26, 2, -23 },
  { 4720, 20, 31, 26, 3, -31 },
  { 4798, 6, 31, 12, 3, -31 },
  { 4822, 11, 41, 12, -2, -31 },
  { 4879, 21, 31, 24, 3, -31 },
  { 4961, 5, 31, 12, 3, -31 },
  { 4981, 33, 23, 39, 3, -23 },
  { 5076, 20, 23, 26, 3, -23 },
  { 5134, 21, 23, 25, 2, -23 },
  { 5195, 21, 33, 26, 3, -23 },
  { 5282, 20, 33, 26, 2, -23 },
  { 5365, 14, 23, 18, 3, -23 },
  { 5406, 16, 23, 20, 2, -23 },
  { 5452, 15, 27, 17, 1, -27 },
  { 5503, 20, 22, 26, 3, -22 },
  { 5558, 22, 22, 22, 0, -22 },
  { 5619, 34, 22, 34, 0, -22 },
  { 5713, 23, 22, 23, 0, -22 },
  { 5777, 22, 32, 22, 0, -22 },
  { 5865, 17, 22, 20, 1, -22 },
  { 5912, 13, 35, 16, 1, -29 },
  { 5969, 4, 41, 23, 9, -31 },
  { 5990, 13, 35, 16, 2, -29 },
  { 6047, 20, 7, 23, 2, -18 },
};

const GFXfont NotoSans_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMIBOLD41PT7B_H_
