#ifndef _NOTOSANS_SEMIBOLD32PT7B_H_
#define _NOTOSANS_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x09, 0xFF, 0xFF, 0xC0, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x77,
  0x1D, 0x87, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC3, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x1F, 0x81, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xBC, 0xC2, 0x79, 0x80,
  0xF3, 0x01, 0xF6, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x01, 0x9F, 0x03, 0x1E, 0x06, 0x3E, 0x0C, 0xFF, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1F, 0x00,
  0x78, 0x0F, 0xE0, 0x1C, 0x07, 0xFC, 0x0F, 0x01, 0xC7, 0x03, 0x80, 0xF1,
  0xC1, 0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1E, 0x38, 0x03, 0x87, 0x8E, 0x00,
  0xE1, 0xC7, 0x00, 0x3C, 0x73, 0xCF, 0x87, 0x1C, 0xE7, 0xF1, 0xFF, 0x7B,
  0xFE, 0x3F, 0x9C, 0xE3, 0x87, 0xCF, 0x38, 0xF0, 0x03, 0x8E, 0x3C, 0x01,
  0xC7, 0x87, 0x00, 0x71, 0xE1, 0xC0, 0x38, 0x38, 0xF0, 0x1E, 0x0E, 0x3C,
  0x07, 0x03, 0x8E, 0x03, 0xC0, 0xF7, 0x80, 0xE0, 0x1F, 0xC0, 0x78, 0x03,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF1, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x03, 0xE3,
  0xFF, 0x07, 0x8F, 0x9F, 0x0F, 0x1E, 0x1F, 0x3C, 0x3C, 0x1F, 0x78, 0xF8,
  0x1F, 0xE1, 0xF0, 0x1F, 0xC1, 0xE0, 0x1F, 0x03, 0xF0, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xDF, 0x03, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x76,
  0x07, 0x0F, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x06, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF3, 0xC3, 0xC7, 0x81, 0x86, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3D, 0xF7, 0x9E, 0x79, 0xCF, 0x38, 0xFF,
  0xFF, 0xFF, 0x27, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3E, 0x3C, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3,
  0xFF, 0xF3, 0xDC, 0x79, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7C, 0x7E, 0x30, 0x1E,
  0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x78, 0x7E, 0x20, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1D, 0xE0, 0x1E,
  0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x87,
  0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7A, 0x00, 0xF6, 0x07,
  0xEF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x60, 0x73, 0xF8, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3E, 0x3E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3E, 0x3C, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C, 0x7E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7C, 0x78, 0x1E, 0xF8,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7E,
  0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0x8F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x13, 0xFF, 0xFF, 0x80, 0x39,
  0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x79,
  0xE7, 0x1C, 0xF3, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0xE3, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F,
  0x40, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0xFE, 0x1C, 0xE0, 0xFF, 0x8F, 0xF0,
  0xFF, 0xC3, 0xF0, 0xF0, 0xE1, 0xF8, 0xF0, 0x70, 0xFC, 0x78, 0x38, 0x7E,
  0x38, 0x1C, 0x3F, 0x1C, 0x0E, 0x1F, 0x8E, 0x07, 0x0F, 0xC7, 0x87, 0x8E,
  0xE1, 0xC7, 0xC7, 0x70, 0xFF, 0x7F, 0x3C, 0x3F, 0x1F, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x38, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xE1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0xF8, 0x01,
  0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF1, 0xFE, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC7,
  0xFF, 0xE7, 0xF1, 0xF3, 0xE0, 0x13, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x71, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x01, 0xF9, 0xE0, 0x1F, 0x3C, 0x01,
  0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07,
  0xDE, 0x01, 0xF3, 0xC0, 0x7E, 0x78, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xE3, 0xE3, 0xE0, 0x04, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x80, 0x3D, 0xF8, 0x07, 0x9F, 0xC1, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xE0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x7F, 0xBF, 0xFF, 0xFC, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x87, 0xBF, 0xDF, 0xCF, 0xC0, 0xF0, 0x07, 0xFC, 0x03,
  0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x0F, 0x03,
  0xC7, 0x80, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x03, 0xE3, 0xC0, 0x78, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xEE, 0x00, 0x7F, 0xEE, 0x00, 0xFF, 0xFF,
  0x00, 0xEF, 0xF7, 0x00, 0xEF, 0xF7, 0x01, 0xEF, 0xF7, 0x81, 0xCF, 0xF3,
  0x83, 0xCF, 0xF3, 0x83, 0x8F, 0xF3, 0xC3, 0x8F, 0xF1, 0xC7, 0x8F, 0xF1,
  0xC7, 0x0F, 0xF1, 0xE7, 0x0F, 0xF0, 0xEF, 0x0F, 0xF0, 0xEE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xDE, 0x01, 0xFB, 0xE0, 0x3F, 0x3C, 0x07, 0xF3, 0xC0, 0xFE,
  0x7C, 0x1F, 0xC7, 0x83, 0xF8, 0xF8, 0x7F, 0x0F, 0x8F, 0xE0, 0xF1, 0xFC,
  0x1F, 0x3F, 0x81, 0xE7, 0xF0, 0x3E, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xE0, 0x1F, 0x3E, 0x00,
  0xF9, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x80, 0x7C, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE,
  0x3F, 0xC0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x80, 0x7C, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1E, 0x7F, 0xCF, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x3C, 0x0F,
  0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3E, 0x0F, 0xF0, 0xFF,
  0xF7, 0xFF, 0xFF, 0x1E, 0xF0, 0x0B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0xFB, 0xFF, 0xC7,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x79, 0xF8, 0x7E,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03,
  0x9E, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x1F, 0x00,
  0xF7, 0x80, 0x7C, 0x03, 0xDE, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x78,
  0xF0, 0x3F, 0x81, 0xE3, 0xC1, 0xFE, 0x07, 0x8F, 0x07, 0xB8, 0x3C, 0x3C,
  0x1C, 0xE0, 0xF0, 0x70, 0x73, 0xC3, 0xC1, 0xE3, 0xCF, 0x0F, 0x07, 0x8F,
  0x1C, 0x78, 0x1E, 0x38, 0x79, 0xE0, 0x38, 0xE1, 0xE7, 0x80, 0xF7, 0x83,
  0x9E, 0x03, 0xDE, 0x0E, 0x70, 0x0F, 0x70, 0x3F, 0xC0, 0x1D, 0xC0, 0xFF,
  0x00, 0x77, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF7, 0xC0,
  0x3E, 0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x07,
  0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x79, 0xE0,
  0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x03,
  0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0,
  0x0F, 0x1E, 0x03, 0xC3, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0x78,
  0xF0, 0x0F, 0x9E, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0xFF, 0xFF, 0xF8, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1C,
  0x78, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0,
  0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x01, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0xFB, 0xF1, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x7F, 0x1F, 0xFE, 0x7F, 0xFD, 0xF0, 0x7B, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xBF, 0xFF, 0x7F, 0xEE, 0x3F, 0x1C, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0xE0, 0xFB, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0x01,
  0xC0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0x81, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x6F,
  0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x06, 0x1F, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xF3,
  0xE7, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xDF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x40, 0x3E, 0x7F,
  0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x70, 0xFB, 0xFC, 0xF7,
  0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x77, 0xFE, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x07,
  0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xEF, 0xF7, 0xFB, 0xF8, 0xF0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0,
  0xFF, 0x80, 0xEF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x18, 0x3C, 0xFF, 0x3F, 0xCF, 0x7F, 0xDF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x87, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F,
  0xE0, 0x7C, 0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0,
  0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81,
  0xE0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xF0,
  0x00, 0x70, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x60, 0xF3, 0xF8, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xF7, 0xFC, 0xFB, 0xF8,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF,
  0x3F, 0xEF, 0x1F, 0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x7F, 0xDF,
  0xFF, 0xFF, 0xE1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0x9E, 0xE0, 0x2F, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFE,
  0x07, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0xFF, 0x8F, 0xF0, 0xFE, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xC7, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF1, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xDE, 0x07, 0xC0,
  0xF7, 0x83, 0xF0, 0x79, 0xE0, 0xFE, 0x1E, 0x3C, 0x3B, 0x87, 0x8F, 0x1E,
  0xE1, 0xE3, 0xC7, 0x38, 0xF0, 0x71, 0xCF, 0x3C, 0x1E, 0x71, 0xCF, 0x07,
  0xBC, 0x73, 0x81, 0xEE, 0x1D, 0xE0, 0x3B, 0x87, 0xF8, 0x0E, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0x78, 0x00, 0x7C, 0x0F, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x0F,
  0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3D, 0xF0, 0x1F, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xF1,
  0xF0, 0x3E, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0E,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC1, 0xF0, 0xFC, 0x3E, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0xFE, 0x3E, 0x0F,
  0x83, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFE, 0x0F,
  0xC0, 0xF8, 0x7F, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x78, 0x00, 0x1C, 0x01, 0x7F, 0x83,
  0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 10, 8, 14, 2, -23 },
  { 26, 19, 23, 21, 1, -23 },
  { 81, 15, 26, 18, 2, -24 },
  { 130, 26, 23, 28, 1, -23 },
  { 205, 23, 23, 24, 1, -23 },
  { 272, 4, 8, 8, 2, -23 },
  { 276, 8, 28, 10, 1, -23 },
  { 304, 8, 28, 10, 1, -23 },
  { 332, 15, 14, 17, 1, -24 },
  { 359, 16, 15, 18, 1, -19 },
  { 389, 6, 8, 9, 1, -4 },
  { 395, 8, 3, 10, 1, -10 },
  { 398, 5, 5, 9, 2, -5 },
  { 402, 13, 23, 13, 0, -23 },
  { 440, 16, 23, 18, 1, -23 },
  { 486, 11, 23, 18, 2, -23 },
  { 518, 16, 23, 18, 1, -23 },
  { 564, 16, 23, 18, 1, -23 },
  { 610, 17, 23, 18, 1, -23 },
  { 659, 15, 23, 18, 2, -23 },
  { 703, 16, 23, 18, 1, -23 },
  { 749, 16, 23, 18, 1, -23 },
  { 795, 16, 23, 18, 1, -23 },
  { 841, 16, 23, 18, 1, -23 },
  { 887, 5, 18, 9, 2, -18 },
  { 899, 6, 22, 9, 1, -18 },
  { 916, 16, 17, 18, 1, -20 },
  { 950, 15, 9, 18, 2, -16 },
  { 967, 16, 17, 18, 1, -20 },
  { 1001, 14, 23, 15, 0, -23 },
  { 1042, 25, 26, 29, 2, -23 },
  { 1124, 21, 23, 22, 0, -23 },
  { 1185, 16, 23, 21, 3, -23 },
  { 1231, 17, 23, 20, 2, -23 },
  { 1280, 19, 23, 23, 3, -23 },
  { 1335, 13, 23, 18, 3, -23 },
  { 1373, 13, 23, 17, 3, -23 },
  { 1411, 19, 23, 23, 2, -23 },
  { 1466, 18, 23, 24, 3, -23 },
  { 1518, 10, 23, 12, 1, -23 },
  { 1547, 9, 29, 10, -2, -23 },
  { 1580, 18, 23, 21, 3, -23 },
  { 1632, 14, 23, 17, 3, -23 },
  { 1673, 24, 23, 30, 3, -23 },
  { 1742, 19, 23, 25, 3, -23 },
  { 1797, 21, 23, 25, 2, -23 },
  { 1858, 15, 23, 20, 3, -23 },
  { 1902, 21, 28, 25, 2, -23 },
  { 1976, 17, 23, 21, 3, -23 },
  { 2025, 14, 23, 18, 2, -23 },
  { 2066, 17, 23, 18, 1, -23 },
  { 2115, 18, 23, 24, 3, -23 },
  { 2167, 20, 23, 20, 0, -23 },
  { 2225, 30, 23, 31, 0, -23 },
  { 2312, 20, 23, 20, 0, -23 },
  { 2370, 19, 23, 19, 0, -23 },
  { 2425, 17, 23, 18, 1, -23 },
  { 2474, 8, 28, 11, 2, -23 },
  { 2502, 13, 23, 13, 0, -23 },
  { 2540, 7, 28, 11, 1, -23 },
  { 2565, 16, 15, 18, 1, -23 },
  { 2595, 14, 2, 14, 0, 3 },
  { 2599, 8, 6, 11, 1, -25 },
  { 2605, 15, 18, 19, 1, -18 },
  { 2639, 16, 24, 20, 2, -24 },
  { 2687, 13, 18, 16, 2, -18 },
  { 2717, 16, 24, 20, 2, -24 },
  { 2765, 15, 18, 19, 2, -18 },
  { 2799, 12, 24, 12, 1, -24 },
  { 2835, 16, 26, 20, 2, -18 },
  { 2887, 16, 24, 20, 2, -24 },
  { 2935, 5, 24, 9, 2, -24 },
  { 2950, 9, 32, 9, -2, -24 },
  { 2986, 16, 24, 19, 3, -24 },
  { 3034, 5, 24, 9, 2, -24 },
  { 3049, 26, 18, 31, 2, -18 },
  { 3108, 16, 18, 20, 2, -18 },
  { 3144, 16, 18, 20, 2, -18 },
  { 3180, 16, 26, 20, 2, -18 },
  { 3232, 16, 26, 20, 2, -18 },
  { 3284, 11, 18, 14, 2, -18 },
  { 3309, 12, 18, 16, 2, -18 },
  { 3336, 11, 21, 13, 1, -21 },
  { 3365, 16, 17, 20, 2, -17 },
  { 3399, 18, 17, 18, 0, -17 },
  { 3438, 26, 17, 27, 0, -17 },
  { 3494, 18, 17, 18, 0, -17 },
  { 3533, 18, 25, 18, 0, -17 },
  { 3590, 13, 17, 15, 1, -17 },
  { 3618, 10, 28, 12, 1, -23 },
  { 3653, 3, 31, 18, 7, -24 },
  { 3665, 11, 28, 12, 1, -23 },
  { 3704, 16, 5, 18, 1, -14 },
};

const GFXfont NotoSans_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMIBOLD32PT7B_H_
