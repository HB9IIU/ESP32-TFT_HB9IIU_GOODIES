#ifndef _NOTOSANS_SEMIBOLD34PT7B_H_
#define _NOTOSANS_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x70,
  0x00, 0xEF, 0xFF, 0xEF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0x1E, 0xE3,
  0xDC, 0x7B, 0x87, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x3C, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0xFD, 0xBE, 0xF1, 0x84, 0xF1, 0x80, 0xF1,
  0x80, 0xF9, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x01, 0xBF, 0x01, 0x9F, 0x01, 0x8F, 0x81, 0x8F, 0xE1, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x07, 0x81, 0xFF, 0x00, 0xE0, 0x3C,
  0xE0, 0x3C, 0x07, 0x1E, 0x07, 0x01, 0xE1, 0xC1, 0xE0, 0x3C, 0x38, 0x38,
  0x07, 0x87, 0x0F, 0x00, 0xF0, 0xE1, 0xC0, 0x1E, 0x1C, 0x70, 0x03, 0xC3,
  0x9E, 0x3C, 0x38, 0xF3, 0x9F, 0xE7, 0x9C, 0xF3, 0xFC, 0x7F, 0x9C, 0xF3,
  0xC7, 0xE7, 0x9C, 0x38, 0x30, 0xE3, 0x87, 0x00, 0x3C, 0x70, 0xE0, 0x07,
  0x0E, 0x1C, 0x01, 0xC1, 0xC3, 0x80, 0x78, 0x38, 0x70, 0x0E, 0x07, 0x0E,
  0x03, 0xC0, 0xE3, 0xC0, 0x70, 0x1F, 0xF8, 0x1E, 0x01, 0xFE, 0x07, 0x80,
  0x1F, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F,
  0x00, 0x3E, 0x3C, 0x00, 0x3D, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x03, 0xC7, 0xFC, 0x0F, 0x9F, 0x7C, 0x1E, 0x7C, 0x7C, 0x3C,
  0xF0, 0x7E, 0xF9, 0xE0, 0x7F, 0xE3, 0xC0, 0x7F, 0x87, 0x80, 0x7F, 0x0F,
  0x80, 0xFE, 0x1F, 0xCF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFE, 0x7E, 0x1F,
  0xF0, 0x7E, 0xFF, 0xFF, 0x77, 0x77, 0x70, 0x07, 0x87, 0x87, 0x83, 0xC3,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x71,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0x70, 0x1E, 0x78, 0x3E, 0x3C, 0x1C, 0x38, 0x04, 0x10, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE1, 0xE3, 0xE0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xF1, 0xF0, 0x7F, 0xF8,
  0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFF,
  0xFB, 0xDE, 0x79, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3,
  0xF1, 0x80, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0x81, 0xF1, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xF7, 0x81, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x77, 0x80, 0x3D, 0xE0, 0x1E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF,
  0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x38, 0x3E, 0x1E, 0x0F, 0x8F, 0x03, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x80, 0x3E,
  0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x1C, 0x00, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x10, 0x1E, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF7,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xF7, 0xC0, 0xF9, 0xF8, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1F,
  0x1F, 0x1F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFD,
  0xF8, 0xF8, 0x3E, 0x78, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7,
  0x80, 0xFB, 0xE0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xF3, 0xC0, 0x79,
  0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x01,
  0xF7, 0xC3, 0xF9, 0xFF, 0xFC, 0xFF, 0xDE, 0x1F, 0xCF, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xDF, 0xFF, 0xDE, 0x39, 0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D, 0xE7, 0x9E, 0x73, 0xCF, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0x03,
  0xE8, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE7, 0xF8,
  0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x0E, 0x07,
  0xF0, 0xF3, 0xC3, 0xFF, 0x8E, 0x70, 0xFF, 0xF1, 0xDE, 0x1E, 0x1E, 0x3F,
  0x87, 0x83, 0x83, 0xF0, 0xE0, 0x70, 0x7E, 0x1C, 0x0E, 0x0F, 0xC7, 0x81,
  0xC1, 0xF8, 0xF0, 0x38, 0x77, 0x0E, 0x0F, 0x0E, 0xE1, 0xE1, 0xE1, 0xDC,
  0x3E, 0xFF, 0xF3, 0xC3, 0xFD, 0xFE, 0x38, 0x3F, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0xFC, 0x03, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3E, 0x01,
  0xE0, 0x3C, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xC0, 0xFE, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x3E, 0xF0, 0x0F, 0x3C, 0x0F, 0xCF, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF,
  0x3C, 0x07, 0xEF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8,
  0x3C, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x04, 0x7F, 0xCF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x07, 0xF8, 0xF0,
  0x0F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x07,
  0xCF, 0x01, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xC0, 0xE3, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00,
  0xF7, 0xC0, 0x0F, 0x3F, 0x00, 0xF3, 0xFC, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF7, 0xFC, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xCF,
  0xC0, 0xF8, 0x07, 0xFF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7C,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xBF, 0xF8,
  0x03, 0xFF, 0xDC, 0x01, 0xFF, 0xEF, 0x00, 0xEF, 0xF7, 0x80, 0xF7, 0xF9,
  0xC0, 0x7B, 0xFC, 0xF0, 0x39, 0xFE, 0x78, 0x3C, 0xFF, 0x1E, 0x1E, 0x7F,
  0x8F, 0x0E, 0x3F, 0xC7, 0x8F, 0x1F, 0xE1, 0xE7, 0x0F, 0xF0, 0xF3, 0x87,
  0xF8, 0x7B, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xDF, 0x01, 0xFE, 0xF8, 0x0F, 0xF3, 0xE0, 0x7F, 0x8F, 0x03,
  0xFC, 0x7C, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x3E, 0x3F, 0xC0,
  0xF1, 0xFE, 0x07, 0xCF, 0xF0, 0x1F, 0x7F, 0x80, 0xFB, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xE0,
  0x1F, 0x87, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xE0,
  0x1F, 0x87, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x78, 0x3F, 0x8F, 0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E,
  0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1F, 0x3C,
  0x01, 0xF7, 0x80, 0x3F, 0x01, 0x80, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xEF,
  0xC1, 0xDF, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x03, 0xF7, 0xF9, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x07,
  0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC1, 0xF0, 0x1E,
  0x0F, 0x00, 0xF8, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x78, 0x03, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0,
  0x1E, 0x7C, 0x07, 0xF0, 0x1E, 0x3C, 0x0F, 0xF0, 0x3E, 0x3C, 0x0F, 0xF0,
  0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x3E, 0x0E, 0x78, 0x3C, 0x1E, 0x1E, 0x78,
  0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x3C, 0x78, 0x1F, 0x1C, 0x3C,
  0x78, 0x0F, 0x3C, 0x3C, 0x78, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x3C, 0x1E,
  0xF0, 0x0F, 0x38, 0x1E, 0xF0, 0x07, 0xF8, 0x1E, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3E,
  0x1E, 0x00, 0x7C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x1E, 0x00, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F,
  0xBE, 0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x7C,
  0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xF1, 0xE0,
  0x07, 0x9F, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF,
  0xFF, 0xE0, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x38,
  0xE0, 0x1C, 0x70, 0x1C, 0x1C, 0x0E, 0x0F, 0x0E, 0x03, 0x87, 0x01, 0xE7,
  0x80, 0x73, 0x80, 0x3F, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x01, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x08, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0x3F, 0xFF,
  0x7F, 0x8F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F,
  0x7F, 0xFF, 0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0xC0, 0xF7,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x03, 0xEF, 0x81, 0xF7, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xF9, 0xF9, 0xFF, 0xFC, 0xE7, 0xFC, 0x71,
  0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xF3, 0xFF, 0xDF, 0xFE, 0x7C, 0x0B, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x5F, 0x87, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x0F, 0x1F, 0x1F, 0xEF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF,
  0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF8,
  0xFE, 0xFF, 0xFF, 0x3F, 0xF7, 0x8F, 0xE3, 0xC0, 0x03, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0x7E, 0x7C, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7E, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xF8,
  0x7F, 0xC7, 0xFE, 0x3F, 0x61, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF,
  0xFF, 0xF7, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3E, 0xF8, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF3, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x79, 0x00, 0x7C, 0xF8, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x23, 0xFE, 0xF7, 0x00, 0x00,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0,
  0x02, 0x03, 0xC3, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7E, 0x7F, 0xFE,
  0xFF, 0x7E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x78, 0x1F,
  0x3C, 0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x9F, 0x03, 0xDF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1E, 0x3E, 0x0F, 0x0F, 0x87,
  0x83, 0xC3, 0xC1, 0xF1, 0xE0, 0x7C, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x1E, 0x1C, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0xF0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0x7F,
  0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C,
  0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC,
  0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0,
  0x3F, 0xC0, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xE0, 0x07, 0xFC, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7D, 0xE0, 0x3C, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0xE0, 0x73, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0x7D, 0xF8, 0x7C, 0xFF, 0xFE,
  0x7B, 0xFE, 0x3C, 0xFE, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x7F, 0x9F,
  0xFF, 0xFF, 0xE1, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0x81, 0xFF, 0xDF, 0xFF, 0xFB, 0xEF, 0x01, 0x78, 0x03, 0xE0, 0x1F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x11, 0xFF,
  0x1F, 0xF0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F,
  0xEF, 0x3F, 0xC7, 0xF8, 0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x1E, 0x3E, 0x03,
  0xC3, 0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x0F,
  0x81, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0xC1, 0xFC, 0x1E,
  0x3C, 0x3F, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC1, 0xE3,
  0x9E, 0x7C, 0x1E, 0x79, 0xE7, 0x81, 0xE7, 0x8E, 0x78, 0x1E, 0x70, 0xE7,
  0x80, 0xF7, 0x0F, 0x70, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x03,
  0xE0, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xFB,
  0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x3E, 0x07, 0x83,
  0xC1, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x00,
  0xF9, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x23, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x83, 0xE1,
  0xF8, 0x3C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0x7F, 0x0F,
  0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x18, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x80, 0x10,
};

const GFXglyph NotoSans_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 20, 24, 22, 1, -24 },
  { 89, 16, 28, 19, 2, -26 },
  { 145, 27, 25, 30, 1, -25 },
  { 230, 23, 25, 25, 2, -25 },
  { 302, 4, 9, 9, 2, -24 },
  { 307, 9, 29, 11, 1, -24 },
  { 340, 9, 29, 11, 1, -24 },
  { 373, 16, 16, 19, 1, -26 },
  { 405, 16, 16, 19, 2, -20 },
  { 437, 6, 8, 9, 1, -4 },
  { 443, 9, 4, 11, 1, -11 },
  { 448, 5, 5, 9, 2, -5 },
  { 452, 13, 24, 14, 0, -24 },
  { 491, 17, 25, 19, 1, -25 },
  { 545, 11, 24, 19, 2, -24 },
  { 578, 17, 25, 19, 1, -25 },
  { 632, 17, 25, 19, 1, -25 },
  { 686, 18, 24, 19, 1, -24 },
  { 740, 16, 24, 19, 2, -24 },
  { 788, 17, 25, 19, 1, -25 },
  { 842, 17, 24, 19, 1, -24 },
  { 893, 17, 25, 19, 1, -25 },
  { 947, 17, 25, 19, 1, -25 },
  { 1001, 5, 19, 9, 2, -19 },
  { 1013, 6, 23, 9, 1, -19 },
  { 1031, 16, 17, 19, 2, -21 },
  { 1065, 16, 10, 19, 2, -17 },
  { 1085, 16, 17, 19, 2, -21 },
  { 1119, 15, 25, 16, 0, -25 },
  { 1166, 27, 27, 31, 2, -24 },
  { 1258, 23, 24, 23, 0, -24 },
  { 1327, 18, 24, 22, 3, -24 },
  { 1381, 19, 25, 22, 2, -25 },
  { 1441, 20, 24, 25, 3, -24 },
  { 1501, 14, 24, 19, 3, -24 },
  { 1543, 14, 24, 18, 3, -24 },
  { 1585, 20, 25, 25, 2, -25 },
  { 1648, 20, 24, 26, 3, -24 },
  { 1708, 10, 24, 13, 1, -24 },
  { 1738, 10, 31, 11, -3, -24 },
  { 1777, 19, 24, 22, 3, -24 },
  { 1834, 15, 24, 19, 3, -24 },
  { 1879, 25, 24, 32, 3, -24 },
  { 1954, 21, 24, 27, 3, -24 },
  { 2017, 23, 25, 27, 2, -25 },
  { 2089, 16, 24, 21, 3, -24 },
  { 2137, 23, 31, 27, 2, -25 },
  { 2227, 19, 24, 22, 3, -24 },
  { 2284, 15, 25, 19, 2, -25 },
  { 2331, 18, 24, 19, 1, -24 },
  { 2385, 19, 24, 25, 3, -24 },
  { 2442, 21, 24, 21, 0, -24 },
  { 2505, 32, 24, 32, 0, -24 },
  { 2601, 22, 24, 22, 0, -24 },
  { 2667, 21, 24, 21, 0, -24 },
  { 2730, 18, 24, 20, 1, -24 },
  { 2784, 7, 29, 11, 3, -24 },
  { 2810, 13, 24, 14, 0, -24 },
  { 2849, 8, 29, 11, 1, -24 },
  { 2878, 17, 15, 19, 1, -24 },
  { 2910, 14, 2, 14, 0, 3 },
  { 2914, 9, 5, 11, 1, -26 },
  { 2920, 16, 19, 20, 1, -19 },
  { 2958, 17, 26, 21, 3, -26 },
  { 3014, 14, 19, 17, 2, -19 },
  { 3048, 17, 26, 21, 2, -26 },
  { 3104, 16, 19, 20, 2, -19 },
  { 3142, 13, 26, 13, 1, -26 },
  { 3185, 17, 27, 21, 2, -19 },
  { 3243, 16, 26, 22, 3, -26 },
  { 3295, 5, 26, 10, 2, -26 },
  { 3312, 9, 34, 10, -2, -26 },
  { 3351, 17, 26, 20, 3, -26 },
  { 3407, 4, 26, 10, 3, -26 },
  { 3420, 27, 19, 33, 3, -19 },
  { 3485, 16, 19, 22, 3, -19 },
  { 3523, 17, 19, 21, 2, -19 },
  { 3564, 17, 27, 21, 3, -19 },
  { 3622, 17, 27, 21, 2, -19 },
  { 3680, 11, 19, 15, 3, -19 },
  { 3707, 13, 19, 17, 2, -19 },
  { 3738, 12, 22, 14, 1, -22 },
  { 3771, 16, 18, 22, 3, -18 },
  { 3807, 19, 18, 19, 0, -18 },
  { 3850, 28, 18, 28, 0, -18 },
  { 3913, 19, 18, 19, 0, -18 },
  { 3956, 19, 26, 19, 0, -18 },
  { 4018, 14, 18, 16, 1, -18 },
  { 4050, 11, 29, 13, 1, -24 },
  { 4090, 3, 34, 19, 8, -26 },
  { 4103, 12, 29, 13, 1, -24 },
  { 4147, 16, 6, 19, 2, -15 },
};

const GFXfont NotoSans_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMIBOLD34PT7B_H_
