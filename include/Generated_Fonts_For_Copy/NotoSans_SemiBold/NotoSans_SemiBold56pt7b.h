#ifndef _NOTOSANS_SEMIBOLD56PT7B_H_
#define _NOTOSANS_SEMIBOLD56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1C, 0x00,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xCF, 0x0F, 0x8F, 0xE1, 0xE0, 0x11, 0xFC, 0x3C, 0x00, 0x3F, 0x87, 0x80,
  0x07, 0xF0, 0xF0, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0xF3, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x3F, 0xE0, 0x01, 0xE3, 0xFC,
  0x00, 0x3C, 0x3F, 0x80, 0x07, 0x83, 0xF8, 0x00, 0xF0, 0xFE, 0x80, 0x1E,
  0x1F, 0xDC, 0x03, 0xC7, 0xFB, 0xF8, 0x7B, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3E,
  0x00, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x18, 0x07, 0xE0, 0x7E,
  0x3F, 0x0F, 0xF8, 0x1F, 0x03, 0xF1, 0xF8, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F,
  0x8F, 0xFF, 0x87, 0xF3, 0xF8, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC7,
  0xF3, 0xF8, 0x7F, 0xFC, 0x7E, 0x3F, 0x0F, 0xC1, 0xFF, 0xC7, 0xE3, 0xF0,
  0x3E, 0x07, 0xF8, 0x3E, 0x1F, 0x81, 0xF8, 0x02, 0x03, 0xF0, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xF9, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x83, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F,
  0xF7, 0xFC, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x0F, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0x07, 0xF0, 0x07, 0xFD, 0xFE, 0x0F,
  0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xCF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x60, 0x1F, 0x01, 0xCF, 0xC3, 0xE1, 0xFB, 0xFF,
  0x7B, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x03, 0xC0,
  0x78, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x87, 0xF3,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF1, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x7F, 0xDF, 0xFF, 0xE7, 0xF7, 0xF1, 0xFD, 0xF8, 0x7F, 0x38, 0x1F, 0xC4,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF,
  0x83, 0xF8, 0x07, 0xFC, 0x1E, 0x00, 0x3F, 0xC0, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xF1,
  0xF0, 0x03, 0xFE, 0x18, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x81,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x84, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xB8, 0x00, 0x3F, 0xEF, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xF0, 0x08, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xC0, 0x07, 0xE1,
  0xFF, 0xC0, 0x7E, 0x3F, 0xFE, 0x07, 0xE7, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x3F, 0xEF, 0xFC, 0x01, 0xFE, 0xFF,
  0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x9F, 0xF8, 0x7F,
  0xC0, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xF7, 0xFC, 0x07, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFE, 0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x10, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFE, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD,
  0xFC, 0x38, 0x1F, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xCF, 0xF3, 0xFC, 0x7E,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xF3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0x1F, 0xFC, 0x78, 0x01, 0xFE, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0x80, 0x07, 0xE1, 0xF8, 0x03, 0xFF, 0xF0, 0x7E, 0x3F, 0x00,
  0xFF, 0xFF, 0x83, 0xE3, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0x7E, 0x03, 0xFF,
  0xFF, 0x01, 0xF7, 0xE0, 0x7F, 0x01, 0xF0, 0x1F, 0x7C, 0x0F, 0xE0, 0x1F,
  0x01, 0xF7, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x1F, 0x01,
  0xFF, 0xC1, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xFF,
  0x81, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x81,
  0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xEF, 0x80, 0xFC, 0x07,
  0xF0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFF, 0x87, 0xCF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7C, 0x07, 0xFF, 0xE7, 0xFF, 0x87, 0xE0, 0x3F, 0xFC, 0x7F, 0xF0,
  0x7E, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0x9F,
  0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80,
  0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x9F, 0xC0, 0x03,
  0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x01,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x08, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x01, 0xFF, 0xE1, 0xFC,
  0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0x3F,
  0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x02, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xFC, 0x00,
  0x1F, 0xC3, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0xFE, 0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x7F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0xFF, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xE0,
  0x00, 0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x7E, 0x00, 0x01,
  0xF7, 0xFF, 0xCF, 0xC0, 0x00, 0xFD, 0xFF, 0xF3, 0xF0, 0x00, 0x3F, 0x7F,
  0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0xFF, 0x9F, 0x80, 0x07, 0xE7, 0xFF, 0xE7,
  0xE0, 0x01, 0xF9, 0xFF, 0xF9, 0xF8, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x00,
  0x3F, 0x1F, 0xFF, 0x8F, 0xC0, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0, 0x07, 0xE1,
  0xFF, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xFF,
  0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0x81, 0xF8, 0x7E,
  0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0x8F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xDF, 0xE0,
  0x00, 0xFF, 0xF3, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0x1F,
  0xE0, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xFE, 0x00, 0xFF,
  0x0F, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0xF8, 0x00,
  0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0x80, 0x07, 0xFB, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x7F,
  0xF7, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x07, 0xFB, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xF0, 0x7F, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x3C, 0xFF, 0x00, 0x02, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0xFD, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x3F,
  0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x3F, 0x81, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0x81, 0xE0, 0x0F, 0xF0,
  0x20, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x03,
  0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x7F,
  0xEF, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF3, 0xFF,
  0xFC, 0x7E, 0x3F, 0xFF, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFF,
  0xC0, 0xFE, 0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xCF, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x0F,
  0xC3, 0xFF, 0xE0, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x06, 0x7F, 0xF0,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0xFF,
  0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x3F, 0x01, 0xFF, 0x83,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x87, 0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0, 0x81,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0x07, 0xFF,
  0xE7, 0xF0, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE0, 0x7F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F,
  0x01, 0xFF, 0x87, 0xF0, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x40, 0x00, 0x1F,
  0xE3, 0x80, 0x03, 0xFE, 0x3F, 0x81, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE1,
  0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x01, 0xFE, 0xFF,
  0x80, 0x0F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x3C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFD, 0x8F, 0xFB,
  0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x2F, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0xFF,
  0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xBF,
  0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFB, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC1, 0xFF,
  0xE0, 0xFC, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x0F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC1, 0xFF, 0xC0, 0xFE, 0x7F,
  0xFE, 0x0F, 0xEF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xEF,
  0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xE0,
  0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x18, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0xE7, 0xF0,
  0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0,
  0x7F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F, 0x01, 0xFF,
  0x87, 0xF0, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xC1, 0xFE, 0xFC, 0x3F, 0xEF, 0xC7, 0xFE, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x1F, 0xCF, 0xE0, 0x07,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0x7F, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xDF, 0x8F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFC, 0x7E, 0x0F, 0xFE,
  0x07, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xE7, 0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xBE, 0x01, 0xFC, 0x3F,
  0x80, 0xF9, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xCF, 0xC0, 0xFE, 0x07, 0xE0,
  0x7E, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xF1, 0xF0, 0x3F, 0x81, 0xFC, 0x1F,
  0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xF8, 0x7E, 0x1F, 0xC0, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0x0F, 0xE3, 0xE0, 0x7E,
  0x7F, 0x00, 0x3F, 0x3F, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x1F, 0x9F,
  0xC0, 0x0F, 0xEF, 0xC0, 0x7C, 0xFC, 0x00, 0x7F, 0x7C, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFE,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFA, 0x00, 0x0F, 0xFC, 0x80, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_SemiBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 41, 16, 3, -40 },
  { 48, 18, 14, 25, 4, -40 },
  { 80, 34, 40, 36, 1, -40 },
  { 250, 27, 46, 32, 3, -43 },
  { 406, 45, 42, 49, 2, -41 },
  { 643, 39, 42, 42, 3, -41 },
  { 848, 7, 14, 14, 4, -40 },
  { 861, 14, 49, 18, 2, -40 },
  { 947, 14, 49, 18, 2, -40 },
  { 1033, 27, 26, 31, 2, -43 },
  { 1121, 26, 27, 32, 3, -33 },
  { 1209, 10, 14, 16, 2, -7 },
  { 1227, 14, 6, 18, 2, -18 },
  { 1238, 9, 9, 15, 3, -8 },
  { 1249, 22, 40, 22, 0, -40 },
  { 1359, 28, 42, 32, 2, -41 },
  { 1506, 18, 40, 32, 4, -40 },
  { 1596, 28, 41, 32, 2, -41 },
  { 1740, 27, 42, 32, 2, -41 },
  { 1882, 30, 40, 32, 1, -40 },
  { 2032, 26, 41, 32, 3, -40 },
  { 2166, 28, 41, 32, 2, -40 },
  { 2310, 28, 40, 32, 2, -40 },
  { 2450, 28, 41, 32, 2, -40 },
  { 2594, 28, 41, 32, 2, -40 },
  { 2738, 9, 32, 15, 3, -31 },
  { 2774, 10, 38, 16, 2, -31 },
  { 2822, 26, 29, 32, 3, -35 },
  { 2917, 26, 16, 32, 3, -28 },
  { 2969, 26, 29, 32, 3, -35 },
  { 3064, 25, 42, 26, 0, -41 },
  { 3196, 44, 45, 50, 3, -40 },
  { 3444, 38, 40, 38, 0, -40 },
  { 3634, 29, 40, 37, 5, -40 },
  { 3779, 31, 42, 36, 3, -41 },
  { 3942, 33, 40, 41, 5, -40 },
  { 4107, 23, 40, 31, 5, -40 },
  { 4222, 23, 40, 30, 5, -40 },
  { 4337, 33, 42, 41, 3, -41 },
  { 4511, 32, 40, 42, 5, -40 },
  { 4671, 17, 40, 21, 2, -40 },
  { 4756, 16, 51, 17, -4, -40 },
  { 4858, 31, 40, 36, 5, -40 },
  { 5013, 24, 40, 31, 5, -40 },
  { 5133, 42, 40, 52, 5, -40 },
  { 5343, 34, 40, 44, 5, -40 },
  { 5513, 38, 42, 44, 3, -41 },
  { 5713, 27, 40, 34, 5, -40 },
  { 5848, 38, 51, 44, 3, -41 },
  { 6091, 31, 40, 36, 5, -40 },
  { 6246, 25, 42, 31, 3, -41 },
  { 6378, 30, 40, 32, 1, -40 },
  { 6528, 32, 41, 42, 5, -40 },
  { 6692, 35, 40, 35, 0, -40 },
  { 6867, 53, 40, 53, 0, -40 },
  { 7132, 36, 40, 36, 0, -40 },
  { 7312, 34, 40, 34, 0, -40 },
  { 7482, 29, 40, 32, 2, -40 },
  { 7627, 13, 49, 18, 4, -40 },
  { 7707, 22, 40, 22, 0, -40 },
  { 7817, 13, 49, 18, 1, -40 },
  { 7897, 28, 26, 32, 2, -40 },
  { 7988, 24, 4, 24, 0, 5 },
  { 8000, 14, 9, 19, 2, -43 },
  { 8016, 27, 32, 33, 2, -31 },
  { 8124, 28, 44, 35, 4, -43 },
  { 8278, 23, 32, 28, 3, -31 },
  { 8370, 28, 44, 35, 3, -43 },
  { 8524, 27, 32, 33, 3, -31 },
  { 8632, 22, 43, 21, 1, -43 },
  { 8751, 28, 44, 35, 3, -31 },
  { 8905, 28, 43, 36, 4, -43 },
  { 9056, 8, 42, 16, 4, -42 },
  { 9098, 15, 55, 16, -3, -42 },
  { 9202, 28, 43, 33, 5, -43 },
  { 9353, 7, 43, 16, 4, -43 },
  { 9391, 46, 31, 54, 4, -31 },
  { 9570, 28, 31, 36, 4, -31 },
  { 9679, 29, 32, 35, 3, -31 },
  { 9795, 28, 44, 35, 4, -31 },
  { 9949, 28, 44, 35, 3, -31 },
  { 10103, 20, 31, 24, 4, -31 },
  { 10181, 22, 32, 28, 3, -31 },
  { 10269, 20, 38, 23, 1, -37 },
  { 10364, 27, 31, 36, 4, -30 },
  { 10469, 31, 30, 31, 0, -30 },
  { 10586, 45, 30, 46, 1, -30 },
  { 10755, 30, 30, 31, 1, -30 },
  { 10868, 31, 43, 31, 0, -30 },
  { 11035, 23, 30, 27, 2, -30 },
  { 11122, 19, 49, 22, 1, -40 },
  { 11239, 5, 55, 31, 13, -42 },
  { 11274, 19, 49, 22, 2, -40 },
  { 11391, 26, 9, 32, 3, -24 },
};

const GFXfont NotoSans_SemiBold56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMIBOLD56PT7B_H_
