#ifndef _NOTOSANS_SEMIBOLD17PT7B_H_
#define _NOTOSANS_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0x03, 0xF0, 0xDF, 0x2C, 0xB2, 0x0C, 0x81, 0x30,
  0x26, 0x3F, 0xF7, 0xFE, 0x32, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xC8,
  0x13, 0x00, 0x10, 0x18, 0x7F, 0xD2, 0xD0, 0xF0, 0x7C, 0x1E, 0x17, 0x13,
  0xFF, 0xFE, 0x10, 0x10, 0xF0, 0x66, 0xC6, 0x26, 0x61, 0x33, 0x09, 0xB0,
  0x6D, 0xF9, 0xDB, 0x60, 0x9B, 0x0C, 0x88, 0x46, 0xC6, 0x36, 0x60, 0xE0,
  0x3E, 0x07, 0x60, 0x66, 0x06, 0x60, 0x3E, 0x03, 0x80, 0x7C, 0x6C, 0xEC,
  0xC7, 0xCC, 0x38, 0xFF, 0xC7, 0xEF, 0xFF, 0x36, 0x6C, 0xCC, 0xCC, 0xCC,
  0xCC, 0x66, 0x30, 0xC4, 0x66, 0x33, 0x33, 0x33, 0x66, 0x6C, 0x80, 0x18,
  0x10, 0x91, 0xFF, 0x38, 0x2C, 0x6E, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0xFB, 0x40, 0xF0, 0xFC, 0x0E, 0x18, 0x30, 0xC1, 0x83,
  0x0C, 0x18, 0x60, 0xC1, 0x86, 0x00, 0x7C, 0x6E, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C, 0x1C, 0xFE, 0xD3, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x7C, 0xFE, 0x87, 0x07, 0x06, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xFF, 0xFF, 0xFE, 0xEE, 0x07, 0x06, 0x06, 0x38, 0x3E, 0x07, 0x03,
  0x07, 0xFE, 0xFC, 0x07, 0x03, 0x83, 0xC3, 0x61, 0x31, 0x99, 0x8C, 0x86,
  0xFF, 0x81, 0x80, 0xC0, 0x60, 0x7E, 0x7E, 0xC0, 0xC0, 0xF8, 0xFE, 0x07,
  0x03, 0x03, 0x07, 0xFE, 0xFC, 0x3E, 0x7A, 0x60, 0xC0, 0xDC, 0xFE, 0xC3,
  0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x70, 0x7E, 0xE6, 0xC3, 0xC7, 0x6E, 0x3C, 0x7E,
  0xC7, 0xC3, 0xC3, 0xEF, 0x7E, 0x7C, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFF,
  0x33, 0x03, 0x06, 0x7C, 0x78, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xDA, 0x00, 0x01, 0x03, 0x0E, 0x38, 0xE0, 0xE0, 0x3C, 0x0F, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x07, 0x07, 0x3C, 0xF0, 0x80,
  0xFC, 0xDC, 0x18, 0x30, 0xE3, 0x86, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x0F,
  0xC1, 0xC3, 0x98, 0x06, 0x8F, 0xBC, 0xCC, 0xEC, 0x67, 0x63, 0x33, 0x19,
  0xCD, 0xDE, 0x7B, 0x98, 0x00, 0xE0, 0x81, 0xFC, 0x00, 0x0E, 0x01, 0xE0,
  0x6C, 0x0D, 0x81, 0x98, 0x73, 0x0C, 0x61, 0xFE, 0x7F, 0xCC, 0x19, 0x81,
  0xF0, 0x30, 0xFE, 0xFF, 0xC3, 0xC3, 0xC7, 0xFC, 0xFF, 0xC3, 0xC3, 0xC3,
  0xFF, 0xFE, 0x1F, 0xBF, 0xD8, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x30, 0x1F, 0xE3, 0xF0, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xFF, 0xDF, 0x80, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0,
  0xC3, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x30,
  0x1F, 0xCF, 0xE7, 0x03, 0x80, 0xC0, 0x31, 0xFC, 0x7F, 0x03, 0xE0, 0xD8,
  0x37, 0xFC, 0x7F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x30, 0xFB, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x3D,
  0xF0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xDB, 0xC0, 0xC3,
  0xE3, 0xB3, 0x9B, 0x8D, 0x87, 0xC3, 0xE1, 0xB8, 0xCE, 0x63, 0x31, 0xD8,
  0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0,
  0xE0, 0x7E, 0x07, 0xA0, 0xFB, 0x0F, 0xF0, 0xBD, 0x1B, 0xD9, 0xBD, 0x93,
  0xCB, 0x3C, 0xF3, 0xCE, 0x3C, 0x63, 0xE0, 0xF8, 0x3F, 0x0E, 0xC3, 0x98,
  0xF7, 0x3C, 0xCF, 0x3B, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0x3F, 0x8F, 0xF9,
  0x83, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x6C, 0x1D, 0xFF,
  0x0F, 0xC0, 0xFC, 0xFE, 0xC7, 0xC7, 0xC7, 0xCE, 0xFC, 0xF0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3F, 0x8F, 0xF9, 0x83, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x6C, 0x1D, 0xFF, 0x0F, 0xC0, 0x38, 0x03, 0x80, 0x38, 0xFC,
  0x7F, 0x31, 0xD8, 0xEC, 0x77, 0xF3, 0xF1, 0x98, 0xCE, 0x63, 0x31, 0xD8,
  0x70, 0x7E, 0xFE, 0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x06, 0x07, 0x87, 0xFE,
  0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0x60, 0xD8, 0x77, 0xF8, 0xFC, 0xC0, 0xEC, 0x19, 0x83, 0x30, 0xC3,
  0x18, 0x63, 0x0C, 0xC0, 0xD8, 0x1B, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xC1,
  0x83, 0x61, 0xC3, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0x46, 0x36, 0x66, 0x36,
  0x6C, 0x36, 0x6C, 0x36, 0x2C, 0x14, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xE0,
  0xCE, 0x30, 0xCE, 0x0D, 0x81, 0xF0, 0x1C, 0x03, 0x80, 0xF8, 0x3B, 0x06,
  0x31, 0x87, 0x70, 0x70, 0xE0, 0xD8, 0x67, 0x18, 0xCC, 0x3B, 0x07, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x1F, 0xFF, 0xF0, 0xFC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x0C,
  0x18, 0x18, 0x30, 0x70, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0,
  0x0C, 0x0E, 0x05, 0x86, 0xC3, 0x33, 0x19, 0x87, 0x83, 0xFE, 0xC6, 0x30,
  0x7E, 0x46, 0x03, 0x1F, 0xFF, 0xC3, 0xC7, 0xEF, 0x7B, 0xC0, 0x60, 0x30,
  0x18, 0x0D, 0xE7, 0xBB, 0x8F, 0xC3, 0xC1, 0xF1, 0xF8, 0xFF, 0xED, 0xE0,
  0x7E, 0xEF, 0x06, 0x0C, 0x18, 0x38, 0x3F, 0x3E, 0x03, 0x03, 0x03, 0x03,
  0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7F, 0x7E, 0x67, 0xC3,
  0xFF, 0xFF, 0xC0, 0xC0, 0x7F, 0x3F, 0x1E, 0x7C, 0xC1, 0x8F, 0xC6, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x7F, 0x7F, 0x03, 0x03, 0xFF, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0D,
  0xF7, 0x9B, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x38, 0x5D, 0x0D,
  0xB6, 0xDB, 0x6C, 0x11, 0xC4, 0x03, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xDE, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x37, 0x33, 0x31, 0xB0, 0xFC,
  0x76, 0x39, 0x9C, 0xEE, 0x38, 0xFF, 0xFF, 0xFF, 0xC0, 0xDF, 0xFB, 0xDE,
  0x7E, 0x38, 0xF8, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0C, 0xDF, 0x79, 0xB8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x80,
  0x7E, 0x33, 0xB0, 0xD8, 0x7C, 0x3E, 0x1F, 0x0C, 0xFE, 0x3E, 0x00, 0xDF,
  0x7B, 0xB8, 0xFC, 0x3C, 0x1F, 0x1F, 0x8F, 0xFE, 0xDE, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7F, 0x03,
  0x03, 0x03, 0x03, 0xDF, 0xFE, 0x38, 0xC3, 0x0C, 0x30, 0xC0, 0xFF, 0x8B,
  0x07, 0x87, 0xC1, 0xC1, 0xFE, 0xFC, 0x30, 0xCF, 0xCC, 0x30, 0xC3, 0x0C,
  0x30, 0xF3, 0xC0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8E, 0xFF,
  0x7D, 0x80, 0xE1, 0xB1, 0xD8, 0xCE, 0x63, 0x61, 0xB0, 0x58, 0x38, 0x1C,
  0x00, 0xE3, 0x0D, 0x9E, 0x66, 0x79, 0x99, 0xA6, 0x74, 0xD8, 0xF3, 0xC3,
  0xCF, 0x0F, 0x1C, 0x18, 0x60, 0xE3, 0xB9, 0x8F, 0x83, 0xC1, 0xC0, 0xF0,
  0xDC, 0xE6, 0xE1, 0x80, 0xE1, 0xB1, 0xD8, 0xCE, 0x63, 0x71, 0xB0, 0x78,
  0x38, 0x1C, 0x0E, 0x06, 0x1F, 0x0F, 0x00, 0xFE, 0x18, 0x70, 0xC3, 0x0C,
  0x38, 0x7F, 0xFE, 0x1C, 0x73, 0x0C, 0x30, 0xCF, 0x38, 0x30, 0xC3, 0x0C,
  0x38, 0x70, 0xC0, 0xFF, 0xFF, 0x80, 0xC7, 0x18, 0xC6, 0x30, 0xE7, 0x73,
  0x18, 0xC6, 0x72, 0x00, 0xF9, 0x9F,
};

const GFXglyph NotoSans_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 11, 12, 11, 0, -12 },
  { 26, 8, 14, 10, 1, -13 },
  { 40, 13, 12, 15, 1, -12 },
  { 60, 12, 12, 13, 1, -12 },
  { 78, 2, 4, 4, 1, -12 },
  { 79, 4, 15, 6, 1, -12 },
  { 87, 4, 15, 6, 1, -12 },
  { 95, 8, 8, 9, 1, -13 },
  { 103, 8, 8, 10, 1, -10 },
  { 111, 3, 4, 5, 1, -2 },
  { 113, 4, 1, 5, 1, -5 },
  { 114, 3, 2, 5, 1, -2 },
  { 115, 7, 12, 7, 0, -12 },
  { 126, 8, 12, 10, 1, -12 },
  { 138, 6, 12, 10, 1, -12 },
  { 147, 8, 12, 10, 1, -12 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 9, 12, 10, 0, -12 },
  { 185, 8, 12, 10, 1, -12 },
  { 197, 8, 12, 10, 1, -12 },
  { 209, 8, 12, 10, 1, -12 },
  { 221, 8, 12, 10, 1, -12 },
  { 233, 8, 12, 10, 1, -12 },
  { 245, 3, 9, 5, 1, -9 },
  { 249, 3, 11, 5, 1, -9 },
  { 254, 8, 9, 10, 1, -11 },
  { 263, 8, 4, 10, 1, -8 },
  { 267, 8, 9, 10, 1, -11 },
  { 276, 7, 12, 8, 0, -12 },
  { 287, 13, 13, 15, 1, -12 },
  { 309, 11, 12, 11, 0, -12 },
  { 326, 8, 12, 11, 2, -12 },
  { 338, 9, 12, 11, 1, -12 },
  { 352, 9, 12, 12, 2, -12 },
  { 366, 6, 12, 9, 2, -12 },
  { 375, 6, 12, 9, 2, -12 },
  { 384, 10, 12, 12, 1, -12 },
  { 399, 9, 12, 13, 2, -12 },
  { 413, 5, 12, 6, 1, -12 },
  { 421, 5, 15, 5, -1, -12 },
  { 431, 9, 12, 11, 2, -12 },
  { 445, 7, 12, 9, 2, -12 },
  { 456, 12, 12, 16, 2, -12 },
  { 474, 10, 12, 13, 2, -12 },
  { 489, 11, 12, 13, 1, -12 },
  { 506, 8, 12, 10, 2, -12 },
  { 518, 11, 15, 13, 1, -12 },
  { 539, 9, 12, 11, 2, -12 },
  { 553, 8, 12, 9, 1, -12 },
  { 565, 9, 12, 10, 0, -12 },
  { 579, 10, 12, 13, 1, -12 },
  { 594, 11, 12, 11, 0, -12 },
  { 611, 16, 12, 16, 0, -12 },
  { 635, 11, 12, 11, 0, -12 },
  { 652, 10, 12, 10, 0, -12 },
  { 667, 9, 12, 10, 0, -12 },
  { 681, 4, 15, 6, 1, -12 },
  { 689, 7, 12, 7, 0, -12 },
  { 700, 4, 15, 6, 0, -12 },
  { 708, 9, 8, 10, 0, -12 },
  { 717, 7, 1, 7, 0, 2 },
  { 718, 4, 3, 6, 1, -13 },
  { 720, 8, 9, 10, 1, -9 },
  { 729, 9, 13, 11, 1, -13 },
  { 744, 7, 9, 9, 1, -9 },
  { 752, 8, 13, 11, 1, -13 },
  { 765, 8, 9, 10, 1, -9 },
  { 774, 7, 13, 6, 0, -13 },
  { 786, 8, 13, 11, 1, -9 },
  { 799, 9, 13, 11, 1, -13 },
  { 814, 3, 13, 5, 1, -13 },
  { 819, 5, 17, 5, -1, -13 },
  { 830, 9, 13, 10, 1, -13 },
  { 845, 2, 13, 5, 1, -13 },
  { 849, 14, 9, 16, 1, -9 },
  { 865, 9, 9, 11, 1, -9 },
  { 876, 9, 9, 10, 1, -9 },
  { 887, 9, 13, 11, 1, -9 },
  { 902, 8, 13, 11, 1, -9 },
  { 915, 6, 9, 7, 1, -9 },
  { 922, 7, 9, 8, 1, -9 },
  { 930, 6, 11, 7, 0, -11 },
  { 939, 9, 9, 11, 1, -9 },
  { 950, 9, 9, 9, 0, -9 },
  { 961, 14, 9, 14, 0, -9 },
  { 977, 9, 9, 10, 0, -9 },
  { 988, 9, 13, 9, 0, -9 },
  { 1003, 7, 9, 8, 1, -9 },
  { 1011, 6, 15, 7, 0, -12 },
  { 1023, 1, 17, 9, 4, -13 },
  { 1026, 5, 15, 7, 1, -12 },
  { 1036, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMIBOLD17PT7B_H_
