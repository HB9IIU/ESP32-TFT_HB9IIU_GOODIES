#ifndef _NOTOSANS_SEMIBOLD20PT7B_H_
#define _NOTOSANS_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6C, 0x3F, 0xC0, 0xEF, 0xDF, 0x9A, 0x24, 0x40,
  0x06, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x08, 0xC1, 0x98,
  0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x18, 0x33, 0x03, 0x30, 0x08, 0x07, 0x87,
  0xFB, 0xEE, 0xE8, 0x3A, 0x0F, 0x81, 0xF8, 0x1F, 0x82, 0xE0, 0x9E, 0x26,
  0xFF, 0xBF, 0xC0, 0x80, 0x20, 0x78, 0x38, 0xCC, 0x30, 0xCC, 0x60, 0xCC,
  0x60, 0xCC, 0xC0, 0xCD, 0xDC, 0xCD, 0xBE, 0x7B, 0x36, 0x03, 0x63, 0x06,
  0x63, 0x06, 0x63, 0x0C, 0x63, 0x0C, 0x36, 0x18, 0x1E, 0x3F, 0x01, 0xFE,
  0x07, 0x18, 0x1C, 0xE0, 0x33, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x8E, 0xE7,
  0x33, 0x8F, 0xCE, 0x1E, 0x38, 0x78, 0x7F, 0xF0, 0xFC, 0xF0, 0xFF, 0xA4,
  0x39, 0x98, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x86, 0x38, 0xC3,
  0x18, 0x63, 0x18, 0xE7, 0x39, 0xCE, 0x63, 0x19, 0x8C, 0xC0, 0x1C, 0x0C,
  0x22, 0x3F, 0xFF, 0xF8, 0xE0, 0xD8, 0xEE, 0x22, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x6C,
  0xFF, 0xC0, 0x7F, 0x80, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x08, 0x0F, 0xC7, 0xF3, 0x8E, 0xE1,
  0xB0, 0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1B, 0x86, 0x63, 0x9F, 0xC3,
  0xE0, 0x0E, 0x7D, 0xFF, 0x74, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0x7F, 0x3F, 0xE4, 0x38, 0x06, 0x01, 0x80, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0x3F, 0xE4, 0x38,
  0x06, 0x03, 0x81, 0xC3, 0xC0, 0xFE, 0x03, 0x80, 0x70, 0x1A, 0x0E, 0xFF,
  0xBF, 0x80, 0x03, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0xD8, 0x33, 0x0C, 0x63,
  0x8C, 0x61, 0x9F, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x3F,
  0x98, 0x0C, 0x06, 0x07, 0xF3, 0xFE, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x7F,
  0xF7, 0xF0, 0x1F, 0x8F, 0xE7, 0x01, 0x80, 0xE0, 0x37, 0xCF, 0xFB, 0x86,
  0xC1, 0xF0, 0x7E, 0x1D, 0x86, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xF0, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x1C, 0x00, 0x7F, 0x1D, 0xEE, 0x1B, 0x86, 0x63, 0x9F, 0xC1, 0xE1, 0xFC,
  0xE3, 0xB0, 0x7C, 0x1F, 0x86, 0xFF, 0x8F, 0xC0, 0x7E, 0x1F, 0xCE, 0x3B,
  0x06, 0xC1, 0xF0, 0x7E, 0x3D, 0xFF, 0x3D, 0x80, 0x60, 0x38, 0x1C, 0x7F,
  0x1F, 0x00, 0xFD, 0x80, 0x00, 0x7F, 0x80, 0xFD, 0x80, 0x00, 0x1F, 0xED,
  0x00, 0x00, 0xC0, 0xF0, 0xF0, 0xF0, 0xE0, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xC0, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0xF1, 0xF1, 0xE0, 0xE0, 0x20, 0x00, 0xFF, 0x3F,
  0x90, 0xE0, 0x70, 0x30, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x00, 0x03, 0x03,
  0x80, 0xC0, 0x07, 0xF0, 0x1E, 0x3C, 0x30, 0x0E, 0x60, 0xC6, 0x67, 0xF3,
  0xC6, 0x33, 0xCC, 0x33, 0xCC, 0x33, 0xCC, 0x73, 0xCC, 0x72, 0xC7, 0xFE,
  0x63, 0x9C, 0x60, 0x00, 0x38, 0x10, 0x1F, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x3C, 0x03, 0xE0, 0x1B, 0x81, 0xDC, 0x0E, 0x60, 0x63, 0x87, 0x0C, 0x3F,
  0xE1, 0xFF, 0x9C, 0x1C, 0xE0, 0x76, 0x03, 0xF0, 0x0C, 0xFF, 0x3F, 0xEC,
  0x1F, 0x07, 0xC1, 0xF1, 0xEF, 0xE3, 0xFE, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xFF, 0xBF, 0xC0, 0x1F, 0xE7, 0xFD, 0xE0, 0xB8, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x13, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xFB, 0x07, 0x60, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE1, 0xEF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F,
  0xF3, 0xFE, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xFE, 0x1F, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0x87, 0x3F, 0xF0, 0xFF, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xC0, 0xFD, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xFF, 0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC7, 0xFF, 0xC0, 0xC1, 0xF8, 0x73, 0x0E, 0x63, 0x8C, 0xE1,
  0xB8, 0x3F, 0x07, 0xF0, 0xEE, 0x18, 0xE3, 0x0E, 0x61, 0xCC, 0x1D, 0x81,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFD, 0x83,
  0xFB, 0x0D, 0xF7, 0x1B, 0xE6, 0x77, 0xCC, 0xCF, 0x9D, 0x9F, 0x1F, 0x3E,
  0x3C, 0x7C, 0x78, 0xF8, 0x61, 0xC0, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x83,
  0xDC, 0x3C, 0xE3, 0xCE, 0x3C, 0x73, 0xC7, 0x3C, 0x3B, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFC, 0x07, 0x02, 0x00, 0x7F, 0x83, 0xFF, 0x1C, 0x1E, 0x70, 0x3B,
  0x80, 0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0x9C, 0x0E,
  0x78, 0x70, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0x7F, 0xF0, 0xF8, 0x3C, 0x1E,
  0x1F, 0x1F, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x02, 0x00,
  0x7F, 0x83, 0xFF, 0x1C, 0x1E, 0x70, 0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x6E, 0x03, 0x9C, 0x0E, 0x78, 0x70, 0xFF, 0xC0, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0x1F, 0xF3, 0x0E, 0x60, 0xCC,
  0x19, 0x87, 0x3F, 0xC7, 0xF0, 0xC6, 0x18, 0xE3, 0x0E, 0x61, 0xCC, 0x1D,
  0x81, 0xC0, 0x7F, 0xBF, 0xF8, 0x3C, 0x0E, 0x03, 0xC0, 0xF8, 0x3E, 0x07,
  0x81, 0xC0, 0x70, 0x7F, 0xF7, 0xF0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x83, 0xF0, 0x77, 0xFC, 0x7F, 0x00, 0xE0, 0x3B,
  0x03, 0x9C, 0x1C, 0xE0, 0xC3, 0x0E, 0x1C, 0x70, 0xE3, 0x03, 0x38, 0x1D,
  0xC0, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0xE0, 0xEC,
  0x1C, 0x19, 0x83, 0xC3, 0x38, 0xD8, 0xE7, 0x1B, 0x1C, 0x63, 0x63, 0x0C,
  0xEE, 0x61, 0xD8, 0xCC, 0x3B, 0x1B, 0x83, 0x63, 0x60, 0x7C, 0x7C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x1C, 0x1C, 0x00, 0xF0, 0x71, 0x87, 0x0E, 0x38,
  0x3B, 0x81, 0xD8, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0xEE, 0x0E,
  0x30, 0x61, 0xC7, 0x07, 0x70, 0x3C, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x9C,
  0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x60, 0x70, 0x30,
  0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x1C, 0x07, 0x01,
  0x60, 0xD8, 0x23, 0x18, 0xC6, 0x1B, 0x06, 0xC0, 0xC0, 0xFF, 0x80, 0xE3,
  0x86, 0x3F, 0x3F, 0xD0, 0xE0, 0x31, 0xFB, 0xFF, 0x87, 0x83, 0xE3, 0xFF,
  0xDF, 0x60, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xDE, 0x3F, 0xCE, 0x3B, 0x06,
  0xC1, 0xB0, 0x7C, 0x1B, 0x06, 0xE3, 0xBF, 0xED, 0xF0, 0x1F, 0x7F, 0x71,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x3D, 0xDF, 0xB7, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xE1,
  0xDF, 0xF3, 0xEC, 0x1E, 0x1F, 0xE6, 0x1B, 0x87, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0x60, 0x5F, 0xE3, 0xF8, 0x1F, 0x3F, 0x38, 0x38, 0x7E, 0xFE, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0xDF, 0xB7, 0x1F,
  0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xDF, 0xF3, 0xFC, 0x07, 0x01,
  0xD0, 0xE7, 0xF8, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xF7, 0xFF, 0x8F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x7D, 0x86, 0xDB,
  0x6D, 0xB6, 0xD8, 0x19, 0xC6, 0x01, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x19, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xB1, 0xCC,
  0xE3, 0x70, 0xD8, 0x3F, 0x0F, 0xC3, 0x38, 0xC7, 0x30, 0xEC, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFC, 0xDE, 0x3C, 0xFF, 0x7E, 0xE3, 0xC7, 0xC3, 0x87, 0xC3,
  0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3,
  0x87, 0xDF, 0x7F, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x60, 0x1F, 0x1F, 0xE7, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0x61, 0xDF, 0xE3, 0xF0, 0xDE, 0x3F, 0xCE, 0x3B, 0x06, 0xC1, 0xB0, 0x7C,
  0x1B, 0x06, 0xE3, 0xBF, 0xED, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x3C, 0xDF, 0xB7, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xDF,
  0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xDF, 0xFF, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x3E, 0xFF, 0xC1, 0xE0, 0xF8, 0x7E, 0x0F,
  0x07, 0x87, 0xFF, 0xFE, 0x10, 0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x38, 0x3F, 0x1F, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x87, 0x61, 0xDF, 0xF3, 0xEC, 0xE0, 0xEC, 0x19, 0x87, 0x38,
  0xE3, 0x18, 0x67, 0x0E, 0xE0, 0xD8, 0x1B, 0x01, 0xC0, 0x38, 0x00, 0xE1,
  0xC3, 0x61, 0xC3, 0x63, 0xC7, 0x73, 0x66, 0x73, 0x66, 0x36, 0x6E, 0x36,
  0x6E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0xE0, 0xEE, 0x38,
  0xEE, 0x0D, 0xC1, 0xF0, 0x1C, 0x07, 0xC0, 0xDC, 0x39, 0x8E, 0x3B, 0x83,
  0x80, 0xE0, 0xEC, 0x19, 0xC3, 0x38, 0xE3, 0x18, 0x73, 0x06, 0xE0, 0xD8,
  0x1B, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xFF,
  0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0xE0, 0xFF, 0xFF, 0x0E, 0x3C,
  0x60, 0xC1, 0x83, 0x06, 0x7C, 0xE0, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0x0E, 0xFF, 0xFF, 0xF0, 0xE3, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0x0C, 0xF3,
  0x0C, 0x30, 0xC7, 0x3C, 0xE0, 0x20, 0x7F, 0x39, 0xF8,
};

const GFXglyph NotoSans_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 6, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 12, 14, 13, 0, -14 },
  { 33, 10, 16, 11, 1, -15 },
  { 53, 16, 14, 18, 1, -14 },
  { 81, 14, 14, 15, 1, -14 },
  { 106, 3, 5, 5, 1, -14 },
  { 108, 5, 17, 6, 1, -14 },
  { 119, 5, 17, 6, 1, -14 },
  { 130, 9, 9, 11, 1, -15 },
  { 141, 10, 10, 11, 1, -12 },
  { 154, 3, 5, 6, 1, -2 },
  { 156, 5, 2, 6, 1, -6 },
  { 158, 3, 3, 6, 1, -3 },
  { 160, 8, 14, 8, 0, -14 },
  { 174, 10, 15, 11, 1, -15 },
  { 193, 7, 14, 11, 1, -14 },
  { 206, 10, 14, 11, 1, -14 },
  { 224, 10, 14, 11, 1, -14 },
  { 242, 11, 14, 11, 0, -14 },
  { 262, 9, 14, 11, 1, -14 },
  { 278, 10, 14, 11, 1, -14 },
  { 296, 10, 14, 11, 1, -14 },
  { 314, 10, 14, 11, 1, -14 },
  { 332, 10, 14, 11, 1, -14 },
  { 350, 3, 11, 6, 1, -11 },
  { 355, 3, 14, 6, 1, -11 },
  { 361, 10, 10, 11, 1, -12 },
  { 374, 9, 6, 11, 1, -10 },
  { 381, 10, 10, 11, 1, -12 },
  { 394, 9, 14, 9, 0, -14 },
  { 410, 16, 16, 18, 1, -14 },
  { 442, 13, 14, 13, 0, -14 },
  { 465, 10, 14, 13, 2, -14 },
  { 483, 11, 14, 13, 1, -14 },
  { 503, 11, 14, 15, 2, -14 },
  { 523, 8, 14, 11, 2, -14 },
  { 537, 8, 14, 11, 2, -14 },
  { 551, 12, 14, 15, 1, -14 },
  { 572, 11, 14, 15, 2, -14 },
  { 592, 6, 14, 7, 1, -14 },
  { 603, 6, 18, 6, -2, -14 },
  { 617, 11, 14, 13, 2, -14 },
  { 637, 8, 14, 11, 2, -14 },
  { 651, 15, 14, 19, 2, -14 },
  { 678, 12, 14, 16, 2, -14 },
  { 699, 14, 15, 16, 1, -15 },
  { 726, 9, 14, 12, 2, -14 },
  { 742, 14, 18, 16, 1, -15 },
  { 774, 11, 14, 13, 2, -14 },
  { 794, 9, 14, 11, 1, -14 },
  { 810, 11, 14, 11, 0, -14 },
  { 830, 11, 14, 15, 2, -14 },
  { 850, 13, 14, 13, 0, -14 },
  { 873, 19, 14, 19, 0, -14 },
  { 907, 13, 14, 13, 0, -14 },
  { 930, 12, 14, 12, 0, -14 },
  { 951, 10, 14, 12, 1, -14 },
  { 969, 5, 17, 7, 1, -14 },
  { 980, 8, 14, 8, 0, -14 },
  { 994, 5, 17, 7, 0, -14 },
  { 1005, 10, 9, 11, 1, -14 },
  { 1017, 9, 1, 8, 0, 2 },
  { 1019, 5, 3, 7, 1, -15 },
  { 1021, 9, 11, 12, 1, -11 },
  { 1034, 10, 15, 13, 2, -15 },
  { 1053, 8, 11, 10, 1, -11 },
  { 1064, 10, 15, 13, 1, -15 },
  { 1083, 10, 11, 12, 1, -11 },
  { 1097, 8, 15, 7, 0, -15 },
  { 1112, 10, 16, 13, 1, -11 },
  { 1132, 9, 15, 13, 2, -15 },
  { 1149, 3, 15, 6, 1, -15 },
  { 1155, 5, 20, 6, -1, -15 },
  { 1168, 10, 15, 12, 2, -15 },
  { 1187, 2, 15, 6, 2, -15 },
  { 1191, 16, 11, 19, 2, -11 },
  { 1213, 9, 11, 13, 2, -11 },
  { 1226, 10, 11, 12, 1, -11 },
  { 1240, 10, 16, 13, 2, -11 },
  { 1260, 10, 16, 13, 1, -11 },
  { 1280, 6, 11, 9, 2, -11 },
  { 1289, 8, 11, 10, 1, -11 },
  { 1300, 8, 13, 8, 0, -13 },
  { 1313, 10, 11, 13, 1, -11 },
  { 1327, 11, 11, 11, 0, -11 },
  { 1343, 16, 11, 17, 0, -11 },
  { 1365, 11, 11, 11, 0, -11 },
  { 1381, 11, 16, 11, 0, -11 },
  { 1403, 8, 11, 10, 1, -11 },
  { 1414, 7, 17, 8, 0, -14 },
  { 1429, 1, 20, 11, 5, -15 },
  { 1432, 6, 17, 8, 1, -14 },
  { 1445, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMIBOLD20PT7B_H_
