#ifndef _NOTOSANS_SEMIBOLD21PT7B_H_
#define _NOTOSANS_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x00, 0x6F, 0xE0, 0xE7, 0xCD, 0x9B,
  0x36, 0x60, 0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC7, 0xFF, 0xBF, 0xFC,
  0x33, 0x01, 0x98, 0x18, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x01, 0x98, 0x18,
  0xC0, 0xC6, 0x00, 0x0C, 0x03, 0x03, 0xFD, 0xFE, 0xEC, 0xBB, 0x0E, 0xC1,
  0xF0, 0x3F, 0x03, 0xF0, 0xDC, 0x37, 0xCD, 0xFF, 0xE7, 0xF0, 0x30, 0x0C,
  0x00, 0x78, 0x18, 0x7E, 0x1C, 0x33, 0x0C, 0x19, 0xCC, 0x0C, 0xE6, 0x06,
  0x76, 0x03, 0x33, 0x79, 0xFB, 0x7E, 0x79, 0xB3, 0x01, 0x99, 0xC1, 0xCC,
  0xE0, 0xC6, 0x70, 0xC3, 0x30, 0x61, 0xF8, 0x60, 0x78, 0x1F, 0x00, 0x7F,
  0x01, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0x0E,
  0x77, 0x19, 0xC7, 0x73, 0x87, 0xE7, 0x07, 0x8F, 0x1F, 0x0F, 0xFF, 0x0F,
  0xC7, 0x80, 0xFD, 0xB6, 0x19, 0x9C, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x8E,
  0x71, 0x8E, 0x31, 0xC0, 0xC3, 0x1C, 0x63, 0x1C, 0xE7, 0x18, 0xC6, 0x73,
  0x98, 0xCE, 0x67, 0x00, 0x1C, 0x03, 0x00, 0xC3, 0x37, 0xFF, 0xC7, 0x01,
  0xE0, 0xDC, 0x73, 0x04, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0xEC, 0xFF, 0xC0, 0x6F,
  0xE0, 0x03, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30,
  0x70, 0x70, 0x60, 0xE0, 0x3F, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0x0E,
  0x3C, 0xFF, 0xB6, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x80, 0x3F, 0x3F, 0xE6, 0x39, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0x3F, 0xE4, 0x38,
  0x07, 0x01, 0x80, 0xE3, 0xF0, 0xFC, 0x07, 0x80, 0x70, 0x1C, 0x07, 0x83,
  0xFF, 0xEF, 0xF0, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0D, 0xC1, 0xDC,
  0x19, 0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x07, 0xF3, 0xFE,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x83, 0xBF, 0xEF, 0xE0, 0x0F, 0x8F, 0xE7,
  0x81, 0x80, 0xE0, 0x39, 0x8D, 0xFB, 0xEF, 0xE1, 0xF8, 0x3E, 0x0F, 0x87,
  0x71, 0xDF, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0x3F,
  0x1F, 0xEE, 0x1F, 0x87, 0xE1, 0xDC, 0xE3, 0xF0, 0xFC, 0x77, 0xB8, 0x7C,
  0x0F, 0x03, 0xE1, 0xDF, 0xE3, 0xF0, 0x3E, 0x1F, 0xEE, 0x3B, 0x87, 0xC1,
  0xF0, 0x7E, 0x1F, 0xCF, 0x7E, 0xC6, 0x70, 0x1C, 0x06, 0x07, 0x9F, 0xC7,
  0xC0, 0x6E, 0xF6, 0x00, 0x00, 0x06, 0xFE, 0x6E, 0xF6, 0x00, 0x00, 0x00,
  0x6E, 0xCC, 0xC0, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x7C, 0x78, 0xF8,
  0x38, 0x08, 0x00, 0x7F, 0x7F, 0xD0, 0xE0, 0x30, 0x18, 0x1C, 0x1C, 0x1C,
  0x1C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0xE0, 0x70, 0x03, 0xF0, 0x07, 0xFE,
  0x06, 0x03, 0x86, 0x00, 0x66, 0x3F, 0x33, 0x3F, 0x8F, 0x18, 0xC7, 0x98,
  0x63, 0xCC, 0x31, 0xE6, 0x18, 0xF1, 0x9C, 0xD8, 0xFB, 0xC6, 0x18, 0xC3,
  0x80, 0x00, 0xE0, 0x20, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0xCE, 0x06, 0x18, 0x38,
  0x70, 0xFF, 0xC3, 0xFF, 0x1C, 0x0E, 0x70, 0x39, 0x80, 0x7E, 0x01, 0xC0,
  0xFF, 0x1F, 0xFB, 0x87, 0x70, 0xEE, 0x0D, 0xC3, 0xBF, 0xE7, 0xFC, 0xE1,
  0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xFF, 0xBF, 0xC0, 0x0F, 0xF1, 0xFE,
  0x38, 0x27, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x23, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFC, 0xE3,
  0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0xE3, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x0F, 0xF8, 0xFF, 0x8F, 0x04, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x3F, 0xE1, 0xFF, 0x01, 0xDC, 0x0E, 0xE0, 0x73, 0x83, 0x9F, 0xFC,
  0x3F, 0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xFF,
  0xC0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x1D, 0xFB, 0xE0, 0xE0, 0xEE, 0x1C, 0xE3, 0x8E, 0x38,
  0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0E, 0x70, 0xE7, 0x8E, 0x38,
  0xE1, 0xCE, 0x1E, 0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xD8, 0x1F, 0xD8, 0x37, 0xDC, 0x37, 0xCC, 0x37,
  0xCC, 0x67, 0xCE, 0x67, 0xC6, 0x67, 0xC6, 0xC7, 0xC7, 0xC7, 0xC3, 0xC7,
  0xC3, 0x87, 0xC3, 0x87, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7D, 0xC3,
  0xE7, 0x1F, 0x38, 0xF8, 0xE7, 0xC7, 0x3E, 0x1D, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0x7F, 0x01, 0xE0, 0x0F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0F,
  0x70, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01,
  0xDC, 0x0F, 0x78, 0x78, 0xFF, 0xC0, 0xFE, 0x00, 0xFE, 0x3F, 0xEE, 0x3F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFE, 0xFF, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0F, 0x70, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x0F,
  0x78, 0x78, 0xFF, 0xC0, 0xFE, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7, 0xFC,
  0xFE, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x38, 0x3F, 0x9F,
  0xEE, 0x1B, 0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xE0, 0x1C,
  0x07, 0xC3, 0xBF, 0xEF, 0xF0, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xE7,
  0xFC, 0x3F, 0x80, 0xE0, 0x3B, 0x01, 0xDC, 0x0C, 0xE0, 0xE3, 0x07, 0x1C,
  0x30, 0xE3, 0x83, 0x1C, 0x1C, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x60, 0x7E, 0x0F, 0x07, 0x60, 0xF0, 0x67,
  0x0F, 0x0E, 0x71, 0xF8, 0xE3, 0x1B, 0x8C, 0x31, 0x98, 0xC3, 0x99, 0x9C,
  0x3B, 0x9D, 0xC1, 0xB0, 0xD8, 0x1B, 0x0D, 0x81, 0xB0, 0xD8, 0x1F, 0x0F,
  0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x3B, 0x83, 0x8E, 0x38, 0x39,
  0xC1, 0xDC, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x6E, 0x07, 0x70,
  0x71, 0xC3, 0x87, 0x38, 0x3B, 0x80, 0xE0, 0xE0, 0x7B, 0x83, 0x9C, 0x38,
  0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x3F, 0xFF, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF,
  0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x0E,
  0x06, 0x07, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF,
  0x0C, 0x07, 0x01, 0xE0, 0xD8, 0x33, 0x1C, 0xC6, 0x19, 0x86, 0xC0, 0xF0,
  0x30, 0xFF, 0x80, 0xE3, 0x8E, 0x0E, 0x1F, 0xE3, 0x38, 0x07, 0x01, 0xCF,
  0xF7, 0xFF, 0x87, 0xE1, 0xF8, 0xFF, 0xFD, 0xF3, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC6, 0x37, 0xCF, 0xFB, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1,
  0xF8, 0xFF, 0xFB, 0x7C, 0x0E, 0x1F, 0xDF, 0xCE, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x5F, 0xE7, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0xCE, 0x7D, 0xDF, 0xFF, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E,
  0xE3, 0xDF, 0xF9, 0xF7, 0x0C, 0x0F, 0xE7, 0xBD, 0x87, 0xE0, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x1C, 0x17, 0xFC, 0x7F, 0x0F, 0x8F, 0x8E, 0x07, 0x03,
  0x87, 0xFB, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x0C, 0x07, 0xDD, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0x90, 0x73, 0xFC, 0x7F,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC6, 0x37, 0xEF, 0xFB, 0x87, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0x18, 0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xCF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0xEC, 0x73,
  0x38, 0xDC, 0x36, 0x0F, 0xC3, 0xB8, 0xC7, 0x31, 0xCC, 0x3B, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x6F, 0xDF, 0xBF, 0xFF, 0xDC, 0x78, 0x7C,
  0x1C, 0x3E, 0x0C, 0x1F, 0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0, 0xC1,
  0xF0, 0x60, 0xF8, 0x30, 0x70, 0x06, 0x37, 0xEF, 0xFB, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x0E, 0x07, 0xF1, 0xEF,
  0x30, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x39, 0xFF, 0x0F,
  0x80, 0x06, 0x37, 0xEF, 0xFB, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1,
  0xF8, 0xFF, 0xFB, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x07, 0xDD, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE,
  0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0xBF, 0xFF, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x1C, 0x7F,
  0xE3, 0xE0, 0xE0, 0x7C, 0x3F, 0x0F, 0x03, 0x83, 0xFF, 0xFE, 0x18, 0x38,
  0x38, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE3, 0xFF,
  0xF7, 0xCC, 0xE0, 0xEC, 0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x73, 0x06, 0xE0,
  0xD8, 0x1F, 0x01, 0xE0, 0x38, 0x00, 0xE1, 0xC3, 0xB0, 0xF1, 0xDC, 0xF8,
  0xCE, 0x6C, 0x63, 0x37, 0x71, 0x99, 0xB8, 0xFC, 0xD8, 0x7C, 0x6C, 0x1E,
  0x3E, 0x0F, 0x0E, 0x07, 0x07, 0x00, 0xF0, 0xE3, 0x9C, 0x39, 0x81, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB8, 0x39, 0xC7, 0x0E, 0xF0, 0xF0, 0xE0,
  0xF6, 0x0E, 0x70, 0xC3, 0x1C, 0x39, 0xC3, 0x98, 0x1B, 0x81, 0xF8, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x7C, 0x07, 0x00, 0xFF,
  0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x0E, 0x3C,
  0x70, 0xC1, 0x83, 0x06, 0x0C, 0xF9, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0E,
  0x1E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE1, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x1E, 0x3C, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0xF1, 0xC0,
  0x78, 0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 7, 5, 9, 1, -15 },
  { 14, 13, 15, 14, 0, -15 },
  { 39, 10, 17, 12, 1, -16 },
  { 61, 17, 15, 18, 1, -15 },
  { 93, 15, 15, 16, 1, -15 },
  { 122, 3, 5, 5, 1, -15 },
  { 124, 5, 18, 7, 1, -15 },
  { 136, 5, 18, 7, 1, -15 },
  { 148, 10, 10, 11, 1, -16 },
  { 161, 10, 11, 12, 1, -13 },
  { 175, 3, 5, 6, 1, -2 },
  { 177, 5, 2, 7, 1, -7 },
  { 179, 4, 3, 6, 1, -3 },
  { 181, 8, 15, 8, 0, -15 },
  { 196, 10, 15, 12, 1, -15 },
  { 215, 7, 15, 12, 1, -15 },
  { 229, 10, 15, 12, 1, -15 },
  { 248, 10, 15, 12, 1, -15 },
  { 267, 12, 15, 12, 0, -15 },
  { 290, 10, 15, 12, 1, -15 },
  { 309, 10, 15, 12, 1, -15 },
  { 328, 10, 15, 12, 1, -15 },
  { 347, 10, 15, 12, 1, -15 },
  { 366, 10, 15, 12, 1, -15 },
  { 385, 4, 12, 6, 1, -12 },
  { 391, 4, 15, 6, 1, -12 },
  { 399, 10, 11, 12, 1, -13 },
  { 413, 10, 6, 12, 1, -10 },
  { 421, 10, 11, 12, 1, -13 },
  { 435, 9, 15, 10, 0, -15 },
  { 452, 17, 17, 19, 1, -15 },
  { 489, 14, 15, 14, 0, -15 },
  { 516, 11, 15, 14, 2, -15 },
  { 537, 12, 15, 13, 1, -15 },
  { 560, 12, 15, 15, 2, -15 },
  { 583, 8, 15, 12, 2, -15 },
  { 598, 8, 15, 11, 2, -15 },
  { 613, 13, 15, 15, 1, -15 },
  { 638, 12, 15, 16, 2, -15 },
  { 661, 6, 15, 8, 1, -15 },
  { 673, 7, 19, 6, -2, -15 },
  { 690, 12, 15, 14, 2, -15 },
  { 713, 9, 15, 11, 2, -15 },
  { 730, 16, 15, 20, 2, -15 },
  { 760, 13, 15, 17, 2, -15 },
  { 785, 14, 15, 17, 1, -15 },
  { 812, 10, 15, 13, 2, -15 },
  { 831, 14, 19, 17, 1, -15 },
  { 865, 11, 15, 14, 2, -15 },
  { 886, 10, 15, 12, 1, -15 },
  { 905, 12, 15, 12, 0, -15 },
  { 928, 12, 15, 16, 2, -15 },
  { 951, 13, 15, 13, 0, -15 },
  { 976, 20, 15, 20, 0, -15 },
  { 1014, 13, 15, 13, 0, -15 },
  { 1039, 13, 15, 13, 0, -15 },
  { 1064, 10, 15, 12, 1, -15 },
  { 1083, 4, 18, 7, 2, -15 },
  { 1092, 8, 15, 8, 0, -15 },
  { 1107, 4, 18, 7, 1, -15 },
  { 1116, 10, 10, 12, 1, -15 },
  { 1129, 9, 1, 9, 0, 2 },
  { 1131, 5, 3, 7, 1, -16 },
  { 1133, 10, 12, 12, 1, -12 },
  { 1148, 10, 16, 13, 2, -16 },
  { 1168, 9, 12, 11, 1, -12 },
  { 1182, 11, 16, 13, 1, -16 },
  { 1204, 10, 12, 12, 1, -12 },
  { 1219, 9, 16, 8, 0, -16 },
  { 1237, 11, 17, 13, 1, -12 },
  { 1261, 10, 16, 13, 2, -16 },
  { 1281, 2, 16, 6, 2, -16 },
  { 1285, 5, 21, 6, -1, -16 },
  { 1299, 10, 16, 12, 2, -16 },
  { 1319, 2, 16, 6, 2, -16 },
  { 1323, 17, 12, 20, 2, -12 },
  { 1349, 10, 12, 13, 2, -12 },
  { 1364, 11, 12, 13, 1, -12 },
  { 1381, 10, 17, 13, 2, -12 },
  { 1403, 11, 17, 13, 1, -12 },
  { 1427, 7, 12, 9, 2, -12 },
  { 1438, 8, 12, 10, 1, -12 },
  { 1450, 8, 14, 9, 0, -14 },
  { 1464, 10, 11, 13, 2, -11 },
  { 1478, 11, 11, 11, 0, -11 },
  { 1494, 17, 11, 17, 0, -11 },
  { 1518, 12, 11, 12, 0, -11 },
  { 1535, 12, 16, 12, 0, -11 },
  { 1559, 8, 11, 10, 1, -11 },
  { 1570, 7, 18, 8, 0, -15 },
  { 1586, 2, 21, 12, 5, -16 },
  { 1592, 7, 18, 8, 1, -15 },
  { 1608, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMIBOLD21PT7B_H_
