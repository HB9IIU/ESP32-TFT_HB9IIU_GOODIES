#ifndef _NOTOSANS_SEMIBOLD7PT7B_H_
#define _NOTOSANS_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xA8, 0xC0, 0xB4, 0x5F, 0x6F, 0x60, 0x6C, 0x65, 0xE0, 0xCA, 0xCD,
  0xCD, 0x4C, 0x63, 0x1B, 0x37, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0x4F,
  0x60, 0x4F, 0x40, 0xC0, 0xC0, 0xC0, 0x29, 0x28, 0x69, 0x99, 0x60, 0x74,
  0x92, 0xE1, 0x24, 0xF0, 0xE1, 0x61, 0xE0, 0x26, 0x6F, 0x20, 0x68, 0x61,
  0xE0, 0x68, 0xF9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0xF1,
  0x60, 0xC3, 0xC2, 0x80, 0x3C, 0x30, 0xFF, 0xC3, 0xC0, 0xE5, 0x04, 0x39,
  0xDA, 0xEF, 0x40, 0xE0, 0x23, 0x14, 0xE8, 0x80, 0xF7, 0xDE, 0x74, 0x84,
  0x70, 0xE9, 0x99, 0xE0, 0xF3, 0x4E, 0xEE, 0x80, 0x7A, 0x26, 0x97, 0x80,
  0x99, 0xF9, 0x90, 0xD5, 0xC0, 0x24, 0x93, 0x80, 0xBC, 0xCE, 0xB0, 0x92,
  0x4E, 0x9C, 0xF7, 0xDA, 0x80, 0x9D, 0xDB, 0xB0, 0x72, 0x62, 0x97, 0x00,
  0xF7, 0xC8, 0x72, 0x62, 0x97, 0x0C, 0xF7, 0xDA, 0x78, 0x61, 0xE0, 0xF4,
  0x44, 0x40, 0x99, 0x99, 0xE0, 0x99, 0x56, 0x20, 0x93, 0x69, 0xB3, 0x64,
  0x80, 0x96, 0x26, 0x90, 0x96, 0x62, 0x20, 0xF2, 0x44, 0xF0, 0xFC, 0x89,
  0x22, 0xD5, 0x70, 0x46, 0x90, 0xE0, 0xC0, 0x63, 0xDF, 0x9A, 0xDE, 0x72,
  0x30, 0x17, 0x99, 0x70, 0x69, 0xE7, 0x7D, 0x24, 0x79, 0x97, 0x16, 0x9E,
  0xDA, 0xF8, 0xFE, 0x97, 0x6A, 0xF8, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x69,
  0x97, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA, 0x78, 0xF0, 0x5D, 0x26,
  0xB6, 0xF0, 0x9A, 0x66, 0xA6, 0xE7, 0x92, 0x96, 0x69, 0x9A, 0x66, 0x48,
  0xE5, 0x70, 0x57, 0x50, 0xFE, 0xC9, 0x35, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 5, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 2, 6, 2, 0, -5 },
  { 23, 4, 3, 4, 0, -5 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 5, 2, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 2, 4, 0, -3 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 5, 3, 0, -5 },
  { 71, 6, 6, 6, 0, -5 },
  { 76, 5, 5, 5, 0, -5 },
  { 80, 3, 5, 5, 1, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 5, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 2, 5, 4, 1, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 4, 5, 5, 1, -5 },
  { 99, 2, 5, 3, 0, -5 },
  { 101, 3, 6, 2, -1, -5 },
  { 104, 4, 5, 5, 1, -5 },
  { 107, 3, 5, 4, 1, -5 },
  { 109, 5, 5, 7, 1, -5 },
  { 113, 4, 5, 6, 1, -5 },
  { 116, 5, 5, 6, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 5, 6, 6, 0, -5 },
  { 126, 3, 5, 5, 1, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 5, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 7, 5, 7, 0, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 4, 5, 4, 0, -5 },
  { 151, 4, 5, 4, 0, -5 },
  { 154, 1, 6, 2, 1, -5 },
  { 155, 3, 5, 3, 0, -5 },
  { 157, 2, 6, 2, 0, -5 },
  { 159, 4, 3, 4, 0, -5 },
  { 161, 3, 1, 3, 0, 0 },
  { 162, 2, 1, 2, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 3, 4, 4, 0, -4 },
  { 169, 4, 5, 4, 0, -5 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 3, 5, 3, 0, -5 },
  { 176, 4, 6, 4, 0, -4 },
  { 179, 3, 5, 4, 1, -5 },
  { 181, 1, 5, 2, 0, -5 },
  { 182, 1, 7, 2, 0, -5 },
  { 183, 3, 5, 4, 1, -5 },
  { 185, 1, 5, 2, 0, -5 },
  { 186, 5, 4, 7, 1, -4 },
  { 189, 3, 4, 4, 1, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 3, 6, 4, 1, -4 },
  { 196, 4, 6, 4, 0, -4 },
  { 199, 2, 4, 3, 1, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 3, 5, 3, 0, -5 },
  { 204, 3, 4, 4, 1, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 6, 4, 6, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 2, 6, 3, 0, -5 },
  { 220, 1, 7, 4, 1, -5 },
  { 221, 3, 6, 3, 0, -5 },
  { 224, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMIBOLD7PT7B_H_
