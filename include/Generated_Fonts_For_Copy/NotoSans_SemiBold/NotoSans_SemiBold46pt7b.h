#ifndef _NOTOSANS_SEMIBOLD46PT7B_H_
#define _NOTOSANS_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x43, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C, 0x20, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF1, 0xF8, 0xE0, 0xCF, 0xC3, 0x80, 0x3F, 0x0E, 0x00, 0xFC,
  0x38, 0x01, 0xF8, 0xE0, 0x07, 0xFB, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0x9F, 0xC0, 0x0E, 0x3F, 0x00, 0x38, 0xFC, 0x00,
  0xE3, 0xF8, 0x03, 0x8F, 0xFC, 0x0E, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x3C,
  0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x7C, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0xF8, 0x00,
  0xF0, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x87,
  0xC0, 0x01, 0xE0, 0x7C, 0x3C, 0x00, 0x0F, 0x03, 0xC3, 0xE0, 0x00, 0x7C,
  0x1E, 0x3E, 0x1F, 0x83, 0xE1, 0xF1, 0xF3, 0xFF, 0x0F, 0x0F, 0x9F, 0x3F,
  0xFC, 0x7F, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0xCF, 0x9F, 0x0F, 0x8F, 0xFC,
  0x78, 0xF8, 0x7C, 0x1F, 0xC7, 0xC7, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x0F,
  0x00, 0x03, 0xE1, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x03, 0xE0, 0x01, 0xF0,
  0x78, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x07, 0x80,
  0x0F, 0x80, 0xF8, 0x3C, 0x00, 0x78, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x3E,
  0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x02,
  0x0F, 0xFE, 0x00, 0xFC, 0x1F, 0xFF, 0x00, 0xFC, 0x3F, 0xFF, 0x80, 0xFC,
  0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0xFE, 0x07, 0xF3, 0xF8,
  0xFC, 0x03, 0xFB, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xE0,
  0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0xE0,
  0x7F, 0xEF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFB, 0xFC,
  0x0F, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB,
  0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0C, 0x0F, 0x81,
  0xBE, 0x1C, 0x3E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x87,
  0xFF, 0xF1, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xC1, 0xE0,
  0x03, 0x02, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0,
  0xFE, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xBF, 0xFE, 0x7E, 0xF8, 0xFC, 0xE1, 0xF8,
  0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xE3, 0x80, 0x1F,
  0x84, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xE0, 0x0F, 0xE3, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0xFE, 0xFC, 0x1F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF9,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3,
  0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x78, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x60, 0x3F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xB8, 0x00, 0xFE, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xE3, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x1F, 0x9F, 0xFC, 0x3F, 0x7F, 0xFC,
  0x7D, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFB, 0xF8, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF8,
  0x0F, 0xE3, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0x87, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC,
  0x3F, 0xC7, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFD, 0xFF, 0x0F, 0xC1, 0xFE, 0x7E, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7F, 0x03, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xF7, 0xC7, 0xFF, 0x9F, 0x07, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x20, 0x7F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x20, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC3, 0xC3, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0x80, 0x7F, 0x20, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x0F, 0xFE, 0x0F, 0x8F, 0x80,
  0xFF, 0xF8, 0x3C, 0x78, 0x1F, 0xFF, 0xC1, 0xE7, 0xC1, 0xFE, 0x3E, 0x0F,
  0xBE, 0x0F, 0x80, 0xF0, 0x7D, 0xE0, 0xF8, 0x0F, 0x81, 0xEF, 0x07, 0xC0,
  0x7C, 0x0F, 0x78, 0x3C, 0x03, 0xE0, 0x7F, 0xC1, 0xE0, 0x1F, 0x03, 0xFE,
  0x1F, 0x00, 0xF8, 0x1F, 0xF0, 0xF8, 0x07, 0xC1, 0xFF, 0x87, 0xC0, 0x3E,
  0x0F, 0x7C, 0x1E, 0x01, 0xF0, 0x7B, 0xE0, 0xF8, 0x1F, 0x87, 0xCF, 0x07,
  0xE1, 0xFC, 0x3C, 0x78, 0x1F, 0xFE, 0xFF, 0xE3, 0xE0, 0xFF, 0xF7, 0xFE,
  0x1F, 0x03, 0xFF, 0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x70, 0xFF, 0x00,
  0x08, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x61, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x07, 0xFE, 0x3F, 0x00, 0x3F, 0xE7, 0xE0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xF3, 0xF0, 0x03, 0xFC, 0x7E, 0x01, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x07, 0x0F, 0xF0, 0x00, 0x21, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x9F, 0xF0, 0x03, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFB,
  0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFC,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0xF8,
  0x00, 0x3F, 0xFF, 0xDF, 0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x01, 0xF7, 0xFF,
  0x3E, 0x00, 0x3E, 0xFF, 0xE7, 0xC0, 0x07, 0xDF, 0xFC, 0xF8, 0x01, 0xF3,
  0xFF, 0xCF, 0x80, 0x3E, 0x7F, 0xF9, 0xF0, 0x07, 0x8F, 0xFF, 0x3E, 0x01,
  0xF1, 0xFF, 0xE3, 0xE0, 0x3E, 0x3F, 0xFC, 0x7C, 0x07, 0x87, 0xFF, 0x8F,
  0x81, 0xF0, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0xFE, 0x1F, 0x07, 0x83, 0xFF,
  0xC3, 0xE1, 0xF0, 0x7F, 0xF8, 0x3E, 0x3E, 0x0F, 0xFF, 0x07, 0xCF, 0x81,
  0xFF, 0xE0, 0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0xBE, 0x07, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0x80, 0x7F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0x00,
  0x1F, 0xFB, 0xF8, 0x01, 0xFF, 0x9F, 0x80, 0x1F, 0xF9, 0xFC, 0x01, 0xFF,
  0x8F, 0xC0, 0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x87, 0xF0, 0x1F, 0xF8, 0x3F,
  0x01, 0xFF, 0xC3, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFC, 0x0F, 0xE1, 0xFF, 0xC0, 0x7E, 0x1F, 0xFC, 0x07, 0xF1, 0xFF, 0xC0,
  0x3F, 0x1F, 0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0x1F, 0xDF, 0xFC, 0x00, 0xFD,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xBF, 0x01, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x80, 0x71, 0xF8,
  0x00, 0x4F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x7F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x1F, 0x80, 0xF9, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x1F, 0x80, 0xF9, 0xF0, 0x1F,
  0x00, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF1, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x7C,
  0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x00, 0x7E, 0x3E,
  0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x07,
  0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xEF,
  0xC0, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xC7,
  0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x78, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xF0, 0x3F, 0x84, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xF0, 0x7D, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xBF,
  0xFF, 0xFD, 0xFF, 0xF9, 0xE7, 0xFF, 0x8F, 0x1F, 0xF8, 0x78, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x87, 0xF8, 0x3E, 0x7F, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xF8, 0x7F, 0xBF, 0x80, 0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xFC, 0x7F, 0xBF,
  0xFF, 0xFC, 0xFB, 0xFF, 0xE3, 0xE7, 0xFF, 0x8F, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xF7, 0xC3,
  0xF8, 0x04, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x02, 0x3F, 0xE7, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xF1, 0xF8, 0x7F, 0xFB,
  0xF1, 0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0xBF, 0xC0, 0x7F,
  0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xF0,
  0x07, 0xEF, 0xE0, 0x1F, 0xCF, 0xF1, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xBE, 0x1F, 0xFE, 0x7C, 0x0F, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x43, 0xFC, 0x07, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x3E, 0x1F, 0xFE, 0x7C, 0x7F, 0xFE, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFC, 0x7F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF3,
  0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0x03,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE8, 0x00, 0x1F, 0xCE, 0x00, 0x7F, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x87, 0xFC, 0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xFC, 0x7F, 0xBF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x10,
  0xFB, 0xFF, 0xFF, 0xEF, 0x86, 0x00, 0x00, 0x01, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x80, 0x3E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC,
  0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xF7, 0xC0,
  0x1F, 0xCF, 0x80, 0x7F, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0,
  0x0F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F,
  0x81, 0xFC, 0x1F, 0x01, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xF8,
  0x03, 0xF9, 0xF0, 0x03, 0xFB, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xCF,
  0xFF, 0x1F, 0xFE, 0x3E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xF8, 0xFF, 0xF8, 0xFF, 0x7F, 0x01, 0xFF, 0x01, 0xFB, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0xF0, 0x7F, 0xC3, 0xC7, 0xFF, 0x8F, 0xBF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xC7, 0xFB, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xC3, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F,
  0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xF0, 0x7F, 0x83, 0xE7, 0xFF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0x87, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFF, 0xCF, 0xFB,
  0xFF, 0xFF, 0xCF, 0xBF, 0xFE, 0x3E, 0x7F, 0xF0, 0xF8, 0xFF, 0x83, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x3E, 0x1F, 0xFE, 0x7C, 0x7F,
  0xFE, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x3F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF8, 0x07, 0xF3, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87,
  0xFF, 0xBF, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0xF0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xE0, 0x79,
  0xF8, 0x01, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x80, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE1, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xF7, 0xFC, 0x7F,
  0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xEF, 0x8F, 0xFF, 0x9F, 0x0F, 0xFC, 0x3E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD,
  0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F,
  0x80, 0x7E, 0x3E, 0x01, 0xFF, 0x01, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0xF0, 0x3F, 0x07, 0xC0, 0xF3, 0xC0, 0xFC, 0x1F, 0x83, 0xCF,
  0x83, 0xE0, 0x7E, 0x1F, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0xF8, 0x7E, 0x03,
  0xE1, 0xE1, 0xE1, 0xF0, 0x0F, 0xCF, 0x87, 0xC7, 0xC0, 0x3F, 0x3E, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x7C, 0xFC, 0x01, 0xF3, 0xC0, 0xF3, 0xE0, 0x07,
  0xCF, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x3F,
  0x87, 0xE0, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xF9, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x04, 0xFF, 0x80, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFF,
  0x00,
};

const GFXglyph NotoSans_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 34, 13, 3, -33 },
  { 31, 15, 12, 21, 3, -33 },
  { 54, 28, 33, 30, 1, -33 },
  { 170, 22, 38, 26, 2, -35 },
  { 275, 37, 33, 40, 2, -33 },
  { 428, 32, 33, 34, 2, -33 },
  { 560, 6, 12, 12, 3, -33 },
  { 569, 12, 40, 15, 2, -33 },
  { 629, 12, 40, 15, 1, -33 },
  { 689, 22, 21, 25, 2, -35 },
  { 747, 22, 22, 26, 2, -27 },
  { 808, 8, 11, 13, 2, -5 },
  { 819, 11, 5, 15, 2, -15 },
  { 826, 7, 8, 13, 3, -7 },
  { 833, 18, 33, 18, 0, -33 },
  { 908, 22, 33, 26, 2, -33 },
  { 999, 15, 33, 26, 3, -33 },
  { 1061, 22, 33, 26, 2, -33 },
  { 1152, 22, 33, 26, 2, -33 },
  { 1243, 24, 33, 26, 1, -33 },
  { 1342, 22, 33, 26, 2, -33 },
  { 1433, 23, 33, 26, 2, -33 },
  { 1528, 23, 33, 26, 2, -33 },
  { 1623, 22, 33, 26, 2, -33 },
  { 1714, 22, 33, 26, 2, -33 },
  { 1805, 7, 26, 13, 3, -25 },
  { 1828, 9, 31, 13, 1, -25 },
  { 1863, 22, 23, 26, 2, -28 },
  { 1927, 22, 13, 26, 2, -23 },
  { 1963, 22, 23, 26, 2, -28 },
  { 2027, 20, 34, 21, 0, -33 },
  { 2112, 37, 37, 41, 2, -33 },
  { 2284, 31, 33, 31, 0, -33 },
  { 2412, 24, 33, 30, 4, -33 },
  { 2511, 25, 33, 29, 3, -33 },
  { 2615, 27, 33, 34, 4, -33 },
  { 2727, 19, 33, 26, 4, -33 },
  { 2806, 19, 33, 25, 4, -33 },
  { 2885, 27, 33, 33, 3, -33 },
  { 2997, 27, 33, 35, 4, -33 },
  { 3109, 13, 33, 17, 2, -33 },
  { 3163, 14, 42, 14, -4, -33 },
  { 3237, 26, 33, 30, 4, -33 },
  { 3345, 20, 33, 25, 4, -33 },
  { 3428, 35, 33, 43, 4, -33 },
  { 3573, 28, 33, 36, 4, -33 },
  { 3689, 31, 33, 36, 3, -33 },
  { 3817, 22, 33, 28, 4, -33 },
  { 3908, 31, 41, 36, 3, -33 },
  { 4067, 25, 33, 30, 4, -33 },
  { 4171, 21, 33, 25, 2, -33 },
  { 4258, 24, 33, 26, 1, -33 },
  { 4357, 26, 33, 34, 4, -33 },
  { 4465, 29, 33, 29, 0, -33 },
  { 4585, 44, 33, 44, 0, -33 },
  { 4767, 29, 33, 29, 0, -33 },
  { 4887, 28, 33, 28, 0, -33 },
  { 5003, 24, 33, 27, 1, -33 },
  { 5102, 11, 40, 15, 3, -33 },
  { 5157, 18, 33, 18, 0, -33 },
  { 5232, 11, 40, 15, 1, -33 },
  { 5287, 24, 21, 26, 1, -33 },
  { 5350, 20, 3, 19, 0, 4 },
  { 5358, 11, 7, 15, 2, -35 },
  { 5368, 21, 25, 27, 2, -25 },
  { 5434, 22, 35, 29, 4, -35 },
  { 5531, 20, 25, 23, 2, -25 },
  { 5594, 23, 35, 29, 2, -35 },
  { 5695, 23, 25, 27, 2, -25 },
  { 5767, 18, 35, 17, 1, -35 },
  { 5846, 23, 36, 29, 2, -25 },
  { 5950, 22, 35, 29, 4, -35 },
  { 6047, 7, 35, 13, 3, -35 },
  { 6078, 12, 46, 13, -2, -35 },
  { 6147, 23, 35, 27, 4, -35 },
  { 6248, 5, 35, 13, 4, -35 },
  { 6270, 37, 25, 44, 4, -25 },
  { 6386, 22, 25, 29, 4, -25 },
  { 6455, 24, 25, 28, 2, -25 },
  { 6530, 22, 36, 29, 4, -25 },
  { 6629, 23, 36, 29, 2, -25 },
  { 6733, 15, 25, 20, 4, -25 },
  { 6780, 19, 25, 23, 2, -25 },
  { 6840, 16, 30, 19, 1, -30 },
  { 6900, 23, 25, 29, 3, -25 },
  { 6972, 25, 25, 25, 0, -25 },
  { 7051, 38, 25, 38, 0, -25 },
  { 7170, 25, 25, 26, 0, -25 },
  { 7249, 25, 36, 25, 0, -25 },
  { 7362, 19, 25, 22, 2, -25 },
  { 7422, 15, 40, 18, 1, -33 },
  { 7497, 5, 46, 25, 10, -35 },
  { 7526, 15, 40, 18, 2, -33 },
  { 7601, 22, 7, 26, 2, -20 },
};

const GFXfont NotoSans_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMIBOLD46PT7B_H_
