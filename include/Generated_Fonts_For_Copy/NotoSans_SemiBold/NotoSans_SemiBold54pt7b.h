#ifndef _NOTOSANS_SEMIBOLD54PT7B_H_
#define _NOTOSANS_SEMIBOLD54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x7F, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xF9, 0xFC, 0x38, 0xFE, 0x1F,
  0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC7, 0x0F, 0x9F, 0xC3, 0x80,
  0x4F, 0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF8, 0x70, 0x01, 0xFC, 0x38,
  0x00, 0xFF, 0x1C, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0E, 0xFF, 0xC0, 0x07, 0x1F, 0xE0,
  0x03, 0x87, 0xF0, 0x01, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0x70, 0x7F,
  0x80, 0x38, 0x7F, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xE0, 0x7C, 0x3F, 0x07, 0x80, 0xFC, 0x0F, 0x87, 0xC3, 0xFE,
  0x0F, 0x83, 0xF1, 0xF8, 0xFF, 0xE1, 0xF8, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F,
  0xBF, 0x8F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF3, 0xF1, 0xF8, 0xFC, 0x3F, 0xFC,
  0x7C, 0x3E, 0x0F, 0x83, 0xFF, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x83, 0xE1,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xFF,
  0xE0, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0x83, 0xFE, 0x7F, 0x80, 0xFE,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC1, 0xFC, 0x03,
  0xFC, 0x7F, 0x07, 0xF0, 0x07, 0xFB, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xE0,
  0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x01, 0x00, 0xF8, 0x06, 0x7C, 0x3E, 0x0F, 0xBF, 0xE7, 0xBF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0x80, 0x0E, 0x03, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE,
  0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7,
  0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0x8F, 0xEF,
  0x87, 0xF3, 0x83, 0xF8, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0xE1, 0xF0,
  0x01, 0xFC, 0x18, 0x00, 0x3F, 0x81, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0xF8, 0x60, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0x00,
  0x7F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xF1, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0xC0,
  0x00, 0xFF, 0x7E, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x8E, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x03, 0xF1, 0xFF, 0xC0, 0x7E, 0x7F, 0xFE, 0x0F, 0xDF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFD, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x28, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x80, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xFC,
  0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0xBF, 0xE0,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xDF, 0x87, 0xFF, 0xF3, 0xF0,
  0x3F, 0xFC, 0x7E, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x04, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x3F, 0x9F,
  0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xFE,
  0x7F, 0x7F, 0xFF, 0xFF, 0xF7, 0xF3, 0xF8, 0x70, 0x1F, 0x0F, 0xE3, 0xF9,
  0xFF, 0x7F, 0xDF, 0xF3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3C,
  0x01, 0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x18, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0xFE, 0x07, 0xC3, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFC, 0x7C, 0x07, 0xFF, 0xFC, 0x0F, 0x9F, 0x81, 0xFF, 0xFF,
  0x81, 0xF3, 0xE0, 0x7F, 0x01, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0x3E, 0x03,
  0xFF, 0x83, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xFC,
  0x0F, 0x80, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x03, 0xE0, 0x3F, 0xF0, 0x7E,
  0x00, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0xC1, 0xF8, 0x03,
  0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xDF, 0x03, 0xE0, 0x0F, 0xC0,
  0xFB, 0xE0, 0x7E, 0x03, 0xF8, 0x3E, 0x7C, 0x0F, 0xC0, 0x7F, 0x07, 0xCF,
  0x80, 0xFE, 0x3F, 0xF3, 0xF1, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0x01,
  0xFF, 0xF3, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7E, 0x00, 0xFE,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xCF, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0x07, 0xFE, 0x00, 0x0C, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x30, 0x3F, 0xFF, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0xF8,
  0x7F, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x3C, 0x0F, 0xF8, 0x00,
  0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x7F, 0x1F, 0xF0, 0x00,
  0x7F, 0x1F, 0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x03, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0xFD, 0xF8, 0x00, 0x1F,
  0xBF, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00,
  0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xC0, 0x3F,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0x80, 0x07, 0xFF,
  0x9F, 0xC0, 0x03, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0xF1, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0, 0x1F,
  0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x81, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xF0, 0x0F, 0xF0,
  0x7F, 0xF8, 0x03, 0xFC, 0x3F, 0xFC, 0x01, 0xFE, 0x1F, 0xFE, 0x00, 0x7F,
  0x8F, 0xFF, 0x00, 0x1F, 0xC7, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0xC0, 0x03,
  0xFD, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFB, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xEF, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFD, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xF8, 0x07, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0x80, 0x3C, 0xFF, 0x00, 0x04,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xA0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x01, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3E, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0x81,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE1, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00,
  0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0xE0, 0x70, 0x07, 0xF8,
  0x10, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F, 0xDF, 0xE0, 0x07, 0xF7,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0x8F, 0xC1,
  0xFF, 0x81, 0xF0, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xE3,
  0xFF, 0x81, 0xFC, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xDF, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0x87, 0xE3, 0xFF, 0xE0, 0xFC, 0x3F, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFE, 0x03, 0x9F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0x3F, 0xE0,
  0x7C, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3E, 0x07, 0xF0, 0x3F,
  0xF8, 0xFE, 0x1F, 0xFF, 0x9F, 0xC7, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xDF, 0xC3, 0xFF, 0xFB, 0xF8, 0x3F, 0xFE, 0x3F, 0x03, 0xFF, 0x07,
  0xE0, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xC3,
  0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x02, 0x3F, 0xE0,
  0x07, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x28, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFC,
  0x18, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFC, 0x01, 0xFF,
  0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF,
  0xC0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xF0, 0x7F, 0xFC, 0xFE, 0x07,
  0xFE, 0x1F, 0xC0, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x20, 0x00, 0x1F, 0xE3, 0x80,
  0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0xFE, 0x3F, 0xFC, 0x3F, 0x9F, 0xFF, 0x8F, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xC0, 0x10, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x20, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x02, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xEF, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x3F, 0x0F, 0xFF, 0x0F, 0xC7, 0xFF, 0xE3, 0xF3, 0xFF, 0xFC, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x87, 0xFF, 0x03, 0xF1, 0xFF, 0xF0, 0x7E, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xE7,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0xE0, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0x0F, 0xE7,
  0xFF, 0xC1, 0xFC, 0x3F, 0xE0, 0x3F, 0x80, 0x40, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F,
  0x8F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xF0,
  0x1F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F,
  0xE0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xFF, 0xF7,
  0xF0, 0x7F, 0xFC, 0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x04, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xEF, 0xCF, 0xFD, 0xFB, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x01, 0x9F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x08, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xA0, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x07, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFB, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF,
  0x1F, 0x07, 0xFF, 0x07, 0xC0, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xFC, 0x01, 0xFC,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0x3E, 0xF8, 0x07, 0xE1, 0xF8,
  0x07, 0xDF, 0x01, 0xFC, 0x3F, 0x81, 0xFB, 0xF0, 0x3F, 0x87, 0xF0, 0x3E,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x3F, 0x87, 0xC3, 0xF0, 0xFC,
  0x03, 0xF0, 0xF8, 0x3E, 0x1F, 0x80, 0x7E, 0x3F, 0x07, 0xC7, 0xF0, 0x0F,
  0xE7, 0xE0, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x1F, 0x9F, 0x80, 0x1F, 0x9F,
  0x01, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x3E, 0xFE, 0x00, 0x7E, 0xFC, 0x07,
  0xDF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x02, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFA, 0x00, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 40, 15, 3, -39 },
  { 46, 18, 14, 24, 3, -39 },
  { 78, 33, 39, 35, 1, -39 },
  { 239, 25, 44, 31, 3, -41 },
  { 377, 43, 39, 47, 2, -39 },
  { 587, 38, 40, 40, 2, -39 },
  { 777, 7, 14, 14, 3, -39 },
  { 790, 14, 48, 18, 2, -39 },
  { 874, 13, 48, 18, 2, -39 },
  { 952, 26, 25, 29, 2, -41 },
  { 1034, 26, 26, 31, 2, -32 },
  { 1119, 9, 13, 15, 2, -6 },
  { 1134, 14, 5, 17, 2, -17 },
  { 1143, 9, 9, 15, 3, -8 },
  { 1154, 21, 39, 22, 0, -39 },
  { 1257, 27, 40, 31, 2, -39 },
  { 1392, 17, 39, 31, 4, -39 },
  { 1475, 27, 39, 31, 2, -39 },
  { 1607, 26, 40, 31, 2, -39 },
  { 1737, 29, 39, 31, 1, -39 },
  { 1879, 25, 40, 31, 3, -39 },
  { 2004, 27, 40, 31, 2, -39 },
  { 2139, 27, 39, 31, 2, -39 },
  { 2271, 27, 40, 31, 2, -39 },
  { 2406, 27, 40, 31, 2, -39 },
  { 2541, 9, 31, 15, 3, -30 },
  { 2576, 10, 37, 15, 2, -30 },
  { 2623, 26, 27, 31, 2, -33 },
  { 2711, 25, 16, 31, 3, -27 },
  { 2761, 26, 27, 31, 2, -33 },
  { 2849, 24, 40, 25, 0, -39 },
  { 2969, 43, 44, 48, 3, -39 },
  { 3206, 36, 39, 36, 0, -39 },
  { 3382, 28, 39, 36, 5, -39 },
  { 3519, 30, 40, 34, 3, -39 },
  { 3669, 31, 39, 40, 5, -39 },
  { 3821, 22, 39, 30, 5, -39 },
  { 3929, 22, 39, 29, 5, -39 },
  { 4037, 32, 40, 39, 3, -39 },
  { 4197, 31, 39, 41, 5, -39 },
  { 4349, 16, 39, 20, 2, -39 },
  { 4427, 16, 50, 17, -4, -39 },
  { 4527, 30, 39, 35, 5, -39 },
  { 4674, 23, 39, 29, 5, -39 },
  { 4787, 40, 39, 50, 5, -39 },
  { 4982, 33, 39, 43, 5, -39 },
  { 5143, 36, 40, 43, 3, -39 },
  { 5323, 26, 39, 33, 5, -39 },
  { 5450, 36, 48, 43, 3, -39 },
  { 5666, 29, 39, 35, 5, -39 },
  { 5808, 24, 40, 30, 3, -39 },
  { 5928, 29, 39, 31, 1, -39 },
  { 6070, 31, 40, 40, 5, -39 },
  { 6225, 34, 39, 34, 0, -39 },
  { 6391, 51, 39, 51, 0, -39 },
  { 6640, 34, 39, 34, 0, -39 },
  { 6806, 33, 39, 33, 0, -39 },
  { 6967, 28, 39, 31, 2, -39 },
  { 7104, 12, 48, 18, 4, -39 },
  { 7176, 21, 39, 22, 0, -39 },
  { 7279, 13, 48, 18, 1, -39 },
  { 7357, 27, 25, 31, 2, -39 },
  { 7442, 23, 3, 23, 0, 5 },
  { 7451, 14, 8, 18, 2, -41 },
  { 7465, 26, 31, 32, 2, -30 },
  { 7566, 27, 42, 34, 4, -41 },
  { 7708, 22, 31, 27, 3, -30 },
  { 7794, 27, 42, 34, 3, -41 },
  { 7936, 26, 31, 32, 3, -30 },
  { 8037, 21, 41, 20, 1, -41 },
  { 8145, 27, 43, 34, 3, -30 },
  { 8291, 26, 41, 34, 4, -41 },
  { 8425, 8, 41, 15, 4, -41 },
  { 8466, 15, 54, 15, -3, -41 },
  { 8568, 28, 41, 32, 4, -41 },
  { 8712, 7, 41, 15, 4, -41 },
  { 8748, 44, 30, 52, 4, -30 },
  { 8913, 26, 30, 34, 4, -30 },
  { 9011, 28, 31, 33, 3, -30 },
  { 9120, 27, 43, 34, 4, -30 },
  { 9266, 27, 43, 34, 3, -30 },
  { 9412, 19, 30, 23, 4, -30 },
  { 9484, 21, 31, 27, 3, -30 },
  { 9566, 19, 37, 22, 1, -36 },
  { 9654, 26, 30, 34, 4, -29 },
  { 9752, 30, 29, 30, 0, -29 },
  { 9861, 43, 29, 45, 1, -29 },
  { 10017, 29, 29, 30, 1, -29 },
  { 10123, 30, 42, 30, 0, -29 },
  { 10281, 22, 29, 26, 2, -29 },
  { 10361, 18, 48, 21, 1, -39 },
  { 10469, 5, 54, 30, 12, -41 },
  { 10503, 18, 48, 21, 2, -39 },
  { 10611, 26, 8, 31, 2, -23 },
};

const GFXfont NotoSans_SemiBold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMIBOLD54PT7B_H_
