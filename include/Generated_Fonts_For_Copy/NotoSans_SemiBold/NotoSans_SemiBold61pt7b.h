#ifndef _NOTOSANS_SEMIBOLD61PT7B_H_
#define _NOTOSANS_SEMIBOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x07, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE1, 0xC0, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0x9E, 0x0F, 0x8F, 0xF0, 0xF0, 0x0C, 0x7F, 0x87, 0x80, 0x03, 0xFC,
  0x3C, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0xFF, 0x0F, 0x00, 0x07, 0xFC, 0x78,
  0x00, 0x1F, 0xF3, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xF7, 0xFF, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x3C, 0x1F,
  0xE0, 0x01, 0xE0, 0xFF, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x78, 0x1F, 0xE0,
  0x03, 0xC1, 0xFF, 0xE0, 0x1E, 0x1F, 0xFF, 0xE0, 0xF1, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0x1F, 0x81, 0xFC, 0x3F, 0x0F, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xFF,
  0x07, 0xF0, 0x7E, 0x3F, 0x8F, 0xFF, 0xC1, 0xF8, 0x7F, 0x1F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xC7, 0xFB, 0xF8, 0x3F, 0xFF, 0x8F, 0xC7, 0xF0,
  0xFE, 0x0F, 0xFF, 0x8F, 0xE3, 0xF0, 0x3F, 0x03, 0xFF, 0x87, 0xE1, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xFD,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x0F,
  0xF0, 0x01, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x0F, 0x80, 0x73,
  0xF8, 0x7C, 0x1F, 0x9F, 0xFB, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x01,
  0xF8, 0x00, 0x38, 0x07, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xF7, 0xF8,
  0xFF, 0x3F, 0x0F, 0xF3, 0xE0, 0xFF, 0x1C, 0x0F, 0xF0, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0x8F, 0xF0,
  0x07, 0xFC, 0x3E, 0x00, 0x1F, 0xF0, 0xE0, 0x00, 0x7F, 0x84, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07, 0xFC, 0x0C, 0x00, 0x0F, 0xF8, 0x20,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFD, 0x00,
  0x00, 0x3F, 0xEE, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x7F, 0xF3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xA0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x04, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0xF8, 0x0F, 0xE3, 0xFF, 0xF8, 0x3F,
  0x9F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE,
  0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xFB, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x03,
  0xFE, 0x7F, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFF,
  0x00, 0x1F, 0xE3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x1F, 0xC0, 0x7F,
  0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x87, 0x00, 0x07, 0x03,
  0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87,
  0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0xF1, 0xF0, 0x01, 0xFE, 0x10, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x83, 0xF0,
  0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x7E,
  0x3F, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x0F,
  0x9F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xCF, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xF7, 0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0x00,
  0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xBF, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xDF, 0x81, 0xF8, 0x00, 0xFC,
  0x07, 0xEF, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x00, 0x7F,
  0x01, 0xF3, 0xF0, 0x1F, 0x80, 0x7F, 0x81, 0xF9, 0xF8, 0x0F, 0xE0, 0x7F,
  0xE1, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x01, 0xFF, 0xFE,
  0xFF, 0xFC, 0x1F, 0x80, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFC, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF,
  0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xF0, 0x00,
  0x1F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x78, 0x1F,
  0xFC, 0x00, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xF8,
  0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xB0, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0x80,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x7F, 0xC7, 0xF0,
  0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x3F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0x1F, 0xF0, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x0F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x0F, 0xF8, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xFF,
  0x7F, 0x00, 0x00, 0x7E, 0xFF, 0xF9, 0xF8, 0x00, 0x07, 0xF7, 0xFF, 0xCF,
  0xE0, 0x00, 0x3F, 0x3F, 0xFE, 0x7F, 0x00, 0x01, 0xF9, 0xFF, 0xF1, 0xF8,
  0x00, 0x1F, 0xCF, 0xFF, 0xCF, 0xE0, 0x00, 0xFC, 0x7F, 0xFE, 0x7F, 0x00,
  0x07, 0xE3, 0xFF, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0xFF, 0x8F, 0xE0, 0x03,
  0xF0, 0xFF, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x01, 0xFC,
  0x3F, 0xFF, 0x0F, 0xE0, 0x0F, 0xC1, 0xFF, 0xF8, 0x7F, 0x00, 0xFE, 0x0F,
  0xFF, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xFF,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xF8, 0x1F, 0x80, 0xFF, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0x01,
  0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xFE,
  0x3F, 0xC0, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x3F,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFC,
  0x3F, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xF8, 0x00, 0x7F, 0xCF, 0xFF, 0xC0,
  0x03, 0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0xF0, 0x00, 0x3F, 0xDF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFE, 0xFF, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFE, 0xFF,
  0x00, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x7C,
  0x7F, 0x80, 0x00, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0x70, 0x01, 0xFF, 0x04,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0x8F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF3, 0xFF, 0xFE, 0x3F, 0x1F,
  0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0x3F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xE0, 0x03, 0xF8,
  0x3F, 0xF8, 0x0F, 0xE3, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xE0, 0xFE, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x07,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF,
  0xBF, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xEF, 0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x03, 0xF0,
  0x7F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x1C, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x08, 0xFF,
  0xE0, 0x1E, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x5C,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1E,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0x1F, 0xC1, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7,
  0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xFF,
  0xF0, 0xFC, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0x0F, 0xFC, 0x00, 0x1C, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0x0F, 0xC1, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF,
  0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x07,
  0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x7F,
  0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xF1, 0xFC, 0x03,
  0xFF, 0x07, 0xF0, 0x00, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x30, 0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x27, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x7F, 0x07,
  0xFF, 0x83, 0xF8, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x1E, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFC, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3C, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xBF, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xF9, 0xFE, 0x00,
  0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7E, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x7F,
  0xF8, 0x3F, 0x0F, 0xFF, 0xE1, 0xF8, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xA0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x3F,
  0xF8, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x07, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xEF,
  0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x03, 0xF8, 0x3F,
  0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0x0F, 0xC1, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xFE, 0x7F, 0x03, 0xFF,
  0xF1, 0xFC, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xE7, 0xE0, 0x7F, 0xFF, 0x07, 0xFD, 0xF8, 0x7F,
  0xEF, 0xC7, 0xFF, 0x7F, 0x7F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0x80, 0xFC, 0xFF, 0x00, 0x0C, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFC, 0xFF,
  0xFF, 0xCF, 0xE1, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x7E,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x9F,
  0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xE3,
  0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF1, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF0,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC,
  0x1F, 0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7E,
  0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x3F, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x7E, 0x7F, 0x00, 0x0F, 0xEF,
  0xC0, 0x3F, 0x3F, 0x80, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFB,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x09, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xD8, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 45, 17, 4, -44 },
  { 52, 20, 16, 28, 4, -44 },
  { 92, 37, 44, 39, 1, -44 },
  { 296, 29, 50, 35, 3, -46 },
  { 478, 49, 45, 53, 2, -44 },
  { 754, 42, 45, 45, 3, -44 },
  { 991, 7, 16, 15, 4, -44 },
  { 1005, 16, 54, 20, 2, -44 },
  { 1113, 15, 54, 20, 2, -44 },
  { 1215, 29, 28, 33, 2, -46 },
  { 1317, 29, 29, 35, 3, -36 },
  { 1423, 11, 15, 17, 2, -7 },
  { 1444, 16, 7, 20, 2, -20 },
  { 1458, 9, 10, 17, 4, -9 },
  { 1470, 24, 44, 24, 0, -44 },
  { 1602, 30, 45, 35, 2, -44 },
  { 1771, 20, 44, 35, 4, -44 },
  { 1881, 29, 44, 35, 3, -44 },
  { 2041, 30, 45, 35, 2, -44 },
  { 2210, 33, 44, 35, 1, -44 },
  { 2392, 29, 45, 35, 3, -44 },
  { 2556, 30, 45, 35, 3, -44 },
  { 2725, 31, 44, 35, 2, -44 },
  { 2896, 30, 45, 35, 2, -44 },
  { 3065, 30, 45, 35, 2, -44 },
  { 3234, 9, 35, 17, 4, -34 },
  { 3274, 11, 42, 17, 2, -34 },
  { 3332, 29, 32, 35, 3, -38 },
  { 3448, 29, 17, 35, 3, -30 },
  { 3510, 29, 32, 35, 3, -38 },
  { 3626, 27, 45, 28, 0, -44 },
  { 3778, 49, 49, 55, 3, -44 },
  { 4079, 41, 44, 41, 0, -44 },
  { 4305, 32, 44, 40, 5, -44 },
  { 4481, 34, 45, 39, 3, -44 },
  { 4673, 36, 44, 45, 5, -44 },
  { 4871, 24, 44, 34, 6, -44 },
  { 5003, 24, 44, 33, 6, -44 },
  { 5135, 36, 45, 44, 4, -44 },
  { 5338, 34, 44, 46, 6, -44 },
  { 5525, 18, 44, 23, 2, -44 },
  { 5624, 18, 56, 19, -5, -44 },
  { 5750, 33, 44, 39, 6, -44 },
  { 5932, 26, 44, 33, 5, -44 },
  { 6075, 45, 44, 57, 6, -44 },
  { 6323, 37, 44, 48, 6, -44 },
  { 6527, 42, 45, 48, 3, -44 },
  { 6764, 30, 44, 38, 5, -44 },
  { 6929, 42, 54, 48, 3, -44 },
  { 7213, 34, 44, 39, 5, -44 },
  { 7400, 28, 45, 34, 3, -44 },
  { 7558, 33, 44, 35, 1, -44 },
  { 7740, 35, 45, 46, 5, -44 },
  { 7937, 38, 44, 38, 0, -44 },
  { 8146, 58, 44, 58, 0, -44 },
  { 8465, 39, 44, 39, 0, -44 },
  { 8680, 37, 44, 37, 0, -44 },
  { 8884, 31, 44, 35, 2, -44 },
  { 9055, 14, 54, 20, 5, -44 },
  { 9150, 24, 44, 24, 0, -44 },
  { 9282, 14, 54, 20, 2, -44 },
  { 9377, 31, 28, 35, 2, -44 },
  { 9486, 26, 5, 26, 0, 5 },
  { 9503, 16, 10, 20, 2, -47 },
  { 9523, 28, 35, 36, 3, -34 },
  { 9646, 30, 47, 38, 5, -46 },
  { 9823, 26, 35, 31, 3, -34 },
  { 9937, 30, 47, 38, 3, -46 },
  { 10114, 30, 35, 36, 3, -34 },
  { 10246, 24, 47, 23, 1, -47 },
  { 10387, 30, 49, 38, 3, -34 },
  { 10571, 29, 46, 39, 5, -46 },
  { 10738, 9, 46, 17, 4, -46 },
  { 10790, 16, 61, 17, -3, -46 },
  { 10912, 31, 46, 36, 5, -46 },
  { 11091, 8, 46, 17, 5, -46 },
  { 11137, 49, 34, 59, 5, -34 },
  { 11346, 29, 34, 39, 5, -34 },
  { 11470, 32, 35, 38, 3, -34 },
  { 11610, 30, 49, 38, 5, -34 },
  { 11794, 30, 49, 38, 3, -34 },
  { 11978, 21, 34, 26, 5, -34 },
  { 12068, 24, 35, 30, 3, -34 },
  { 12173, 22, 41, 25, 1, -40 },
  { 12286, 29, 34, 39, 5, -33 },
  { 12410, 33, 33, 33, 0, -33 },
  { 12547, 49, 33, 51, 1, -33 },
  { 12750, 33, 33, 34, 1, -33 },
  { 12887, 33, 48, 33, 0, -33 },
  { 13085, 25, 33, 30, 2, -33 },
  { 13189, 20, 54, 24, 1, -44 },
  { 13324, 6, 60, 34, 14, -46 },
  { 13369, 21, 54, 24, 2, -44 },
  { 13511, 29, 9, 35, 3, -26 },
};

const GFXfont NotoSans_SemiBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMIBOLD61PT7B_H_
