#ifndef _NOTOSANS_SEMIBOLD28PT7B_H_
#define _NOTOSANS_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x00, 0xEF, 0xFF, 0xE7,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1B, 0x8C, 0x03, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E,
  0x38, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C,
  0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0xFF, 0x0F, 0xFE, 0x7F, 0xF9, 0xCC, 0x4F, 0x30, 0x3C,
  0xC0, 0x7B, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0D, 0xF0,
  0x33, 0xC0, 0xCF, 0xE3, 0x7B, 0xFF, 0xEF, 0xFF, 0x07, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x3E, 0x01, 0xC1, 0xFC, 0x0E, 0x07, 0x78, 0x38,
  0x38, 0xE1, 0xC0, 0xE3, 0x87, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0xE0, 0x38,
  0xE7, 0x00, 0xE3, 0x9D, 0xF1, 0xDE, 0xEF, 0xE7, 0xF7, 0x39, 0xCF, 0x9C,
  0xE7, 0x00, 0xE7, 0x0C, 0x03, 0x9C, 0x30, 0x1C, 0x70, 0xC0, 0x71, 0xC3,
  0x03, 0x83, 0x1C, 0x0E, 0x0E, 0x70, 0x70, 0x1F, 0x83, 0x80, 0x7C, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x38, 0x38, 0x03,
  0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xC1, 0xE7, 0xDE, 0x1C, 0x78, 0xF3, 0xCF, 0x07, 0xB8, 0xF0, 0x3F,
  0x8F, 0x01, 0xF0, 0x78, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFB, 0xC1, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0E, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x38, 0xF1,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xE1, 0xC3, 0xC3, 0x87, 0x07,
  0x07, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x78, 0x07, 0x00,
  0x38, 0x01, 0xC1, 0x0E, 0x1F, 0x77, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x0D,
  0xC0, 0xEE, 0x0F, 0x38, 0x71, 0xE0, 0x88, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7B, 0xDC, 0xEE,
  0x73, 0x80, 0xFF, 0xFF, 0xF8, 0xEF, 0xFF, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x0F,
  0xC0, 0xFF, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xEF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7,
  0x03, 0x9C, 0x0E, 0x78, 0x78, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0x07, 0x87,
  0xC7, 0xE7, 0xFF, 0xFB, 0xBD, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x1F, 0xC1, 0xFF,
  0xCF, 0xFF, 0x9C, 0x1E, 0x20, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7,
  0xFF, 0x98, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x1F, 0xE0,
  0x7E, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x7B, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x77, 0x00, 0xFE, 0x03, 0xBC, 0x0E, 0x78, 0x1C, 0xF0,
  0x71, 0xE1, 0xC3, 0xC3, 0x87, 0x8E, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0xE3, 0xFF,
  0x3F, 0xF9, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0xC0, 0xFF, 0xC7,
  0xFF, 0x18, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x80,
  0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xF0, 0xF7, 0xF3, 0xFF, 0xEF,
  0x87, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x78,
  0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x9E, 0x1E, 0x70,
  0x39, 0xC0, 0xE7, 0x87, 0x8F, 0x3C, 0x1F, 0xE0, 0x3F, 0x03, 0xFE, 0x1F,
  0x3E, 0x70, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xF3, 0xE3,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0xF0, 0x3B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0xFF, 0x83, 0xFC,
  0x0F, 0xE0, 0x4F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x23, 0xDE,
  0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xCE, 0x77, 0x39, 0x80, 0x00,
  0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x3E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x7F, 0xF4, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0x07, 0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x87,
  0x07, 0xC3, 0x8C, 0x3F, 0xE3, 0x38, 0xFB, 0xC6, 0x71, 0xC3, 0x8E, 0xC7,
  0x07, 0x1F, 0x8E, 0x0E, 0x3F, 0x1C, 0x1C, 0x7E, 0x38, 0x38, 0xDC, 0x70,
  0xF3, 0x98, 0x73, 0xE7, 0x38, 0xFE, 0xFC, 0x70, 0x78, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x0F, 0x70, 0x01, 0xCF, 0x00, 0x38, 0xE0, 0x0F, 0x1E, 0x01, 0xC3,
  0xC0, 0x78, 0x38, 0x0F, 0x07, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0F, 0x78, 0x00,
  0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x01, 0xDE, 0x03,
  0xBC, 0x07, 0x78, 0x1E, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0xE7, 0x81, 0xEF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF3, 0xE0, 0x27, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x04, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E,
  0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x3E, 0xF0, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF,
  0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x03, 0xFE, 0x0F, 0xFF,
  0x3F, 0xFE, 0x3E, 0x02, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x78, 0x07, 0x7C, 0x07, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0xBF, 0xFE,
  0xFC, 0x70, 0xE0, 0x1F, 0xC0, 0x7B, 0x81, 0xE7, 0x07, 0x8E, 0x1E, 0x1C,
  0x78, 0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0E, 0x3C, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x78, 0xE0, 0x79, 0xC0, 0xF3,
  0x80, 0xF7, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x37, 0xEE, 0x07, 0x7E, 0xE0, 0x77, 0xEE, 0x0E, 0x7E, 0x70, 0xE7, 0xE7,
  0x0E, 0x7E, 0x71, 0xC7, 0xE3, 0x9C, 0x7E, 0x39, 0xC7, 0xE3, 0xB8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xBC, 0x1F, 0xCF, 0x0F, 0xE7, 0x87, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC,
  0x3C, 0xFE, 0x0F, 0x7F, 0x07, 0xBF, 0x81, 0xEF, 0xC0, 0xF7, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC7, 0xEF, 0xFF, 0x3F,
  0xF8, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E,
  0x78, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xE0,
  0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x1F, 0x1F, 0xF1, 0xFF, 0xDF, 0xFC, 0xF0, 0x27, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0xFF, 0xBF, 0xFC, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x7C,
  0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xF0, 0x03, 0xDC, 0x01, 0xE7,
  0x00, 0x79, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x38,
  0x01, 0xCE, 0x00, 0x77, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xEE, 0x03, 0xC0, 0x39, 0xC0,
  0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0x83, 0xF0, 0x38, 0x70, 0x77, 0x07,
  0x0E, 0x0E, 0xE1, 0xE1, 0xE1, 0xDC, 0x3C, 0x3C, 0x73, 0x87, 0x03, 0x8E,
  0x38, 0xE0, 0x71, 0xC7, 0x3C, 0x0E, 0x78, 0xE7, 0x81, 0xEE, 0x1C, 0xE0,
  0x1D, 0xC1, 0xDC, 0x03, 0xB8, 0x3B, 0x80, 0x76, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0x9E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x1C, 0x03,
  0xCF, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0x78,
  0x3C, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xC0, 0xF1, 0xE0, 0x78, 0xE0,
  0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0D, 0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x18,
  0x38, 0x71, 0xC0, 0xE7, 0x03, 0xB8, 0x07, 0xE0, 0x1C, 0xFF, 0xF0, 0xF8,
  0x78, 0x70, 0x70, 0x1F, 0xE1, 0xFF, 0x8E, 0x3E, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x7F, 0xEF, 0xFF, 0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x9F,
  0xBF, 0xDC, 0xFC, 0x60, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x7E, 0x3F, 0xFC, 0xFC, 0xFB, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xEF,
  0xFF, 0xBB, 0xFC, 0xE7, 0xE0, 0x0F, 0xF3, 0xFF, 0x3E, 0xE7, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x81, 0x3F,
  0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x71, 0xFD, 0xCF, 0xFF, 0x7E, 0xFD, 0xE0, 0xF7, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x78, 0x1D, 0xE0, 0xF7,
  0xFF, 0xCF, 0xF7, 0x1F, 0x9C, 0x0F, 0xE0, 0xFF, 0xC3, 0xC7, 0x9E, 0x0F,
  0x70, 0x3D, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x01, 0x3F, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x1F,
  0x61, 0xE0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF, 0xFC, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0x1F, 0xDC, 0xFF, 0xF7, 0xEF, 0xDE, 0x0F, 0x78,
  0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x81, 0xDE,
  0x0F, 0x7F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF7,
  0x07, 0xDF, 0xFE, 0x7F, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x7F, 0x3F, 0xFE, 0xFE, 0xFB, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xF6, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0x60, 0x00,
  0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xFB, 0xE7, 0x80, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFC, 0x3C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3C, 0xF0,
  0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xF3, 0xF9, 0xDF,
  0xEF, 0xFB, 0xF7, 0xFD, 0xF7, 0xC3, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07,
  0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70,
  0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03,
  0xFC, 0x0E, 0x07, 0x80, 0xE7, 0xF3, 0xBF, 0xEF, 0xEF, 0xBE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0, 0xF9,
  0xF3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E,
  0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00,
  0xE7, 0xE3, 0xBF, 0xCF, 0xCF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1E, 0xFF, 0xFB, 0xFF,
  0xCF, 0x7E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1F, 0xDC, 0xFF, 0xF7, 0xEF, 0xDE, 0x0F, 0x70, 0x1D,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x81, 0xDE, 0x0F,
  0x7F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xE7, 0xFB, 0xFF, 0xFF, 0xF0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x3F, 0xE7, 0xFE, 0x70, 0xEF, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x81,
  0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0xFB, 0xEF, 0xFE, 0x7F, 0x80,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0xFF, 0xBF, 0xE3, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xCF, 0xF1, 0xFC,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0x7F, 0xFD, 0xFF,
  0x73, 0xF9, 0xC0, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0x83,
  0xC7, 0x87, 0x07, 0x1E, 0x0E, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0x80,
  0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x1E, 0xE0,
  0xF8, 0x39, 0xE1, 0xF0, 0x73, 0xC3, 0x71, 0xE3, 0x8E, 0xE3, 0xC7, 0x1D,
  0xC7, 0x0F, 0x39, 0x8E, 0x1E, 0x63, 0xBC, 0x1D, 0xC7, 0x70, 0x3B, 0x8E,
  0xE0, 0x77, 0x0D, 0xC0, 0x7C, 0x1B, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x78, 0x78, 0xF1, 0xE0, 0xF3, 0xC0,
  0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x7B,
  0xC0, 0xF3, 0xC3, 0xC3, 0xCF, 0x07, 0xBE, 0x07, 0x80, 0xF0, 0x1E, 0xE0,
  0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x07, 0x1E, 0x0E, 0x38,
  0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x87, 0xC7, 0xE3, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x1F, 0x0F, 0x07, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xF0, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x3F, 0x07, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x81, 0xF0, 0x78, 0xFC, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC3, 0xE3, 0xE1, 0xE0, 0x3C, 0x07, 0xFE, 0x7F, 0xFF,
  0xE0, 0x7E,
};

const GFXglyph NotoSans_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 20, 8, 2, -20 },
  { 11, 9, 7, 13, 2, -20 },
  { 19, 16, 20, 18, 1, -20 },
  { 59, 14, 23, 16, 1, -21 },
  { 100, 22, 20, 25, 1, -20 },
  { 155, 20, 20, 21, 1, -20 },
  { 205, 3, 7, 7, 2, -20 },
  { 208, 7, 24, 9, 1, -20 },
  { 229, 7, 24, 9, 1, -20 },
  { 250, 13, 13, 15, 1, -21 },
  { 272, 14, 14, 16, 1, -17 },
  { 297, 5, 7, 8, 1, -3 },
  { 302, 7, 3, 9, 1, -9 },
  { 305, 4, 4, 8, 2, -4 },
  { 307, 11, 20, 11, 0, -20 },
  { 335, 14, 20, 16, 1, -20 },
  { 370, 9, 20, 16, 2, -20 },
  { 393, 14, 20, 16, 1, -20 },
  { 428, 14, 20, 16, 1, -20 },
  { 463, 15, 20, 16, 1, -20 },
  { 501, 13, 20, 16, 2, -20 },
  { 534, 14, 20, 16, 1, -20 },
  { 569, 14, 20, 16, 1, -20 },
  { 604, 14, 20, 16, 1, -20 },
  { 639, 14, 20, 16, 1, -20 },
  { 674, 4, 16, 8, 2, -16 },
  { 682, 5, 20, 8, 1, -16 },
  { 695, 14, 14, 16, 1, -17 },
  { 720, 14, 8, 16, 1, -14 },
  { 734, 14, 14, 16, 1, -17 },
  { 759, 12, 20, 13, 0, -20 },
  { 789, 23, 22, 25, 1, -20 },
  { 853, 19, 20, 19, 0, -20 },
  { 901, 15, 20, 18, 2, -20 },
  { 939, 15, 20, 18, 2, -20 },
  { 977, 17, 20, 21, 2, -20 },
  { 1020, 11, 20, 16, 3, -20 },
  { 1048, 11, 20, 15, 3, -20 },
  { 1076, 16, 20, 20, 2, -20 },
  { 1116, 16, 20, 21, 3, -20 },
  { 1156, 8, 20, 10, 1, -20 },
  { 1176, 8, 26, 9, -2, -20 },
  { 1202, 15, 20, 18, 3, -20 },
  { 1240, 12, 20, 15, 2, -20 },
  { 1270, 20, 20, 26, 3, -20 },
  { 1320, 17, 20, 22, 3, -20 },
  { 1363, 18, 20, 22, 2, -20 },
  { 1408, 14, 20, 17, 2, -20 },
  { 1443, 18, 25, 22, 2, -20 },
  { 1500, 16, 20, 18, 2, -20 },
  { 1540, 13, 20, 15, 1, -20 },
  { 1573, 15, 20, 16, 0, -20 },
  { 1611, 16, 20, 21, 2, -20 },
  { 1651, 18, 20, 18, 0, -20 },
  { 1696, 27, 20, 27, 0, -20 },
  { 1764, 18, 20, 18, 0, -20 },
  { 1809, 17, 20, 17, 0, -20 },
  { 1852, 14, 20, 16, 1, -20 },
  { 1887, 7, 24, 9, 2, -20 },
  { 1908, 11, 20, 11, 0, -20 },
  { 1936, 6, 24, 9, 1, -20 },
  { 1954, 14, 13, 16, 1, -20 },
  { 1977, 12, 1, 12, 0, 3 },
  { 1979, 7, 4, 9, 1, -21 },
  { 1983, 13, 15, 16, 1, -15 },
  { 2008, 14, 21, 18, 2, -21 },
  { 2045, 12, 15, 14, 1, -15 },
  { 2068, 14, 21, 18, 1, -21 },
  { 2105, 14, 15, 16, 1, -15 },
  { 2132, 12, 21, 10, 0, -21 },
  { 2164, 14, 22, 18, 1, -15 },
  { 2203, 14, 21, 18, 2, -21 },
  { 2240, 4, 21, 8, 2, -21 },
  { 2251, 7, 28, 8, -1, -21 },
  { 2276, 14, 21, 16, 2, -21 },
  { 2313, 4, 21, 8, 2, -21 },
  { 2324, 23, 15, 27, 2, -15 },
  { 2368, 14, 15, 18, 2, -15 },
  { 2395, 15, 15, 17, 1, -15 },
  { 2424, 14, 22, 18, 2, -15 },
  { 2463, 14, 22, 18, 1, -15 },
  { 2502, 10, 15, 12, 2, -15 },
  { 2521, 12, 15, 14, 1, -15 },
  { 2544, 10, 19, 11, 1, -19 },
  { 2568, 14, 15, 18, 2, -15 },
  { 2595, 15, 15, 15, 0, -15 },
  { 2624, 23, 15, 23, 0, -15 },
  { 2668, 15, 15, 16, 0, -15 },
  { 2697, 15, 22, 15, 0, -15 },
  { 2739, 12, 15, 14, 1, -15 },
  { 2762, 9, 24, 11, 1, -20 },
  { 2789, 3, 28, 15, 6, -21 },
  { 2800, 9, 24, 11, 1, -20 },
  { 2827, 14, 4, 16, 1, -12 },
};

const GFXfont NotoSans_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMIBOLD28PT7B_H_
