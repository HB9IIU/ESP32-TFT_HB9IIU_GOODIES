#ifndef _NOTOSANS_SEMIBOLD33PT7B_H_
#define _NOTOSANS_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0xEF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0x9C, 0x73, 0x8E, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1E, 0x00, 0xF1, 0xC0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x03, 0xC7, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xBE, 0xE7, 0x79, 0xC0, 0xF3, 0x81, 0xE7, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0x9E, 0x07, 0x3C, 0x0E, 0x7E, 0x1D, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x07,
  0xF0, 0x07, 0x01, 0xFF, 0x01, 0xE0, 0x38, 0xE0, 0x38, 0x0F, 0x1E, 0x0E,
  0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x38, 0x70, 0x07, 0x87, 0x1E, 0x00, 0xF0,
  0xE3, 0x80, 0x1E, 0x3C, 0xF0, 0x01, 0xC7, 0x9C, 0xFC, 0x38, 0xE7, 0xBF,
  0xC7, 0xFC, 0xE7, 0xBC, 0x7F, 0x39, 0xE3, 0x83, 0xCF, 0x38, 0x70, 0x01,
  0xC7, 0x0F, 0x00, 0x78, 0xE1, 0xE0, 0x0E, 0x1C, 0x3C, 0x03, 0xC3, 0x87,
  0x80, 0x70, 0x78, 0xE0, 0x1E, 0x0F, 0x1C, 0x03, 0x80, 0xFF, 0x80, 0xE0,
  0x1F, 0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x03, 0xC7, 0xFF, 0x0F, 0x9F, 0x1F, 0x1E,
  0x3C, 0x1F, 0x3C, 0x78, 0x1F, 0xF9, 0xF0, 0x1F, 0xE1, 0xE0, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x07, 0x87, 0x83, 0x83, 0xC1,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x41, 0x82, 0xF9, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C,
  0x3C, 0x0C, 0x30, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0xF7, 0x9E,
  0x79, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C,
  0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1E, 0x3E, 0x3E, 0x1F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF3, 0xFE, 0xFB, 0xFE,
  0x7B, 0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x07, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC3, 0x81, 0xE1, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xFE, 0x7F, 0xFE, 0x30,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x0F,
  0xF8, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E,
  0x07, 0x8F, 0x03, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xC0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xFF,
  0x83, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xFE, 0x0F, 0xDF, 0xFF, 0xBF,
  0xFE, 0x3F, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xFC,
  0x1D, 0xFF, 0x1E, 0xFF, 0xCF, 0xE1, 0xF7, 0xE0, 0x7B, 0xE0, 0x3D, 0xF0,
  0x1F, 0x78, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x81, 0xE3, 0xE1, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xF0, 0x3E, 0x3C, 0x1E, 0x1F, 0xBE, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x3E, 0xF8, 0x0F, 0x78, 0x03, 0xFC,
  0x03, 0xFF, 0x01, 0xE7, 0xC1, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x03, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xC0,
  0x3D, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDF,
  0x79, 0xE7, 0x9C, 0xF3, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x01,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x60, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x79, 0xE0, 0xFF, 0x8E, 0x70, 0xFF,
  0xE3, 0xBC, 0x3C, 0x38, 0x7E, 0x1E, 0x0E, 0x1F, 0x87, 0x03, 0x87, 0xE3,
  0xC1, 0xE1, 0xF8, 0xF0, 0x78, 0x7E, 0x3C, 0x1E, 0x1F, 0x8F, 0x07, 0x8E,
  0xE1, 0xC1, 0xE3, 0xB8, 0x79, 0xFD, 0xEE, 0x0F, 0xF7, 0xF3, 0xC1, 0xF8,
  0xF8, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x01, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xF0, 0x0F, 0x03, 0xC0,
  0x3C, 0x0F, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x0F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xE7, 0x87, 0xFB,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x07, 0xF7, 0xFF, 0xFB, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x01, 0x9F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x87, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0x01, 0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1F,
  0x78, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0x04, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00,
  0x3D, 0xF0, 0x07, 0x9F, 0x00, 0xF3, 0xF8, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFE, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7F, 0xFE, 0xFF, 0xBF, 0xC7, 0x80, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F,
  0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0x9F, 0x03, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C,
  0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00,
  0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xBF, 0xFC, 0x01, 0xDF, 0xEE, 0x01, 0xEF, 0xF7, 0x80,
  0xE7, 0xFB, 0xC0, 0x73, 0xFC, 0xE0, 0x79, 0xFE, 0x78, 0x38, 0xFF, 0x3C,
  0x1C, 0x7F, 0x8E, 0x1E, 0x3F, 0xC7, 0x8E, 0x1F, 0xE3, 0xCF, 0x0F, 0xF0,
  0xE7, 0x87, 0xF8, 0x7B, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xE0, 0x7F, 0x83, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x78, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x7C, 0x0F, 0xF7, 0xC0, 0xFF, 0x3E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1F, 0x0F, 0xF0, 0xF8, 0xFF, 0x07, 0x8F, 0xF0,
  0x7C, 0xFF, 0x03, 0xCF, 0xF0, 0x3E, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x03, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3F, 0x87, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFE, 0x80, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xE3,
  0xC0, 0x78, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0x07,
  0xE0, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0x80, 0x9E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xFF, 0x0F, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xF1,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x3D, 0xE0, 0x1F, 0x00, 0x7B, 0xC0,
  0x3F, 0x01, 0xF7, 0x80, 0x7E, 0x03, 0xCF, 0x81, 0xFC, 0x07, 0x8F, 0x03,
  0xB8, 0x0F, 0x1E, 0x07, 0x78, 0x3C, 0x3C, 0x1E, 0xF0, 0x78, 0x3C, 0x3C,
  0xE0, 0xF0, 0x78, 0x79, 0xE1, 0xE0, 0xF0, 0xE3, 0xC7, 0x81, 0xE3, 0xC7,
  0x8F, 0x01, 0xE7, 0x87, 0x1E, 0x03, 0xCE, 0x0F, 0x3C, 0x07, 0x9C, 0x1E,
  0xF0, 0x0F, 0x78, 0x3D, 0xE0, 0x0E, 0xF0, 0x3B, 0xC0, 0x1F, 0xC0, 0x77,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0x83, 0xC0,
  0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7B, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F,
  0x83, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8,
  0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1,
  0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3B,
  0x80, 0x39, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x0E, 0x0E, 0x07, 0x07,
  0x01, 0xC7, 0x80, 0xE3, 0x80, 0x3B, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x1C, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F, 0xFF,
  0x7F, 0xFF, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x3F,
  0x7F, 0xFF, 0x7F, 0xEF, 0x1F, 0xC7, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xF8,
  0xFF, 0xFC, 0xFC, 0x7E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E,
  0xFC, 0x3E, 0xFF, 0xFC, 0xEF, 0xFC, 0xE3, 0xF0, 0x07, 0xFC, 0x7F, 0xE3,
  0xFF, 0x9F, 0x8E, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE1, 0x9F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF,
  0x7E, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F,
  0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xC7, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x06,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3E,
  0x21, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0xC7, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x40, 0x1F, 0x7E, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x77, 0xFE, 0xF3, 0x00, 0x0F, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x07, 0x07, 0xC3,
  0xE0, 0xF0, 0x20, 0x00, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFF, 0xFB, 0xFD, 0xFC, 0xFC, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1,
  0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE3, 0xF0, 0x7E, 0x3B, 0xFF, 0x7F, 0xEF, 0xFF, 0xDF, 0xFB,
  0xF1, 0xFE, 0x3F, 0xF8, 0x3F, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01,
  0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF,
  0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80,
  0xF0, 0xE3, 0xF8, 0xEF, 0xFC, 0xEF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x87, 0xCF, 0x81, 0xF7,
  0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF8, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E,
  0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC,
  0xFF, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xCF, 0x3F, 0xEF,
  0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xE3, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0xFD, 0xE0, 0x6F, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3F,
  0x03, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x1E,
  0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x8F, 0xF1, 0xFE,
  0x1F, 0xC0, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xF7,
  0x1F, 0xC7, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x1F, 0x01, 0xEF, 0x03,
  0xE0, 0x3D, 0xE0, 0x7E, 0x0F, 0x3C, 0x1F, 0xC1, 0xE3, 0xC3, 0xB8, 0x3C,
  0x78, 0x77, 0x0F, 0x8F, 0x0E, 0xF1, 0xE1, 0xE3, 0xCE, 0x3C, 0x1E, 0x71,
  0xC7, 0x83, 0xCE, 0x3D, 0xE0, 0x79, 0xC7, 0xBC, 0x07, 0x78, 0x77, 0x80,
  0xFE, 0x0E, 0xF0, 0x1F, 0xC1, 0xDC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xCF, 0x03,
  0xE3, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0x3E, 0x03, 0xEF, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F,
  0xBC, 0x07, 0xC7, 0x81, 0xE1, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0xBE, 0x01,
  0xF0, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3C, 0x0F,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xB8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x05, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0xFC, 0x3F,
  0x87, 0xF0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE1, 0xFC, 0x3E, 0x07, 0xE0, 0xFE, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3F, 0x83, 0xF0, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x1F, 0x03, 0xF0, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0xC0, 0xF8, 0x3F, 0x0F,
  0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC3, 0xF8, 0x7E, 0x0F, 0x80, 0x7E, 0x03, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xF8, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 20, 24, 21, 1, -24 },
  { 89, 15, 27, 19, 2, -25 },
  { 140, 27, 24, 29, 1, -24 },
  { 221, 23, 24, 25, 1, -24 },
  { 290, 4, 9, 8, 2, -24 },
  { 295, 9, 29, 11, 1, -24 },
  { 328, 8, 29, 11, 1, -24 },
  { 357, 16, 15, 18, 1, -25 },
  { 387, 15, 16, 19, 2, -20 },
  { 417, 6, 8, 9, 1, -4 },
  { 423, 9, 4, 11, 1, -11 },
  { 428, 5, 5, 9, 2, -5 },
  { 432, 13, 24, 13, 0, -24 },
  { 471, 16, 24, 19, 1, -24 },
  { 519, 11, 24, 19, 2, -24 },
  { 552, 17, 24, 19, 1, -24 },
  { 603, 16, 24, 19, 1, -24 },
  { 651, 17, 24, 19, 1, -24 },
  { 702, 15, 24, 19, 2, -24 },
  { 747, 17, 24, 19, 1, -24 },
  { 798, 17, 24, 19, 1, -24 },
  { 849, 17, 24, 19, 1, -24 },
  { 900, 16, 24, 19, 1, -24 },
  { 948, 5, 18, 9, 2, -18 },
  { 960, 6, 22, 9, 1, -18 },
  { 977, 15, 17, 19, 2, -20 },
  { 1009, 15, 9, 19, 2, -16 },
  { 1026, 15, 17, 19, 2, -20 },
  { 1058, 14, 24, 15, 0, -24 },
  { 1100, 26, 27, 30, 2, -24 },
  { 1188, 22, 24, 22, 0, -24 },
  { 1254, 17, 24, 22, 3, -24 },
  { 1305, 18, 24, 21, 2, -24 },
  { 1359, 19, 24, 24, 3, -24 },
  { 1416, 13, 24, 18, 3, -24 },
  { 1455, 13, 24, 18, 3, -24 },
  { 1494, 19, 24, 24, 2, -24 },
  { 1551, 19, 24, 25, 3, -24 },
  { 1608, 10, 24, 12, 1, -24 },
  { 1638, 10, 31, 10, -3, -24 },
  { 1677, 18, 24, 21, 3, -24 },
  { 1731, 14, 24, 18, 3, -24 },
  { 1773, 25, 24, 31, 3, -24 },
  { 1848, 20, 24, 26, 3, -24 },
  { 1908, 22, 24, 26, 2, -24 },
  { 1974, 16, 24, 20, 3, -24 },
  { 2022, 22, 30, 26, 2, -24 },
  { 2105, 18, 24, 21, 3, -24 },
  { 2159, 15, 24, 18, 2, -24 },
  { 2204, 17, 24, 19, 1, -24 },
  { 2255, 19, 24, 25, 3, -24 },
  { 2312, 21, 24, 21, 0, -24 },
  { 2375, 31, 24, 31, 0, -24 },
  { 2468, 21, 24, 21, 0, -24 },
  { 2531, 20, 24, 20, 0, -24 },
  { 2591, 17, 24, 19, 1, -24 },
  { 2642, 8, 29, 11, 2, -24 },
  { 2671, 13, 24, 13, 0, -24 },
  { 2710, 7, 29, 11, 1, -24 },
  { 2736, 17, 15, 19, 1, -24 },
  { 2768, 14, 2, 14, 0, 3 },
  { 2772, 9, 5, 11, 1, -25 },
  { 2778, 16, 18, 19, 1, -18 },
  { 2814, 16, 25, 21, 3, -25 },
  { 2864, 14, 18, 17, 2, -18 },
  { 2896, 16, 25, 21, 2, -25 },
  { 2946, 16, 18, 19, 2, -18 },
  { 2982, 13, 25, 12, 1, -25 },
  { 3023, 16, 26, 21, 2, -18 },
  { 3075, 16, 25, 21, 3, -25 },
  { 3125, 5, 25, 9, 2, -25 },
  { 3141, 9, 33, 9, -2, -25 },
  { 3179, 16, 25, 19, 3, -25 },
  { 3229, 4, 25, 9, 3, -25 },
  { 3242, 26, 18, 32, 3, -18 },
  { 3301, 16, 18, 21, 3, -18 },
  { 3337, 17, 18, 20, 2, -18 },
  { 3376, 16, 26, 21, 3, -18 },
  { 3428, 16, 26, 21, 2, -18 },
  { 3480, 11, 18, 14, 3, -18 },
  { 3505, 13, 18, 16, 2, -18 },
  { 3535, 11, 22, 13, 1, -22 },
  { 3566, 16, 18, 21, 2, -18 },
  { 3602, 18, 18, 18, 0, -18 },
  { 3643, 27, 18, 27, 0, -18 },
  { 3704, 18, 18, 18, 0, -18 },
  { 3745, 18, 26, 18, 0, -18 },
  { 3804, 14, 18, 16, 1, -18 },
  { 3836, 11, 29, 13, 1, -24 },
  { 3876, 3, 33, 18, 8, -25 },
  { 3889, 11, 29, 13, 1, -24 },
  { 3929, 15, 5, 19, 2, -14 },
};

const GFXfont NotoSans_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMIBOLD33PT7B_H_
