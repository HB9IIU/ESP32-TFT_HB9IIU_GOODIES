#ifndef _NOTOSANS_SEMIBOLD18PT7B_H_
#define _NOTOSANS_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF2, 0x41, 0x7E, 0xCF, 0x3C, 0xF3, 0xCC, 0x0C, 0xC1,
  0x90, 0x32, 0x04, 0xC7, 0xFE, 0x33, 0x06, 0x60, 0xC8, 0xFF, 0xE2, 0x60,
  0xCC, 0x19, 0x83, 0x20, 0x08, 0x08, 0x7F, 0xFF, 0xC8, 0xC8, 0xF8, 0x3E,
  0x0F, 0x0B, 0x0B, 0xFF, 0xFE, 0x08, 0x08, 0x70, 0x63, 0x61, 0x8C, 0x8C,
  0x23, 0x20, 0x89, 0x83, 0x24, 0xED, 0xB7, 0xDD, 0xB3, 0x06, 0xCC, 0x33,
  0x30, 0xCC, 0xC6, 0x1B, 0x30, 0x78, 0x3E, 0x07, 0xF0, 0x63, 0x06, 0x30,
  0x76, 0x03, 0xC0, 0x7C, 0x7E, 0xE6, 0xC7, 0x6C, 0x3C, 0xE1, 0xCF, 0xFE,
  0x7E, 0x70, 0xFF, 0xC0, 0x36, 0x6E, 0xCC, 0xCC, 0xCC, 0xCC, 0xE6, 0x63,
  0xCC, 0x66, 0x33, 0x33, 0x33, 0x33, 0x66, 0xCC, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x3C, 0x3C, 0x66, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0xFB, 0x60, 0xFF, 0x5F, 0x80, 0x06, 0x1C, 0x30, 0x61, 0x83,
  0x06, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x00, 0x3C, 0x3F, 0x39, 0xD8, 0x6C,
  0x36, 0x1F, 0x0F, 0x87, 0xC3, 0x61, 0xB8, 0xCF, 0xC3, 0xE0, 0x0C, 0xF7,
  0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0x7F, 0xB0, 0xC0,
  0x60, 0x30, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1F, 0xFF, 0xF8, 0x7E,
  0xFF, 0x43, 0x03, 0x03, 0x3E, 0x3C, 0x07, 0x03, 0x03, 0x83, 0xFF, 0xFE,
  0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C, 0xFF, 0xFF,
  0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x7F, 0x60, 0xE0, 0xE0, 0xFE, 0xFF,
  0x03, 0x03, 0x03, 0x83, 0xFF, 0xFC, 0x1F, 0x1F, 0x98, 0x1C, 0x0C, 0x06,
  0xF3, 0xFD, 0x86, 0xC3, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00,
  0x3E, 0x3F, 0xB0, 0xD8, 0x6E, 0x73, 0xF0, 0xF0, 0xCE, 0xC3, 0x61, 0xF0,
  0xDF, 0xE7, 0xE0, 0x3C, 0x3F, 0x31, 0xD8, 0x6C, 0x36, 0x1F, 0x9E, 0xFE,
  0x03, 0x01, 0x81, 0xCF, 0xC7, 0x80, 0xFF, 0x00, 0x02, 0xFC, 0xFD, 0x00,
  0x00, 0xFB, 0x60, 0x01, 0x07, 0x1E, 0x78, 0xC0, 0xF0, 0x1E, 0x07, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x0F, 0x3C,
  0xE0, 0x80, 0x7C, 0xFE, 0x43, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x10, 0x00,
  0x10, 0x38, 0x38, 0x07, 0xC0, 0x7F, 0xC3, 0x01, 0x98, 0x43, 0x47, 0xCF,
  0x31, 0x1C, 0x84, 0x76, 0x31, 0xC8, 0xCF, 0x37, 0xEC, 0x73, 0x98, 0x00,
  0x30, 0x20, 0x7F, 0x80, 0x20, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xF8,
  0x19, 0x81, 0x98, 0x39, 0xC3, 0x0C, 0x3F, 0xC7, 0xFE, 0x60, 0x66, 0x07,
  0xE0, 0x70, 0xFC, 0x7F, 0xB0, 0xD8, 0x7C, 0x37, 0xFB, 0xF9, 0x86, 0xC3,
  0xE1, 0xF0, 0xFF, 0xEF, 0xE0, 0x1F, 0x8F, 0xF7, 0x09, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x3F,
  0xCC, 0x3B, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x3B,
  0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83,
  0x06, 0x0C, 0x00, 0x0F, 0xE7, 0xF9, 0xC1, 0x30, 0x0E, 0x01, 0xC0, 0x30,
  0xFF, 0x1F, 0xE0, 0xFC, 0x1D, 0xC3, 0x9F, 0xF1, 0xFE, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xC0, 0xFF, 0xD8, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFF, 0x80, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xFE, 0xC0, 0xC1, 0xF0,
  0xCC, 0x73, 0x38, 0xDC, 0x36, 0x0F, 0x83, 0xF0, 0xCE, 0x31, 0x8C, 0x73,
  0x0E, 0xC1, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xFF, 0xE0, 0xE0, 0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x0D, 0xEC,
  0x6F, 0x63, 0x7B, 0x33, 0xCD, 0x9E, 0x68, 0xF3, 0xC7, 0x8E, 0x3C, 0x61,
  0x80, 0xE0, 0x7C, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0xB8, 0xF3, 0x1E, 0x73,
  0xC7, 0x78, 0x6F, 0x0F, 0xE0, 0xFC, 0x1E, 0x1F, 0x83, 0xFC, 0x70, 0xE6,
  0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0x70, 0xE3,
  0xFE, 0x1F, 0x80, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFF, 0xFC, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x7E,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0x70, 0xE3, 0xFE, 0x1F, 0x80,
  0x18, 0x00, 0xC0, 0x0F, 0xFC, 0x7F, 0xB1, 0xD8, 0x6C, 0x36, 0x3B, 0xF9,
  0xF8, 0xCE, 0x63, 0x31, 0xD8, 0x7C, 0x18, 0x3E, 0x7F, 0xE1, 0xC0, 0xE0,
  0x70, 0x3C, 0x0F, 0x07, 0x03, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7E, 0x19, 0xFE, 0x3F, 0x00, 0xC0, 0x7C, 0x0D, 0x83, 0xB0, 0x63,
  0x0C, 0x63, 0x8C, 0x60, 0xCC, 0x1B, 0x03, 0x60, 0x3C, 0x07, 0x00, 0xE0,
  0xC1, 0xC1, 0xF0, 0xE1, 0xD8, 0x70, 0xCC, 0x2C, 0x66, 0x36, 0x33, 0x9B,
  0x38, 0xCD, 0x98, 0x6C, 0x6C, 0x36, 0x36, 0x0F, 0x1B, 0x07, 0x87, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xEE, 0x18, 0xC7, 0x1C, 0xC1, 0xF0, 0x1E,
  0x03, 0x80, 0x78, 0x1B, 0x07, 0x30, 0xC7, 0x38, 0x6E, 0x0E, 0xE0, 0xEC,
  0x19, 0xC7, 0x18, 0xC3, 0xB0, 0x36, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xFF, 0xC0, 0xC1, 0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F,
  0xFF, 0x18, 0x0C, 0x0F, 0x04, 0x86, 0x63, 0x13, 0x0D, 0x83, 0xFF, 0xE6,
  0x30, 0x3E, 0x7F, 0x43, 0x03, 0x3F, 0xF3, 0xC3, 0xC3, 0xFF, 0x7B, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7F, 0xFE, 0xF8, 0x3F, 0x7E, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7E,
  0x3E, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0xFF, 0x8F, 0x87, 0xC1, 0xE0,
  0xF0, 0x7C, 0x77, 0xF9, 0xEC, 0x3E, 0x3F, 0xB8, 0xD8, 0x7F, 0xFF, 0xFF,
  0x01, 0xC0, 0x7F, 0x1F, 0x80, 0x0E, 0x7C, 0xC1, 0x87, 0xFF, 0xCC, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x3D, 0xBF, 0xF8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0xC7, 0x7F, 0x9E, 0xC0, 0x60, 0x77, 0xF3, 0xF0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0xF7, 0xFF, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0C, 0x5D, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x11, 0xC6, 0x03, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xF7, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE3, 0xB8, 0xCE, 0x63, 0xB0, 0xF8, 0x3F, 0x0E, 0xE3, 0x9C, 0xE3,
  0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCE, 0x3D, 0xFE, 0xFF,
  0x8E, 0x3F, 0x1C, 0x3E, 0x18, 0x7C, 0x30, 0xF8, 0x61, 0xF0, 0xC3, 0xE1,
  0x87, 0xC3, 0x0C, 0xCF, 0x6F, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xC0, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC7,
  0x7F, 0x1F, 0x00, 0xCE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xFF, 0xFF, 0xB8, 0x1C, 0x0E, 0x07, 0x00, 0x3D, 0xBF, 0xF8, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x9E, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xCF,
  0xBB, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7D, 0xFF, 0x07, 0x07,
  0x87, 0xC3, 0x83, 0xFF, 0xF8, 0x30, 0x61, 0xFF, 0xF3, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xF8, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC7, 0x7F, 0xBE, 0xC0, 0xC1, 0xF8, 0x66, 0x19, 0x8E, 0x33, 0x0C, 0xC3,
  0x60, 0x78, 0x1E, 0x03, 0x00, 0xE3, 0x8E, 0xC7, 0x19, 0x8A, 0x33, 0x36,
  0x67, 0x6D, 0xC6, 0xDB, 0x0D, 0x16, 0x1E, 0x3C, 0x1C, 0x70, 0x38, 0xE0,
  0xE1, 0xDC, 0xE3, 0x30, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xCC, 0x73, 0xB8,
  0x70, 0xE1, 0xD8, 0x66, 0x19, 0xCE, 0x33, 0x0C, 0xC1, 0xF0, 0x78, 0x1E,
  0x03, 0x00, 0xC0, 0x70, 0xF8, 0x3C, 0x00, 0xFF, 0xFC, 0x30, 0xE1, 0x86,
  0x1C, 0x70, 0xFF, 0xFC, 0x0C, 0x71, 0x86, 0x18, 0x63, 0xBC, 0xF0, 0xE1,
  0x86, 0x18, 0x61, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x86, 0x18,
  0x61, 0x87, 0x0F, 0x3D, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0x61, 0xFF, 0x8F,
};

const GFXglyph NotoSans_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 6, 5, 8, 1, -13 },
  { 10, 11, 13, 12, 0, -13 },
  { 28, 8, 15, 10, 1, -14 },
  { 43, 14, 13, 16, 1, -13 },
  { 66, 12, 13, 13, 1, -13 },
  { 86, 2, 5, 5, 1, -13 },
  { 88, 4, 16, 6, 1, -13 },
  { 96, 4, 16, 6, 1, -13 },
  { 104, 8, 9, 10, 1, -14 },
  { 113, 8, 9, 10, 1, -11 },
  { 122, 3, 4, 5, 1, -2 },
  { 124, 4, 2, 6, 1, -6 },
  { 125, 3, 3, 5, 1, -3 },
  { 127, 7, 13, 7, 0, -13 },
  { 139, 9, 13, 10, 1, -13 },
  { 154, 6, 13, 10, 1, -13 },
  { 164, 9, 13, 10, 1, -13 },
  { 179, 8, 13, 10, 1, -13 },
  { 192, 10, 13, 10, 0, -13 },
  { 209, 8, 13, 10, 1, -13 },
  { 222, 9, 13, 10, 1, -13 },
  { 237, 9, 13, 10, 1, -13 },
  { 252, 9, 13, 10, 1, -13 },
  { 267, 9, 13, 10, 1, -13 },
  { 282, 3, 10, 5, 1, -10 },
  { 286, 3, 12, 5, 1, -10 },
  { 291, 8, 9, 10, 1, -11 },
  { 300, 8, 5, 10, 1, -9 },
  { 305, 8, 9, 10, 1, -11 },
  { 314, 8, 13, 8, 0, -13 },
  { 327, 14, 15, 16, 1, -13 },
  { 354, 12, 13, 12, 0, -13 },
  { 374, 9, 13, 12, 2, -13 },
  { 389, 10, 13, 11, 1, -13 },
  { 406, 10, 13, 13, 2, -13 },
  { 423, 7, 13, 10, 2, -13 },
  { 435, 7, 13, 10, 2, -13 },
  { 447, 11, 13, 13, 1, -13 },
  { 465, 10, 13, 14, 2, -13 },
  { 482, 5, 13, 7, 1, -13 },
  { 491, 5, 17, 6, -1, -13 },
  { 502, 10, 13, 12, 2, -13 },
  { 519, 7, 13, 10, 2, -13 },
  { 531, 13, 13, 17, 2, -13 },
  { 553, 11, 13, 14, 2, -13 },
  { 571, 12, 13, 14, 1, -13 },
  { 591, 8, 13, 11, 2, -13 },
  { 604, 12, 16, 14, 1, -13 },
  { 628, 9, 13, 12, 2, -13 },
  { 643, 8, 13, 10, 1, -13 },
  { 656, 10, 13, 10, 0, -13 },
  { 673, 10, 13, 13, 2, -13 },
  { 690, 11, 13, 11, 0, -13 },
  { 708, 17, 13, 17, 0, -13 },
  { 736, 11, 13, 11, 0, -13 },
  { 754, 11, 13, 11, 0, -13 },
  { 772, 9, 13, 10, 1, -13 },
  { 787, 4, 16, 6, 1, -13 },
  { 795, 7, 13, 7, 0, -13 },
  { 807, 5, 16, 6, 0, -13 },
  { 817, 9, 8, 10, 1, -13 },
  { 826, 8, 1, 8, 0, 2 },
  { 827, 4, 3, 6, 1, -14 },
  { 829, 8, 10, 11, 1, -10 },
  { 839, 9, 14, 11, 1, -14 },
  { 855, 8, 10, 9, 1, -10 },
  { 865, 9, 14, 11, 1, -14 },
  { 881, 9, 10, 11, 1, -10 },
  { 893, 7, 14, 7, 0, -14 },
  { 906, 9, 14, 11, 1, -10 },
  { 922, 9, 14, 11, 1, -14 },
  { 938, 3, 14, 5, 1, -14 },
  { 944, 5, 18, 5, -1, -14 },
  { 956, 10, 14, 11, 1, -14 },
  { 974, 3, 14, 5, 1, -14 },
  { 980, 15, 10, 17, 1, -10 },
  { 999, 9, 10, 11, 1, -10 },
  { 1011, 9, 10, 11, 1, -10 },
  { 1023, 9, 14, 11, 1, -10 },
  { 1039, 9, 14, 11, 1, -10 },
  { 1055, 7, 10, 8, 1, -10 },
  { 1064, 7, 10, 9, 1, -10 },
  { 1073, 7, 12, 7, 0, -12 },
  { 1084, 9, 10, 11, 1, -10 },
  { 1096, 10, 10, 10, 0, -10 },
  { 1109, 15, 10, 15, 0, -10 },
  { 1128, 10, 10, 10, 0, -10 },
  { 1141, 10, 14, 10, 0, -10 },
  { 1159, 7, 10, 9, 1, -10 },
  { 1168, 6, 16, 7, 0, -13 },
  { 1180, 2, 18, 10, 4, -14 },
  { 1185, 6, 16, 7, 1, -13 },
  { 1197, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMIBOLD18PT7B_H_
