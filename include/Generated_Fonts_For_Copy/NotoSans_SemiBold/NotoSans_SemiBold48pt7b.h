#ifndef _NOTOSANS_SEMIBOLD48PT7B_H_
#define _NOTOSANS_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x40, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x78, 0x3E,
  0x78, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0xF9, 0xF8, 0xFC, 0x70, 0x33, 0xF8, 0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0xE3,
  0x80, 0x0F, 0xC7, 0x00, 0x1F, 0xEE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0E, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x38, 0x7E,
  0x00, 0x70, 0xFC, 0x00, 0xE1, 0xFE, 0x01, 0xC3, 0xFF, 0xC3, 0x9F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x3E, 0x00,
  0x7E, 0xFC, 0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0x0F,
  0x83, 0xE3, 0xE1, 0xF8, 0x3E, 0x0F, 0x8F, 0x8F, 0xF8, 0x7C, 0x7E, 0x7C,
  0x7F, 0xF1, 0xFB, 0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0xCF, 0x8F, 0x8F, 0x8F,
  0xFE, 0x3E, 0x7C, 0x1E, 0x1F, 0xF1, 0xF1, 0xF0, 0x7C, 0x1F, 0x0F, 0x87,
  0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x3F,
  0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0xF8, 0x07,
  0xF0, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x9F, 0xE0, 0x7E, 0x1F, 0xC3, 0xFC,
  0x3F, 0x87, 0xE0, 0x7F, 0x8F, 0xC3, 0xF8, 0x0F, 0xF7, 0xF0, 0xFE, 0x01,
  0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFE,
  0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x38,
  0x1E, 0x03, 0x7E, 0x3C, 0x7E, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x10, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x70, 0x38, 0x00, 0x20, 0x40, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0x7E, 0x3F, 0x3C, 0x3F, 0x38, 0x3F, 0x10, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xCF, 0xFC, 0x3E, 0x01, 0xFC, 0x38, 0x00, 0xFC, 0x10, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x8E, 0x00,
  0x7F, 0x08, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x60,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0xE0, 0x07, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xF8, 0x08, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x3F, 0x80, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x07,
  0xE3, 0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xF8, 0x7F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xFD, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFD, 0xF1, 0xFF, 0xF3, 0xE1, 0xFF, 0xCF, 0xC0, 0x7C,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x0E, 0x3F, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0,
  0x80, 0x04, 0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0x87, 0xF8,
  0xE0, 0x0F, 0xE4, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x3E, 0x01, 0xFF, 0xC0, 0xF0, 0xF8, 0x0F, 0xFF, 0xE1,
  0xF1, 0xF0, 0x3F, 0xFF, 0x83, 0xE3, 0xC0, 0xFF, 0xBF, 0x03, 0xCF, 0x83,
  0xF0, 0x1E, 0x07, 0x9F, 0x07, 0xC0, 0x3C, 0x0F, 0xBC, 0x0F, 0x80, 0x78,
  0x1F, 0x78, 0x3E, 0x01, 0xF0, 0x3E, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0xE0,
  0xF8, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0x1F,
  0x03, 0xDF, 0x07, 0xC0, 0x3E, 0x07, 0x9E, 0x0F, 0x80, 0xFC, 0x1F, 0x3C,
  0x0F, 0x81, 0xF8, 0x3C, 0x78, 0x1F, 0x8F, 0xF8, 0xF8, 0xF8, 0x1F, 0xFE,
  0xFF, 0xE1, 0xF0, 0x3F, 0xF8, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xF0, 0x07, 0xFB,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xC0, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0x00, 0x30, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8,
  0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF9, 0xFE, 0x1F, 0xF0, 0x00, 0xC1,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0xC0, 0x03, 0xF1, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0x00, 0x07,
  0xDF, 0xFD, 0xF0, 0x00, 0x7D, 0xFF, 0xDF, 0x00, 0x0F, 0xBF, 0xFD, 0xF8,
  0x00, 0xFB, 0xFF, 0xCF, 0x80, 0x1F, 0xBF, 0xFC, 0xF8, 0x01, 0xF3, 0xFF,
  0xCF, 0xC0, 0x1F, 0x3F, 0xFC, 0x7C, 0x03, 0xF3, 0xFF, 0xC7, 0xC0, 0x3E,
  0x3F, 0xFC, 0x7E, 0x03, 0xE3, 0xFF, 0xC3, 0xE0, 0x7C, 0x3F, 0xFC, 0x3E,
  0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0x7C, 0x3F, 0xFC, 0x1F, 0x0F, 0x83, 0xFF,
  0xC1, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F, 0x8F, 0x83, 0xFF, 0xC0, 0xF9, 0xF0,
  0x3F, 0xFC, 0x0F, 0x9F, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0xFF, 0xF7, 0xF0, 0x03, 0xFF,
  0xCF, 0xE0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0xFC, 0x7F, 0x00, 0xFF, 0xF0,
  0xFC, 0x03, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0x01, 0xFC,
  0x3F, 0xFC, 0x03, 0xF8, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xC0, 0x1F, 0xCF,
  0xFF, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x03,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F, 0xE7, 0xF0, 0x03, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE7, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xC3, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x7F, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0x8F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x07, 0xC1,
  0xF8, 0x7C, 0x1F, 0x80, 0x1F, 0x87, 0xC1, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x00, 0x3F, 0x3E, 0x01,
  0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x1F,
  0x7E, 0x00, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03,
  0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x0F, 0xF0, 0xC0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0x7E,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7C,
  0xFF, 0xF8, 0xF0, 0xFF, 0x83, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x04, 0x00,
  0xFC, 0x7F, 0xC0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE7, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0,
  0xF9, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x00,
  0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x18, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x3F, 0x03,
  0xFE, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xF7, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0xFF, 0x3F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x9F, 0x07,
  0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x1F,
  0xF0, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xE1, 0x83, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x1F,
  0x07, 0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF,
  0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF,
  0x3F, 0xE7, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF,
  0x03, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x30, 0x00, 0xFE, 0x3F, 0x87, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x08, 0x03, 0xF1, 0xFF, 0x87, 0xE7,
  0xFF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x7F, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x3C,
  0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xFB, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFE, 0x03,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE,
  0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x04, 0x03, 0xE1, 0xFF, 0x01,
  0xFF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFF, 0x3E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x04, 0x01, 0xF0, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xE3, 0xF0, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0xF8,
  0x7F, 0xC0, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xE7, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF,
  0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFD,
  0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x1F, 0x07,
  0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F,
  0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F,
  0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x3F, 0x03,
  0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x04, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xE0, 0x3C, 0xFC,
  0x00, 0x4F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFE, 0x70, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xBF, 0x3F, 0xFE, 0x3E,
  0x1F, 0xF8, 0x7C, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFE,
  0x00, 0xFD, 0xF8, 0x03, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0xF0, 0x1F, 0x8F, 0xC0, 0x7B,
  0xE0, 0x3E, 0x0F, 0xC0, 0xF3, 0xC0, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF8,
  0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7E, 0x0F, 0x9F, 0x07, 0xC0, 0x7E, 0x3E,
  0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0xF9, 0xF8, 0x03, 0xE7, 0xC1, 0xF3, 0xF0, 0x07, 0xEF,
  0x81, 0xF7, 0xE0, 0x0F, 0xDF, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x07, 0xDF,
  0x00, 0x1F, 0x78, 0x07, 0xBE, 0x00, 0x3E, 0xF0, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xEF,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x47, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x40,
  0x00, 0xF0,
};

const GFXglyph NotoSans_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 35, 13, 3, -34 },
  { 32, 16, 12, 22, 3, -34 },
  { 56, 29, 34, 31, 1, -34 },
  { 180, 23, 39, 27, 2, -36 },
  { 293, 38, 35, 42, 2, -35 },
  { 460, 34, 35, 36, 2, -35 },
  { 609, 6, 12, 12, 3, -34 },
  { 618, 12, 42, 16, 2, -34 },
  { 681, 13, 42, 16, 1, -34 },
  { 750, 23, 22, 26, 2, -36 },
  { 814, 23, 24, 27, 2, -29 },
  { 883, 8, 12, 13, 2, -6 },
  { 895, 12, 5, 15, 2, -15 },
  { 903, 7, 8, 13, 3, -7 },
  { 910, 19, 34, 19, 0, -34 },
  { 991, 23, 35, 27, 2, -35 },
  { 1092, 16, 34, 27, 3, -34 },
  { 1160, 24, 35, 27, 2, -35 },
  { 1265, 23, 35, 27, 2, -35 },
  { 1366, 26, 34, 27, 1, -34 },
  { 1477, 22, 34, 27, 3, -34 },
  { 1571, 24, 35, 27, 2, -35 },
  { 1676, 24, 34, 27, 2, -34 },
  { 1778, 23, 35, 27, 2, -35 },
  { 1879, 23, 35, 27, 2, -35 },
  { 1980, 7, 28, 13, 3, -27 },
  { 2005, 9, 33, 13, 1, -27 },
  { 2043, 23, 25, 27, 2, -30 },
  { 2115, 23, 14, 27, 2, -24 },
  { 2156, 23, 25, 27, 2, -30 },
  { 2228, 21, 36, 22, 0, -35 },
  { 2323, 39, 38, 43, 2, -34 },
  { 2509, 32, 34, 32, 0, -34 },
  { 2645, 25, 34, 32, 4, -34 },
  { 2752, 26, 35, 31, 3, -35 },
  { 2866, 28, 34, 35, 4, -34 },
  { 2985, 20, 34, 27, 4, -34 },
  { 3070, 20, 34, 26, 4, -34 },
  { 3155, 28, 35, 35, 3, -35 },
  { 3278, 28, 34, 36, 4, -34 },
  { 3397, 14, 34, 18, 2, -34 },
  { 3457, 15, 44, 15, -4, -34 },
  { 3540, 27, 34, 31, 4, -34 },
  { 3655, 21, 34, 26, 4, -34 },
  { 3745, 36, 34, 45, 4, -34 },
  { 3898, 30, 34, 38, 4, -34 },
  { 4026, 32, 35, 38, 3, -35 },
  { 4166, 23, 34, 30, 4, -34 },
  { 4264, 32, 43, 38, 3, -35 },
  { 4436, 27, 34, 31, 4, -34 },
  { 4551, 22, 35, 26, 2, -35 },
  { 4648, 26, 34, 27, 1, -34 },
  { 4759, 28, 34, 36, 4, -34 },
  { 4878, 30, 34, 30, 0, -34 },
  { 5006, 46, 34, 46, 0, -34 },
  { 5202, 30, 34, 31, 0, -34 },
  { 5330, 29, 34, 29, 0, -34 },
  { 5454, 25, 34, 28, 1, -34 },
  { 5561, 11, 42, 16, 4, -34 },
  { 5619, 19, 34, 19, 0, -34 },
  { 5700, 11, 42, 16, 1, -34 },
  { 5758, 25, 22, 27, 1, -34 },
  { 5827, 20, 3, 20, 0, 4 },
  { 5835, 12, 8, 16, 2, -37 },
  { 5847, 22, 27, 28, 2, -27 },
  { 5922, 24, 36, 30, 4, -36 },
  { 6030, 21, 27, 24, 2, -27 },
  { 6101, 24, 36, 30, 2, -36 },
  { 6209, 24, 27, 28, 2, -27 },
  { 6290, 19, 37, 18, 1, -37 },
  { 6378, 24, 39, 30, 2, -27 },
  { 6495, 23, 36, 31, 4, -36 },
  { 6599, 7, 36, 14, 3, -36 },
  { 6631, 13, 48, 14, -3, -36 },
  { 6709, 24, 36, 28, 4, -36 },
  { 6817, 6, 36, 14, 4, -36 },
  { 6844, 38, 27, 46, 4, -27 },
  { 6973, 23, 27, 31, 4, -27 },
  { 7051, 25, 27, 30, 2, -27 },
  { 7136, 24, 39, 30, 4, -27 },
  { 7253, 24, 39, 30, 2, -27 },
  { 7370, 16, 27, 21, 4, -27 },
  { 7424, 20, 27, 24, 2, -27 },
  { 7492, 17, 32, 19, 1, -32 },
  { 7560, 23, 26, 31, 4, -26 },
  { 7635, 26, 26, 26, 0, -26 },
  { 7720, 39, 26, 40, 0, -26 },
  { 7847, 26, 26, 27, 0, -26 },
  { 7932, 26, 38, 26, 0, -26 },
  { 8056, 20, 26, 23, 2, -26 },
  { 8121, 16, 42, 19, 1, -34 },
  { 8205, 5, 47, 26, 11, -36 },
  { 8235, 16, 42, 19, 2, -34 },
  { 8319, 23, 8, 27, 2, -21 },
};

const GFXfont NotoSans_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMIBOLD48PT7B_H_
