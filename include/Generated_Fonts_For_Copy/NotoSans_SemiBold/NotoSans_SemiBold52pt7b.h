#ifndef _NOTOSANS_SEMIBOLD52PT7B_H_
#define _NOTOSANS_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xEF, 0xC3, 0xF7,
  0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F,
  0xDF, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0x3C,
  0x7C, 0xFE, 0x3C, 0x0C, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C,
  0x00, 0xFE, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFF, 0x00, 0x3C,
  0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x80, 0x3C,
  0x7F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x3F, 0x07,
  0x80, 0xFC, 0x1F, 0x0F, 0x8F, 0xFC, 0x1F, 0x07, 0xC7, 0xC7, 0xFF, 0x87,
  0xE3, 0xF1, 0xF1, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x7E, 0x3E, 0x1F, 0x87, 0xFF, 0x1F, 0x1F, 0x83, 0xE0, 0xFF, 0x8F, 0xC7,
  0xC0, 0xF8, 0x07, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x00,
  0x0F, 0x81, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x87, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xF7,
  0xF8, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF0,
  0x7F, 0x01, 0xFE, 0x3F, 0x83, 0xF8, 0x07, 0xFB, 0xF8, 0x3F, 0x80, 0x1F,
  0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0x80, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xC1, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01,
  0x00, 0x78, 0x02, 0xF8, 0x3C, 0x0F, 0x7F, 0x9E, 0x7F, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x1E,
  0x07, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F,
  0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38,
  0x3F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0xF8, 0x01, 0xFC, 0x18, 0x00, 0x7F, 0x04, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xFC, 0x30, 0x00, 0xFE, 0x10, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x18, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0xC0, 0x01, 0xFE, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0xFF, 0xE0, 0x7E, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0x8F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0x0F,
  0xEF, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFC, 0xFF, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF,
  0xC0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFD, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xF7, 0xE0, 0xFF, 0xF9, 0xF8, 0x1F, 0xFC, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x1C, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFC,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0x8F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0x80, 0x7F, 0x18, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0x00, 0x1F, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F,
  0xC7, 0xC0, 0x3F, 0xFF, 0x83, 0xE7, 0xE0, 0x7F, 0xFF, 0xC1, 0xF3, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7D, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0xF0, 0x3F, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xFC, 0x1F, 0x80, 0x3E, 0x07,
  0xFE, 0x0F, 0xC0, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0x0F, 0x81, 0xFF, 0x83,
  0xE0, 0x0F, 0xC0, 0xFF, 0xC1, 0xF0, 0x07, 0xE0, 0x7F, 0xE0, 0xF8, 0x03,
  0xF0, 0x3F, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0xF8, 0x3F, 0x01, 0xFC, 0x1F,
  0x7C, 0x0F, 0x80, 0xFE, 0x0F, 0xBE, 0x07, 0xE0, 0xFF, 0x0F, 0x9F, 0x03,
  0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0xF9, 0xFF, 0xC3, 0xE0, 0x3F, 0xF8,
  0xFF, 0xC1, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x07,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xF8, 0x07,
  0xFF, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xDF,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x8F, 0xC0, 0x3F, 0xF9, 0xF8, 0x00, 0xFF, 0xBF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xBF, 0x00,
  0x1F, 0xF7, 0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0x83,
  0xFE, 0x00, 0x0C, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x04, 0x0F, 0xFE, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0x0F, 0xC0, 0x07, 0xFE, 0x3F, 0x00,
  0x07, 0xFC, 0xFC, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0x7F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7F, 0xBF, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0xFF,
  0x8F, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x3E, 0x0F, 0xFC,
  0x00, 0x08, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x7F, 0x0F,
  0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x07, 0xFB, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x0C, 0x00, 0xFC, 0x00,
  0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x07, 0xF8, 0x1F,
  0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x03,
  0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC3, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0x81, 0xFE,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x83, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0xC7, 0xE0, 0x00,
  0xFE, 0x3F, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0xFB, 0xF0,
  0x00, 0x3F, 0xFF, 0xFB, 0xE0, 0x00, 0x7D, 0xFF, 0xF7, 0xE0, 0x00, 0xFB,
  0xFF, 0xEF, 0xC0, 0x03, 0xF7, 0xFF, 0xCF, 0x80, 0x07, 0xCF, 0xFF, 0x9F,
  0x80, 0x1F, 0x9F, 0xFF, 0x3F, 0x00, 0x3F, 0x3F, 0xFE, 0x3E, 0x00, 0x7C,
  0x7F, 0xFC, 0x7E, 0x01, 0xF8, 0xFF, 0xF8, 0xFC, 0x03, 0xF1, 0xFF, 0xF0,
  0xF8, 0x07, 0xC3, 0xFF, 0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xC3, 0xF0, 0x3F,
  0x0F, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xFF, 0x07, 0xE1, 0xF8, 0x3F, 0xFE,
  0x0F, 0xC3, 0xE0, 0x7F, 0xFC, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x1F, 0x9F,
  0x81, 0xFF, 0xF0, 0x3F, 0x3E, 0x03, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x7F, 0xF3, 0xF8, 0x00, 0xFF, 0xE7,
  0xF0, 0x01, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFF, 0x0F, 0xE0, 0x1F, 0xFE, 0x1F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xC0, 0x7F, 0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x3F,
  0x83, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0x80, 0x7F, 0x0F, 0xFF, 0x00, 0xFF,
  0x0F, 0xFE, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0xFE, 0x3F, 0xF8, 0x01, 0xFE,
  0x7F, 0xF0, 0x01, 0xFC, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xC0, 0x03, 0xFB,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xE0, 0xFF, 0xF3, 0xF0, 0x07, 0xFD, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0xFE, 0xFC, 0x01, 0xFF, 0x7E, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC0, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xEF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xC0, 0x7C, 0x7F, 0x80, 0x0C, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xFE, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xBF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xBF, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xDF, 0x80, 0x3F,
  0x83, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF3, 0xE0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3E, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x00, 0xFE, 0x1F, 0x81, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0x0F, 0xF8, 0x18, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F,
  0xBF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xEF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xCF, 0xFF, 0xE7, 0xE3, 0xFF, 0xE3, 0xF0, 0xFF,
  0xC0, 0xF8, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x3F, 0xF0, 0x3F,
  0xBF, 0xFE, 0x0F, 0xDF, 0xFF, 0xC3, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0xEF, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0x83,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFC, 0x03, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x9F, 0xF0,
  0x1E, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x7F, 0x03, 0xFF, 0x1F,
  0xC3, 0xFF, 0xE7, 0xF1, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xF0, 0xFF, 0xF8,
  0xFC, 0x0F, 0xF8, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x7F, 0x80, 0x1C, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFE, 0xF0, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0xFF, 0xF8,
  0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xF8,
  0x0F, 0xFD, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0x3F, 0xFE, 0x7F, 0x03, 0xFE,
  0x1F, 0xC0, 0x08, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE6, 0x00, 0x07, 0xF9, 0xF0, 0x07, 0xFC,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x78, 0x0F, 0xE3, 0xFF, 0x87, 0xF7, 0xFF,
  0xE3, 0xF7, 0xFF, 0xF9, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F,
  0x9F, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xBF,
  0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xCF,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0,
  0x7C, 0x1F, 0xFC, 0x3F, 0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF, 0xC7,
  0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x0F, 0xFC,
  0x0F, 0xCF, 0xFF, 0x83, 0xF7, 0xFF, 0xF8, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF8, 0x07, 0xFB, 0xFF, 0x03, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xC3, 0xFB, 0xFF,
  0xE0, 0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFD, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xFD, 0xFF,
  0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC,
  0x3F, 0xFE, 0x7F, 0x03, 0xFE, 0x1F, 0xC0, 0x18, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xBE, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xBF, 0x7F, 0xEF,
  0xFF, 0xDB, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xC1, 0xF9, 0xF8, 0x00, 0x9F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x02, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xEF, 0xC7, 0xFF, 0xE3, 0xE0,
  0xFF, 0xC1, 0xF0, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xF8, 0x03, 0xF9,
  0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0x1F, 0xC0,
  0x7D, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0xFC, 0x07, 0xDF,
  0x01, 0xF8, 0x3F, 0x01, 0xF7, 0xE0, 0x7E, 0x0F, 0xE0, 0xF8, 0xF8, 0x1F,
  0x81, 0xF8, 0x3E, 0x3E, 0x0F, 0xE0, 0x7E, 0x0F, 0x8F, 0x83, 0xF0, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x7C, 0x7F, 0x00, 0xFC, 0x7C,
  0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x03, 0xFB, 0xE0, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x0F, 0xBF, 0x00,
  0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0x07, 0xEF, 0x80, 0xFB, 0xF0, 0x00, 0xFB,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0x7E, 0x01, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF9, 0x00, 0x00,
  0x60,
};

const GFXglyph NotoSans_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 17, 13, 24, 3, -37 },
  { 67, 31, 37, 34, 1, -37 },
  { 211, 24, 42, 30, 3, -39 },
  { 337, 42, 38, 46, 2, -38 },
  { 537, 37, 39, 39, 2, -38 },
  { 718, 7, 13, 13, 3, -37 },
  { 730, 13, 45, 17, 2, -37 },
  { 804, 13, 45, 17, 2, -37 },
  { 878, 25, 24, 28, 2, -40 },
  { 953, 25, 25, 30, 2, -31 },
  { 1032, 9, 13, 15, 2, -6 },
  { 1047, 13, 6, 17, 2, -17 },
  { 1057, 8, 8, 14, 3, -7 },
  { 1065, 20, 37, 21, 0, -37 },
  { 1158, 26, 39, 30, 2, -38 },
  { 1285, 16, 37, 30, 4, -37 },
  { 1359, 26, 38, 30, 2, -38 },
  { 1483, 25, 39, 30, 2, -38 },
  { 1605, 28, 37, 30, 1, -37 },
  { 1735, 24, 38, 30, 3, -37 },
  { 1849, 26, 39, 30, 2, -38 },
  { 1976, 26, 37, 30, 2, -37 },
  { 2097, 26, 39, 30, 2, -38 },
  { 2224, 26, 39, 30, 2, -38 },
  { 2351, 8, 30, 14, 3, -29 },
  { 2381, 9, 36, 15, 2, -29 },
  { 2422, 25, 27, 30, 2, -32 },
  { 2507, 25, 15, 30, 2, -26 },
  { 2554, 25, 27, 30, 2, -32 },
  { 2639, 23, 39, 24, 0, -38 },
  { 2752, 41, 41, 47, 3, -37 },
  { 2963, 35, 37, 35, 0, -37 },
  { 3125, 27, 37, 34, 5, -37 },
  { 3250, 29, 39, 33, 3, -38 },
  { 3392, 30, 37, 38, 5, -37 },
  { 3531, 21, 37, 29, 5, -37 },
  { 3629, 21, 37, 28, 5, -37 },
  { 3727, 31, 39, 38, 3, -38 },
  { 3879, 29, 37, 39, 5, -37 },
  { 4014, 15, 37, 19, 2, -37 },
  { 4084, 15, 48, 16, -4, -37 },
  { 4174, 29, 37, 34, 5, -37 },
  { 4309, 22, 37, 28, 5, -37 },
  { 4411, 39, 37, 48, 5, -37 },
  { 4592, 31, 37, 41, 5, -37 },
  { 4736, 35, 39, 41, 3, -38 },
  { 4907, 25, 37, 32, 5, -37 },
  { 5023, 35, 47, 41, 3, -38 },
  { 5229, 28, 37, 33, 5, -37 },
  { 5359, 24, 39, 29, 2, -38 },
  { 5476, 28, 37, 30, 1, -37 },
  { 5606, 29, 38, 39, 5, -37 },
  { 5744, 33, 37, 33, 0, -37 },
  { 5897, 49, 37, 50, 0, -37 },
  { 6124, 33, 37, 33, 0, -37 },
  { 6277, 31, 37, 31, 0, -37 },
  { 6421, 26, 37, 30, 2, -37 },
  { 6542, 12, 45, 17, 4, -37 },
  { 6610, 20, 37, 21, 0, -37 },
  { 6703, 12, 45, 17, 1, -37 },
  { 6771, 26, 24, 30, 2, -37 },
  { 6849, 22, 3, 22, 0, 5 },
  { 6858, 13, 8, 17, 2, -40 },
  { 6871, 25, 30, 30, 2, -29 },
  { 6965, 26, 41, 33, 4, -40 },
  { 7099, 22, 30, 26, 3, -29 },
  { 7182, 26, 41, 33, 3, -40 },
  { 7316, 25, 30, 30, 3, -29 },
  { 7410, 21, 40, 19, 1, -40 },
  { 7515, 26, 41, 33, 3, -29 },
  { 7649, 25, 40, 33, 4, -40 },
  { 7774, 7, 39, 15, 4, -39 },
  { 7809, 14, 51, 15, -3, -39 },
  { 7899, 26, 40, 31, 4, -40 },
  { 8029, 7, 40, 15, 4, -40 },
  { 8064, 42, 29, 50, 4, -29 },
  { 8217, 25, 29, 33, 4, -29 },
  { 8308, 26, 30, 32, 3, -29 },
  { 8406, 26, 41, 33, 4, -29 },
  { 8540, 26, 41, 33, 3, -29 },
  { 8674, 18, 29, 23, 4, -29 },
  { 8740, 21, 30, 26, 2, -29 },
  { 8819, 19, 35, 21, 1, -34 },
  { 8903, 25, 29, 33, 4, -28 },
  { 8994, 28, 28, 28, 0, -28 },
  { 9092, 42, 28, 43, 1, -28 },
  { 9239, 28, 28, 29, 1, -28 },
  { 9337, 29, 40, 29, 0, -28 },
  { 9482, 21, 28, 25, 2, -28 },
  { 9556, 17, 45, 20, 1, -37 },
  { 9652, 5, 51, 29, 12, -39 },
  { 9684, 17, 45, 20, 2, -37 },
  { 9780, 25, 8, 30, 2, -22 },
};

const GFXfont NotoSans_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMIBOLD52PT7B_H_
