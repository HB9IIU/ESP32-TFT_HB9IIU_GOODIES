#ifndef _NOTOSANS_SEMIBOLD23PT7B_H_
#define _NOTOSANS_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x76, 0x66, 0x60, 0x07, 0xF7, 0xE7, 0x67, 0x67,
  0x67, 0x67, 0x62, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x18, 0xCF, 0xFF, 0xFF,
  0xFC, 0x63, 0x03, 0x18, 0x18, 0xC7, 0xFF, 0xFF, 0xFE, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xCE, 0x0E, 0x60, 0x04, 0x01, 0xE0, 0xFF, 0xBF, 0xEE, 0x45,
  0xC8, 0x3D, 0x03, 0xE0, 0x3F, 0x81, 0xF8, 0x17, 0x82, 0x70, 0x4F, 0xCB,
  0xFF, 0xF3, 0xF8, 0x04, 0x00, 0x80, 0x38, 0x02, 0x1F, 0x03, 0x0E, 0xE1,
  0xC3, 0x18, 0x60, 0xC6, 0x38, 0x31, 0x8C, 0x0C, 0x66, 0x03, 0x19, 0xBE,
  0xEE, 0xCF, 0x9F, 0x77, 0x33, 0x99, 0x8C, 0x0E, 0x63, 0x03, 0x18, 0xC1,
  0xC6, 0x30, 0x61, 0x8C, 0x38, 0x3F, 0x1C, 0x0F, 0x80, 0x07, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x39, 0xC0, 0x3B, 0xC0, 0x1F,
  0x00, 0x3E, 0x0E, 0x7F, 0x0E, 0xF3, 0x8E, 0xE1, 0xDC, 0xE0, 0xFC, 0xE0,
  0x78, 0xF0, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F, 0xED, 0xB6, 0xC0, 0x1C, 0xE7,
  0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x70, 0xC3,
  0x87, 0xE1, 0xC7, 0x0C, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xC6, 0x18, 0xE3,
  0x8E, 0x71, 0xCE, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x76, 0xFF, 0xFE, 0x1C,
  0x07, 0xC1, 0xD8, 0x73, 0x86, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x77, 0x6E,
  0xEC, 0xFF, 0xF0, 0x7F, 0x70, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDC, 0x71, 0xFE, 0x1F,
  0x00, 0x1E, 0x7D, 0xFF, 0x7C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x0F, 0xF3, 0xFF, 0x30, 0xF0, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x0F, 0xF3, 0xFF, 0x20, 0xF0, 0x0E, 0x01, 0x80,
  0x71, 0xFC, 0x3F, 0x07, 0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xF0, 0x7F,
  0xFE, 0xFF, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0D, 0xC0, 0xEE, 0x06,
  0x70, 0x73, 0x87, 0x1C, 0x30, 0xE3, 0x07, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x7F, 0xCF, 0xF9, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x1F, 0xE3, 0xFE, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x87,
  0xBF, 0xF3, 0xF8, 0x03, 0xC3, 0xF8, 0xFF, 0x3C, 0x07, 0x00, 0xC0, 0x38,
  0x87, 0x7E, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xC1, 0xDC, 0x79,
  0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x0E, 0x07, 0xF1, 0xFF, 0x30, 0x7E, 0x0E, 0xC1, 0xDC, 0x71, 0xFC,
  0x1F, 0x0F, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xFC, 0x3B, 0xFE, 0x3F,
  0x80, 0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF1, 0xEF, 0xFC, 0xFB, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE3, 0xFC, 0x7E,
  0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x7F, 0x70, 0x6F, 0xF6, 0x00, 0x00,
  0x00, 0x77, 0xEE, 0xCC, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x78, 0x7C, 0x3E, 0x1F, 0x03, 0x00, 0x40, 0x00, 0x1E,
  0x3F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x07, 0xFC, 0x03,
  0xC7, 0xC1, 0xC0, 0x38, 0xC0, 0x06, 0x71, 0xFC, 0xD8, 0xFF, 0x36, 0x71,
  0xCF, 0x98, 0x63, 0xC6, 0x18, 0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x9C, 0xF7,
  0x63, 0xEF, 0x98, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x10, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x37, 0x00, 0xEE, 0x01,
  0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x38, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xE7, 0x01, 0xCE, 0x03, 0xDC, 0x03, 0xF0, 0x07, 0xFF, 0xCF, 0xFE, 0xE0,
  0xEE, 0x0F, 0xE0, 0xEE, 0x0E, 0xFF, 0xCF, 0xF8, 0xFF, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xF8, 0x03, 0xC0, 0x7F, 0xC7,
  0xFE, 0x78, 0x27, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0xC3, 0xFE, 0x0F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0F, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0xF3, 0x9F,
  0xCF, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0x02, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0xFF, 0x83, 0xFF, 0x01, 0xDC,
  0x07, 0x70, 0x1D, 0xE0, 0x73, 0xE1, 0xC7, 0xFF, 0x0F, 0xF8, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x3F, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xF7, 0xE7, 0x00, 0xE0, 0x7F, 0x07,
  0x38, 0x71, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0xB8, 0x1F, 0xC0, 0xFF, 0x07,
  0xBC, 0x38, 0xE1, 0xC7, 0x8E, 0x1E, 0x70, 0x73, 0x83, 0xDC, 0x0F, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xBF, 0xC1, 0xDF, 0x60, 0xDF, 0xB8, 0x6F, 0xDC, 0x77,
  0xE6, 0x33, 0xF3, 0x99, 0xF9, 0xDC, 0xFC, 0x6C, 0x7E, 0x3E, 0x3F, 0x1F,
  0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xEE, 0x1F, 0xB8, 0x7E, 0x71, 0xF9, 0xE7, 0xE3, 0x9F, 0x87, 0x7E, 0x1C,
  0xF8, 0x3B, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0x03, 0xC0, 0x0F,
  0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78,
  0x1E, 0x3E, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x9F, 0xFB, 0x87, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFE, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3E, 0x3C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0xFF,
  0x87, 0xFE, 0x38, 0x79, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9F, 0xF8,
  0xFF, 0x87, 0xFC, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0x73, 0x83, 0xDC,
  0x0F, 0x0F, 0x07, 0xF9, 0xFF, 0x78, 0x2E, 0x01, 0xC0, 0x1C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xF8, 0x77, 0xFE, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xBC, 0x78, 0xFF, 0xC3, 0xF8, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x81,
  0xC3, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x39, 0xC0,
  0x3B, 0x80, 0x76, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0xE0,
  0x78, 0x1D, 0xC1, 0xE0, 0xE7, 0x07, 0x83, 0x9C, 0x3E, 0x0E, 0x70, 0xFC,
  0x38, 0xC3, 0x71, 0xC3, 0x8C, 0xC7, 0x0E, 0x73, 0x9C, 0x39, 0xCE, 0x60,
  0x66, 0x1B, 0x81, 0xD8, 0x6E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x70, 0x70, 0xE1,
  0xC0, 0xE3, 0x80, 0xEE, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x3B, 0x80, 0xE7, 0x83, 0x87, 0x07, 0x07, 0x1C, 0x0F, 0x78,
  0x0F, 0xF0, 0x3D, 0xC0, 0xE3, 0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x80,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x06,
  0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xFF, 0xF0, 0x04, 0x01, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x67, 0x0C,
  0x63, 0x8E, 0x60, 0xDC, 0x1F, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3,
  0x87, 0x0F, 0x0F, 0xF8, 0xEF, 0x00, 0x70, 0x0E, 0x1F, 0xDF, 0xFF, 0x87,
  0xE0, 0xFC, 0x1F, 0x87, 0xFF, 0xF7, 0xEE, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x71, 0xFF, 0x3F, 0xF7, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x7F, 0xFE, 0xCF, 0x80, 0x0F, 0x0F, 0xF7, 0xF9, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x8C, 0xFF, 0x1F, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0E, 0x73, 0xF7, 0x7F, 0xF7, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x78, 0xF7, 0xFF,
  0x3F, 0x70, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x9F, 0xF1, 0xFC, 0x07, 0x47, 0xE1, 0xF8,
  0xF0, 0x38, 0x0E, 0x0F, 0xF3, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0xF7, 0x7F, 0xF7,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x70, 0xF7,
  0xFF, 0x3F, 0x70, 0x07, 0x00, 0xE4, 0x0E, 0x7F, 0xE7, 0xFC, 0x04, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x71, 0xFF, 0xBF, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x71, 0x80, 0x00, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFB, 0xE4,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC3, 0xB8, 0xE7, 0x38,
  0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0x71, 0xC7, 0x38, 0xF7, 0x0E, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x07, 0x37, 0xF7,
  0xEF, 0xFF, 0xFF, 0x87, 0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F,
  0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0,
  0xE1, 0xC0, 0x07, 0x1B, 0xFB, 0xFF, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70,
  0xE3, 0xFC, 0x1F, 0x80, 0x07, 0x1B, 0xFB, 0xFF, 0x70, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xFF, 0xEE, 0xF9, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xF7, 0x7F, 0xF7,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x70, 0xF7,
  0xFF, 0x3F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xDF, 0xDE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x1E, 0x3F, 0xFC, 0xFC, 0x0E, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0x80,
  0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x0E, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xFC, 0x7E, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFE, 0x3F, 0xFF,
  0xBF, 0x70, 0xE0, 0x7B, 0x83, 0x9C, 0x38, 0x61, 0xC3, 0x8E, 0x1C, 0xE0,
  0x67, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0xE0,
  0xEE, 0x3E, 0x39, 0xC6, 0xC7, 0x38, 0xD8, 0xE3, 0x1B, 0x98, 0x77, 0x77,
  0x0E, 0xC6, 0xE1, 0xD8, 0xDC, 0x1B, 0x1B, 0x03, 0xE3, 0xE0, 0x78, 0x3C,
  0x07, 0x07, 0x00, 0xF0, 0x71, 0xC7, 0x0F, 0x70, 0x3B, 0x80, 0xF8, 0x07,
  0x80, 0x3E, 0x03, 0xF8, 0x1D, 0xC1, 0xC7, 0x1C, 0x3D, 0xE0, 0xF0, 0xE0,
  0x7B, 0x83, 0x9C, 0x18, 0x61, 0xC3, 0x8E, 0x1C, 0x60, 0x77, 0x03, 0xB8,
  0x0D, 0x80, 0x7C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x0F,
  0x80, 0x78, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0xF8, 0xE0, 0xF8, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1F, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x1E, 0x1C, 0x79, 0xC3, 0x87, 0x0E, 0x1C, 0x39,
  0xE3, 0xC6, 0x00, 0x78, 0x3F, 0xFF, 0x3F, 0xC0, 0xC0,
};

const GFXglyph NotoSans_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 13, 16, 15, 1, -16 },
  { 41, 11, 18, 13, 1, -17 },
  { 66, 18, 17, 20, 1, -17 },
  { 105, 16, 17, 17, 1, -17 },
  { 139, 3, 6, 6, 1, -16 },
  { 142, 6, 20, 7, 1, -16 },
  { 157, 6, 20, 7, 1, -16 },
  { 172, 11, 10, 13, 1, -17 },
  { 186, 11, 11, 13, 1, -14 },
  { 202, 4, 6, 6, 1, -3 },
  { 205, 6, 2, 7, 1, -7 },
  { 207, 4, 3, 6, 1, -3 },
  { 209, 9, 17, 9, 0, -17 },
  { 229, 11, 17, 13, 1, -17 },
  { 253, 7, 16, 13, 2, -16 },
  { 267, 11, 17, 13, 1, -17 },
  { 291, 11, 17, 13, 1, -17 },
  { 315, 13, 16, 13, 0, -16 },
  { 341, 11, 16, 13, 1, -16 },
  { 363, 11, 17, 13, 1, -17 },
  { 387, 11, 16, 13, 1, -16 },
  { 409, 11, 17, 13, 1, -17 },
  { 433, 11, 17, 13, 1, -17 },
  { 457, 4, 13, 6, 1, -13 },
  { 464, 4, 16, 6, 1, -13 },
  { 472, 11, 12, 13, 1, -14 },
  { 489, 11, 6, 13, 1, -11 },
  { 498, 11, 12, 13, 1, -14 },
  { 515, 10, 17, 11, 0, -17 },
  { 537, 18, 18, 21, 1, -16 },
  { 578, 15, 16, 15, 0, -16 },
  { 608, 12, 16, 15, 2, -16 },
  { 632, 13, 17, 15, 1, -17 },
  { 660, 14, 16, 17, 2, -16 },
  { 688, 9, 16, 13, 2, -16 },
  { 706, 9, 16, 12, 2, -16 },
  { 724, 14, 17, 17, 1, -17 },
  { 754, 13, 16, 17, 2, -16 },
  { 780, 7, 16, 9, 1, -16 },
  { 794, 7, 21, 7, -2, -16 },
  { 813, 13, 16, 15, 2, -16 },
  { 839, 10, 16, 13, 2, -16 },
  { 859, 17, 16, 21, 2, -16 },
  { 893, 14, 16, 18, 2, -16 },
  { 921, 16, 17, 18, 1, -17 },
  { 955, 11, 16, 14, 2, -16 },
  { 977, 16, 21, 18, 1, -17 },
  { 1019, 13, 16, 15, 2, -16 },
  { 1045, 11, 17, 13, 1, -17 },
  { 1069, 13, 16, 13, 0, -16 },
  { 1095, 13, 16, 17, 2, -16 },
  { 1121, 15, 16, 15, 0, -16 },
  { 1151, 22, 16, 22, 0, -16 },
  { 1195, 15, 16, 15, 0, -16 },
  { 1225, 14, 16, 14, 0, -16 },
  { 1253, 12, 16, 13, 1, -16 },
  { 1277, 5, 20, 8, 2, -16 },
  { 1290, 9, 17, 9, 0, -17 },
  { 1310, 5, 20, 8, 1, -16 },
  { 1323, 11, 11, 13, 1, -17 },
  { 1339, 10, 2, 10, 0, 2 },
  { 1342, 6, 4, 8, 1, -18 },
  { 1345, 11, 13, 13, 1, -13 },
  { 1363, 11, 17, 14, 2, -17 },
  { 1387, 10, 13, 12, 1, -13 },
  { 1404, 12, 17, 14, 1, -17 },
  { 1430, 11, 13, 13, 1, -13 },
  { 1448, 10, 18, 9, 0, -18 },
  { 1471, 12, 19, 14, 1, -13 },
  { 1500, 11, 17, 15, 2, -17 },
  { 1524, 3, 17, 7, 2, -17 },
  { 1531, 6, 23, 7, -1, -17 },
  { 1549, 11, 17, 14, 2, -17 },
  { 1573, 3, 17, 7, 2, -17 },
  { 1580, 18, 13, 22, 2, -13 },
  { 1610, 11, 13, 15, 2, -13 },
  { 1628, 12, 13, 14, 1, -13 },
  { 1648, 11, 19, 14, 2, -13 },
  { 1675, 12, 19, 14, 1, -13 },
  { 1704, 8, 13, 10, 2, -13 },
  { 1717, 9, 13, 11, 1, -13 },
  { 1732, 9, 15, 9, 0, -15 },
  { 1749, 11, 12, 15, 2, -12 },
  { 1766, 13, 12, 13, 0, -12 },
  { 1786, 19, 12, 19, 0, -12 },
  { 1815, 13, 12, 13, 0, -12 },
  { 1835, 13, 18, 13, 0, -12 },
  { 1865, 9, 12, 11, 1, -12 },
  { 1879, 8, 20, 9, 0, -16 },
  { 1899, 2, 22, 13, 5, -17 },
  { 1905, 7, 20, 9, 1, -16 },
  { 1923, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMIBOLD23PT7B_H_
