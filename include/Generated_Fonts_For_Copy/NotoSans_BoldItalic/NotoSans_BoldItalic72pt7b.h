#ifndef _NOTOSANS_BOLDITALIC72PT7B_H_
#define _NOTOSANS_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F,
  0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xBE, 0xFF, 0x80, 0x7F, 0xF1, 0xF0, 0x78, 0x03, 0xFF, 0x0F,
  0x80, 0x40, 0x3F, 0xF8, 0x78, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x0F,
  0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0x03, 0xFF, 0x8F, 0x80,
  0x00, 0x0F, 0xFF, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x00,
  0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x00, 0x3E, 0x1F, 0xF8,
  0x80, 0x01, 0xF0, 0xFF, 0xC7, 0x80, 0x1F, 0x0F, 0xFE, 0x3F, 0x00, 0xF8,
  0xFF, 0xF1, 0xFF, 0xC7, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x00, 0xC0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF,
  0xFC, 0xFF, 0xCF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xC7, 0xFE, 0x3F, 0xE3,
  0xFF, 0xF8, 0xFF, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0xC3, 0xFE, 0x3F, 0xE0,
  0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xE1,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x7F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x3E, 0x01, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0xFE,
  0x00, 0x07, 0xFF, 0xDF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0x80, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x8F, 0xF0, 0x00, 0xFF, 0xE1, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0xF8, 0x0F, 0xF8,
  0x00, 0x06, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x0F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xC3, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x03,
  0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xFC, 0x3F, 0xFE, 0x7F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0x78, 0x0F,
  0xFC, 0x01, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x40,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE1,
  0x80, 0x00, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFA, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x40, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x00, 0x07, 0xFF, 0x81, 0xF0, 0x00,
  0x3F, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF4, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFF, 0xF8,
  0x03, 0xFF, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF9,
  0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0xF0, 0x1F,
  0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x70, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xC7, 0x80,
  0x0F, 0xFE, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFD, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xDF, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xEF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFB, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF,
  0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xC3,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x80, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE3,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFD,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F,
  0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFF, 0xBF, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x1F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xE3, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xF9, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xEF, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xDF, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x0E, 0x00,
  0x7F, 0xF0, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x00,
  0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x07, 0xF8,
  0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x1F, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0xF0, 0x01, 0xFF,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xE0,
  0x07, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1E, 0x03, 0xFF, 0xC0, 0x01, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x01,
  0xFF, 0xE0, 0x03, 0x80, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xFF, 0xEF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xDF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE7, 0xF8, 0x00, 0x0F, 0xFF, 0xF3, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x3F, 0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x07,
  0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x1F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x02, 0x03, 0xFF, 0xC0, 0x03, 0xC0,
  0x7F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC3, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x80, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x03,
  0xFF, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFF,
  0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xBF, 0xF0, 0x00,
  0x7F, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF,
  0x8F, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x01,
  0xFF, 0x8F, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xEF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00,
  0x3F, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0xFF,
  0x80, 0x1F, 0xE7, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0xFF, 0x00, 0xFF,
  0xBF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03,
  0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0x8F, 0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xFF, 0xFE, 0x00, 0x07,
  0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF7, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x02, 0x00, 0x1F, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xF0, 0x03,
  0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0xFF,
  0xC0, 0x01, 0xFF, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00,
  0x78, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xBF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x04, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xF8, 0x0F, 0xFE, 0x00, 0x38, 0x0F, 0xFE, 0x00, 0x08, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x00,
  0x7F, 0xF0, 0xC0, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x81, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00,
  0x3F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0x7F,
  0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x3F,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xC7,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x3F, 0xCF, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x3F, 0xCF, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x3F, 0xCF, 0xF8,
  0x00, 0x3F, 0xCF, 0xF0, 0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x3F,
  0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xBF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x31, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x27, 0xFF, 0xF8,
  0x00, 0x0D, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xD8, 0x00, 0x1F, 0xFF,
  0xF2, 0x00, 0x00, 0x7F, 0xF8, 0x40, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph NotoSans_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 22, 52, 21, 1, -51 },
  { 144, 27, 18, 33, 7, -51 },
  { 205, 46, 51, 47, 1, -51 },
  { 499, 37, 59, 40, 2, -55 },
  { 772, 55, 53, 62, 4, -52 },
  { 1137, 48, 53, 51, 2, -52 },
  { 1455, 12, 18, 18, 7, -51 },
  { 1482, 27, 62, 24, 3, -51 },
  { 1692, 27, 63, 25, -5, -52 },
  { 1905, 35, 35, 39, 6, -55 },
  { 2059, 35, 35, 41, 4, -43 },
  { 2213, 17, 17, 21, -3, -8 },
  { 2250, 21, 9, 23, 1, -24 },
  { 2274, 12, 12, 21, 1, -11 },
  { 2292, 39, 52, 31, -3, -52 },
  { 2546, 37, 53, 40, 2, -52 },
  { 2792, 29, 51, 40, 6, -51 },
  { 2977, 41, 52, 40, -2, -52 },
  { 3244, 39, 53, 40, 0, -52 },
  { 3503, 40, 51, 40, -1, -51 },
  { 3758, 39, 52, 40, 1, -51 },
  { 4012, 38, 53, 40, 3, -52 },
  { 4264, 40, 51, 40, 3, -51 },
  { 4519, 38, 53, 40, 2, -52 },
  { 4771, 35, 53, 40, 3, -52 },
  { 5003, 19, 41, 21, 1, -40 },
  { 5101, 24, 49, 21, -4, -40 },
  { 5248, 35, 38, 41, 4, -45 },
  { 5415, 35, 21, 41, 4, -36 },
  { 5507, 35, 38, 41, 4, -45 },
  { 5674, 29, 53, 33, 6, -52 },
  { 5867, 58, 58, 62, 3, -51 },
  { 6288, 45, 51, 45, -4, -51 },
  { 6575, 42, 51, 45, 2, -51 },
  { 6843, 43, 53, 44, 4, -52 },
  { 7128, 45, 51, 49, 2, -51 },
  { 7415, 40, 51, 39, 2, -51 },
  { 7670, 39, 51, 38, 2, -51 },
  { 7919, 45, 53, 50, 4, -52 },
  { 8218, 49, 51, 50, 2, -51 },
  { 8531, 34, 51, 28, -2, -51 },
  { 8748, 35, 66, 24, -11, -51 },
  { 9037, 49, 51, 44, 2, -51 },
  { 9350, 30, 51, 37, 2, -51 },
  { 9542, 62, 51, 63, 2, -51 },
  { 9938, 53, 51, 55, 2, -51 },
  { 10276, 46, 53, 53, 4, -52 },
  { 10581, 42, 51, 44, 2, -51 },
  { 10849, 46, 64, 53, 4, -52 },
  { 11217, 41, 51, 45, 2, -51 },
  { 11479, 38, 53, 38, 1, -52 },
  { 11731, 37, 51, 38, 6, -51 },
  { 11967, 45, 52, 50, 5, -51 },
  { 12260, 43, 51, 42, 6, -51 },
  { 12535, 65, 51, 64, 6, -51 },
  { 12950, 54, 51, 44, -4, -51 },
  { 13295, 40, 51, 41, 7, -51 },
  { 13550, 44, 51, 39, -2, -51 },
  { 13831, 30, 62, 24, -1, -51 },
  { 14064, 17, 52, 31, 8, -52 },
  { 14175, 30, 62, 24, -5, -51 },
  { 14408, 37, 34, 40, 1, -52 },
  { 14566, 30, 5, 29, -7, 6 },
  { 14585, 16, 11, 23, 10, -55 },
  { 14607, 39, 41, 43, 3, -40 },
  { 14807, 39, 56, 43, 1, -55 },
  { 15080, 33, 41, 35, 3, -40 },
  { 15250, 42, 56, 43, 3, -55 },
  { 15544, 35, 41, 40, 3, -40 },
  { 15724, 43, 72, 27, -8, -55 },
  { 16111, 41, 57, 43, 1, -40 },
  { 16404, 39, 55, 43, 1, -55 },
  { 16673, 22, 55, 22, 1, -55 },
  { 16825, 32, 72, 22, -9, -55 },
  { 17113, 43, 55, 41, 1, -55 },
  { 17409, 23, 55, 22, 1, -55 },
  { 17568, 60, 40, 65, 1, -40 },
  { 17868, 39, 40, 43, 1, -40 },
  { 18063, 36, 41, 42, 3, -40 },
  { 18248, 42, 57, 43, -2, -40 },
  { 18548, 39, 57, 43, 3, -40 },
  { 18826, 32, 40, 30, 1, -40 },
  { 18986, 32, 41, 34, 1, -40 },
  { 19150, 28, 49, 30, 3, -48 },
  { 19322, 38, 40, 43, 4, -39 },
  { 19512, 37, 39, 37, 4, -39 },
  { 19693, 56, 39, 57, 4, -39 },
  { 19966, 46, 39, 38, -4, -39 },
  { 20191, 46, 56, 37, -5, -39 },
  { 20513, 35, 39, 34, -1, -39 },
  { 20684, 30, 62, 26, 0, -51 },
  { 20917, 8, 71, 40, 16, -55 },
  { 20988, 30, 62, 26, -4, -51 },
  { 21221, 35, 12, 41, 4, -31 },
};

const GFXfont NotoSans_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_BOLDITALIC72PT7B_H_
