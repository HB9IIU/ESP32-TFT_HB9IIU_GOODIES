#ifndef _NOTOSANS_BOLDITALIC70PT7B_H_
#define _NOTOSANS_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xCF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xF7, 0xFC, 0x03,
  0xFF, 0x9F, 0x07, 0x80, 0x7F, 0xF1, 0xF0, 0x08, 0x07, 0xFE, 0x1F, 0x00,
  0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x07, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0xE3,
  0xE0, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x00, 0x7F, 0xFB, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x7F, 0xF8, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0x1F,
  0x1F, 0xF8, 0x00, 0x01, 0xF1, 0xFF, 0x80, 0x00, 0x1E, 0x1F, 0xF8, 0x80,
  0x03, 0xE1, 0xFF, 0x8E, 0x00, 0x3E, 0x1F, 0xF8, 0xF8, 0x03, 0xE3, 0xFF,
  0x8F, 0xF0, 0x3C, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xC0, 0x7F, 0x81, 0xFE, 0x1F,
  0xE1, 0xFF, 0xC3, 0xFC, 0x1F, 0xF1, 0xFE, 0x3F, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xE3, 0xFF, 0xFC, 0xFF, 0xDF, 0xF8, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0x8F, 0xF8,
  0x7F, 0x8F, 0xFF, 0xC7, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xF8, 0x7F, 0x87,
  0xFC, 0x1F, 0xE0, 0x3C, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x3C, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFF,
  0xC7, 0xE0, 0x00, 0x7F, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x60, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xC0, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x01, 0xF8, 0x1F, 0xF0, 0x00, 0x3C, 0x03, 0xFC, 0x00,
  0x02, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07,
  0x83, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x7F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFE,
  0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xDF, 0xF8, 0x3F, 0xF1,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x80, 0xF0, 0x3F, 0xF0,
  0x0C, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x04, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xC0,
  0x06, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xC0, 0x00,
  0x1F, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x20, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x20,
  0x00, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x02, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xE0, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x1F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xCF, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x0C, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xC3,
  0xC0, 0x07, 0xFE, 0x18, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80, 0x7F, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xF8,
  0x03, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0xFF,
  0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F,
  0xFE, 0x3F, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x81,
  0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE3,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x07,
  0xFF, 0xC0, 0x00, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0,
  0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x30,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x06, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0x7F, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F,
  0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xF3,
  0xFF, 0x00, 0x3F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFC, 0x7F,
  0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF7, 0xFE, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x10, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xC0,
  0x00, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0xFF,
  0x9F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE3,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFF,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xEF,
  0xF8, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xE3, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0xFB,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0xFE,
  0x01, 0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0x00, 0x1F, 0xE1,
  0xFF, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x38, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0x7F, 0xF0, 0x00,
  0xC0, 0x7F, 0xF8, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xCF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xFB, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x06, 0x07, 0xFF, 0x80, 0x07, 0x81, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xF0,
  0x00, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x18, 0x00, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xE3, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xEF, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF,
  0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x7F,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0xFC, 0x00, 0xFF, 0x3F,
  0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFC,
  0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFE,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x7F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF,
  0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xFF, 0xE0,
  0x00, 0x7F, 0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x0F, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0xFF,
  0xF0, 0x0F, 0xF3, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0x80, 0x7F, 0xDF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x20, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFE, 0x01, 0xF0, 0x1F, 0xFC, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x10, 0x00, 0x0F,
  0xFC, 0x3C, 0x00, 0x3F, 0xF8, 0x7F, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x20,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0x80, 0xFF,
  0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xF9, 0xFF,
  0x00, 0x7F, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F,
  0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x07, 0xFB, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xCF, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x7F, 0x87, 0xFE,
  0x00, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0x87, 0xF9, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x0F, 0xF3, 0xFE, 0x00, 0x1F,
  0xF3, 0xFC, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x3F, 0xDF, 0xF0,
  0x00, 0x7F, 0xDF, 0xE0, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0xBF, 0x80, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x43, 0xFF, 0x80, 0x00, 0x13, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xCC, 0x00, 0x07, 0xFF, 0xE2, 0x00, 0x00, 0x3F,
  0xE0,
};

const GFXglyph NotoSans_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 21, 51, 20, 1, -50 },
  { 135, 26, 18, 32, 7, -50 },
  { 194, 45, 50, 45, 1, -50 },
  { 476, 36, 57, 39, 2, -53 },
  { 733, 53, 52, 60, 4, -51 },
  { 1078, 47, 52, 50, 2, -51 },
  { 1384, 12, 18, 18, 7, -50 },
  { 1411, 26, 61, 24, 3, -50 },
  { 1610, 26, 62, 24, -5, -51 },
  { 1812, 34, 34, 38, 6, -54 },
  { 1957, 34, 34, 40, 4, -42 },
  { 2102, 16, 17, 20, -3, -8 },
  { 2136, 20, 9, 23, 1, -23 },
  { 2159, 12, 12, 20, 1, -11 },
  { 2177, 38, 50, 30, -3, -50 },
  { 2415, 36, 52, 39, 2, -51 },
  { 2649, 28, 50, 39, 6, -50 },
  { 2824, 40, 51, 39, -2, -51 },
  { 3079, 38, 52, 39, 0, -51 },
  { 3326, 39, 50, 39, -1, -50 },
  { 3570, 38, 51, 39, 1, -50 },
  { 3813, 36, 52, 39, 3, -51 },
  { 4047, 39, 50, 39, 3, -50 },
  { 4291, 37, 52, 39, 2, -51 },
  { 4532, 34, 52, 39, 3, -51 },
  { 4753, 18, 40, 20, 1, -39 },
  { 4843, 23, 48, 20, -4, -39 },
  { 4981, 34, 37, 40, 4, -44 },
  { 5139, 34, 21, 40, 4, -35 },
  { 5229, 34, 37, 40, 4, -44 },
  { 5387, 29, 52, 32, 5, -51 },
  { 5576, 56, 56, 60, 3, -50 },
  { 5968, 44, 50, 44, -4, -50 },
  { 6243, 41, 50, 43, 2, -50 },
  { 6500, 42, 52, 43, 4, -51 },
  { 6773, 43, 50, 47, 2, -50 },
  { 7042, 38, 50, 38, 2, -50 },
  { 7280, 38, 50, 37, 2, -50 },
  { 7518, 44, 52, 48, 4, -51 },
  { 7804, 47, 50, 49, 2, -50 },
  { 8098, 33, 50, 27, -2, -50 },
  { 8305, 35, 65, 23, -11, -50 },
  { 8590, 47, 50, 43, 2, -50 },
  { 8884, 30, 50, 36, 2, -50 },
  { 9072, 60, 50, 62, 2, -50 },
  { 9447, 51, 50, 53, 2, -50 },
  { 9766, 45, 52, 51, 4, -51 },
  { 10059, 41, 50, 43, 2, -50 },
  { 10316, 45, 63, 51, 4, -51 },
  { 10671, 40, 50, 43, 2, -50 },
  { 10921, 37, 52, 37, 1, -51 },
  { 11162, 36, 50, 37, 6, -50 },
  { 11387, 44, 51, 48, 5, -50 },
  { 11668, 42, 50, 41, 6, -50 },
  { 11931, 63, 50, 63, 6, -50 },
  { 12325, 52, 50, 43, -4, -50 },
  { 12650, 40, 50, 39, 6, -50 },
  { 12900, 43, 50, 38, -2, -50 },
  { 13169, 29, 61, 23, -1, -50 },
  { 13391, 16, 50, 30, 8, -50 },
  { 13491, 29, 61, 23, -5, -50 },
  { 13713, 36, 32, 39, 1, -50 },
  { 13857, 29, 5, 28, -6, 6 },
  { 13876, 15, 12, 23, 10, -54 },
  { 13899, 37, 40, 41, 3, -39 },
  { 14084, 38, 54, 42, 1, -53 },
  { 14341, 32, 40, 34, 3, -39 },
  { 14501, 41, 54, 42, 3, -53 },
  { 14778, 34, 40, 39, 3, -39 },
  { 14948, 41, 71, 26, -7, -54 },
  { 15312, 39, 56, 42, 1, -39 },
  { 15585, 38, 53, 42, 1, -53 },
  { 15837, 21, 53, 21, 1, -53 },
  { 15977, 32, 70, 21, -9, -53 },
  { 16257, 42, 53, 40, 1, -53 },
  { 16536, 22, 53, 21, 1, -53 },
  { 16682, 59, 39, 63, 1, -39 },
  { 16970, 38, 39, 42, 1, -39 },
  { 17156, 35, 40, 41, 3, -39 },
  { 17331, 41, 56, 42, -2, -39 },
  { 17618, 37, 56, 42, 3, -39 },
  { 17877, 31, 39, 30, 1, -39 },
  { 18029, 31, 40, 33, 1, -39 },
  { 18184, 27, 47, 29, 3, -46 },
  { 18343, 37, 39, 42, 4, -38 },
  { 18524, 37, 38, 36, 3, -38 },
  { 18700, 55, 38, 55, 4, -38 },
  { 18962, 45, 38, 37, -4, -38 },
  { 19176, 45, 55, 36, -5, -38 },
  { 19486, 35, 38, 33, -1, -38 },
  { 19653, 29, 61, 25, 0, -50 },
  { 19875, 7, 69, 39, 16, -53 },
  { 19936, 29, 61, 25, -4, -50 },
  { 20158, 34, 12, 40, 4, -31 },
};

const GFXfont NotoSans_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_BOLDITALIC70PT7B_H_
