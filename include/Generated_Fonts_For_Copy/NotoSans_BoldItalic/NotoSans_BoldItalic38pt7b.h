#ifndef _NOTOSANS_BOLDITALIC38PT7B_H_
#define _NOTOSANS_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x7C, 0xFD, 0xF3, 0xE7, 0x8F,
  0x9E, 0x3E, 0xF8, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE3, 0x87,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x87,
  0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0x98, 0x41, 0xF3, 0x80, 0x1F,
  0x38, 0x01, 0xFB, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xEF, 0xC0, 0x0E, 0xFC,
  0x00, 0xE7, 0xC8, 0x0C, 0xFC, 0xF0, 0xDF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x07,
  0xFC, 0x01, 0xF0, 0x7F, 0xF0, 0x0F, 0x03, 0xEF, 0x80, 0xF0, 0x3E, 0x3C,
  0x0F, 0x01, 0xF1, 0xE0, 0xF8, 0x0F, 0x0F, 0x07, 0x80, 0xF8, 0xF8, 0x78,
  0x07, 0xC7, 0xC7, 0x80, 0x3E, 0x3E, 0x7C, 0x01, 0xF1, 0xE3, 0xC7, 0x8F,
  0x9F, 0x3C, 0xFE, 0x7D, 0xFB, 0xCF, 0xF9, 0xFF, 0xBE, 0xFF, 0xEF, 0xF9,
  0xE7, 0xDF, 0x3F, 0x9E, 0x7C, 0x78, 0x21, 0xF3, 0xE3, 0xC0, 0x1F, 0x3E,
  0x3E, 0x00, 0xF1, 0xF1, 0xF0, 0x0F, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x7C,
  0x0F, 0x83, 0xE3, 0xC0, 0x78, 0x1F, 0x3E, 0x07, 0x80, 0xFF, 0xE0, 0x7C,
  0x03, 0xFF, 0x07, 0xC0, 0x1F, 0xF0, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xF0, 0xFF, 0xC0, 0xF8, 0x7F,
  0xF0, 0x7E, 0x3F, 0xFE, 0x1F, 0x1F, 0xCF, 0xCF, 0xC7, 0xE3, 0xFF, 0xE3,
  0xF0, 0x7F, 0xF0, 0xFC, 0x0F, 0xFC, 0x3F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xEF, 0xE0, 0x3F, 0xE1, 0xFC, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF3,
  0x80, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x70, 0xF0, 0x1F, 0x3C, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0x78,
  0x0F, 0xDE, 0x07, 0xE7, 0xC0, 0x70, 0xF0, 0x08, 0x3E, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3,
  0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x83,
  0xE1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x3F, 0x87, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xFC, 0x7E, 0xFC, 0x3C, 0xFC, 0x30,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xF9, 0xFC, 0x0E, 0x07, 0xE0, 0x20, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x78, 0x7F, 0x02, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x80, 0x0F, 0xCF, 0x83,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C,
  0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x38, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x60, 0x0F, 0xE3, 0xE3, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0x47, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x40, 0x3E, 0x7F, 0x07, 0xDF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF0, 0xFC, 0xFC, 0x0F, 0xDF, 0x81,
  0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0x0F,
  0xE7, 0xF3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xBF, 0x87, 0xE0,
  0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC,
  0x0F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xC7, 0xF7, 0xE0, 0xFD, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xEF, 0x87, 0xF3, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE2, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x04, 0x00, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x7F,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x78, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0xFC, 0x1F, 0x3E,
  0x0F, 0xFE, 0x3D, 0xF0, 0xFF, 0xF0, 0xF7, 0x87, 0xFF, 0xC3, 0xDE, 0x1F,
  0x0F, 0x0F, 0xF8, 0xF8, 0x3C, 0x3F, 0xC3, 0xC1, 0xE0, 0xFF, 0x1F, 0x07,
  0x83, 0xFC, 0x78, 0x1E, 0x1F, 0xF1, 0xE0, 0xF8, 0x7B, 0xC7, 0x83, 0xC3,
  0xEF, 0x1E, 0x1F, 0x0F, 0x3C, 0x7C, 0xFE, 0xFC, 0xF1, 0xFF, 0xFF, 0xE3,
  0xE3, 0xFD, 0xFF, 0x0F, 0x87, 0xE3, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x01, 0xFC, 0x03, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF8,
  0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0x1F, 0x07, 0xF8, 0x06, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x10, 0x3F, 0xF7, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x0F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x7C, 0x0F, 0xE0, 0x04, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC,
  0x0F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F,
  0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xC1, 0xFC, 0x01,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0,
  0x03, 0xE7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0x7C, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDE, 0x07, 0xBF, 0x07, 0xCF,
  0x07, 0xDF, 0x03, 0xE7, 0x83, 0xCF, 0x81, 0xF3, 0xC3, 0xE7, 0xC0, 0xF9,
  0xE1, 0xE3, 0xE0, 0x7C, 0xF1, 0xF3, 0xF0, 0x7E, 0x78, 0xF1, 0xF0, 0x3E,
  0x3C, 0xF8, 0xF8, 0x1F, 0x1E, 0x78, 0x7C, 0x0F, 0x8F, 0x7C, 0x7E, 0x07,
  0xC7, 0xBC, 0x3E, 0x07, 0xC3, 0xFE, 0x1F, 0x03, 0xE1, 0xFE, 0x0F, 0x81,
  0xF0, 0xFF, 0x07, 0xC0, 0xF8, 0x7F, 0x07, 0xE0, 0x7C, 0x3F, 0x83, 0xE0,
  0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3E, 0x07,
  0xFC, 0x03, 0xE0, 0xFF, 0xC0, 0x3E, 0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0,
  0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x1F, 0xBF, 0x0F, 0xC1,
  0xF1, 0xF0, 0xFC, 0x1F, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0xF8, 0x1F, 0x0F,
  0x8F, 0x83, 0xF0, 0xF9, 0xF8, 0x3E, 0x0F, 0xDF, 0x03, 0xE0, 0x7D, 0xF0,
  0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x7F, 0xF0, 0x7E, 0x03, 0xFF, 0x07, 0xC0,
  0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x01, 0xFE,
  0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xCF, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0,
  0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0,
  0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x87, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xE7, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x3C, 0x1F, 0x80, 0x41, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0xC0, 0x3F, 0x0F, 0x8F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8,
  0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80,
  0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x01, 0xF9, 0xF0,
  0x0F, 0xC0, 0x3E, 0x3E, 0x03, 0xF8, 0x0F, 0xC7, 0xC0, 0x7F, 0x01, 0xF8,
  0xF8, 0x1F, 0xE0, 0x7E, 0x1F, 0x03, 0xFC, 0x0F, 0xC3, 0xE0, 0xFF, 0x81,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7E, 0x0F, 0x83, 0xDE, 0x0F, 0x81, 0xF0, 0xFB,
  0xC3, 0xF0, 0x3E, 0x1E, 0x78, 0x7C, 0x07, 0xC7, 0xCF, 0x0F, 0x80, 0xF8,
  0xF9, 0xE3, 0xF0, 0x1F, 0x3E, 0x3C, 0x7C, 0x03, 0xE7, 0xC7, 0x9F, 0x80,
  0x7D, 0xF0, 0xF3, 0xE0, 0x0F, 0xBE, 0x1E, 0x7C, 0x01, 0xF7, 0x83, 0xDF,
  0x00, 0x3F, 0xF0, 0x7B, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x3E,
  0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x3F,
  0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07,
  0xCF, 0x00, 0xF0, 0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x3C, 0x7C,
  0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFD, 0xF9, 0xF1, 0xF1, 0xE3, 0xC0, 0x03, 0xF1, 0xF0,
  0x7F, 0x9F, 0x0F, 0xFD, 0xF1, 0xFF, 0xFE, 0x3F, 0xDF, 0xE3, 0xF0, 0xFE,
  0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFE, 0x7F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x3F,
  0x9F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x8F,
  0x80, 0xFB, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xEF, 0xF1, 0xF8,
  0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E,
  0x03, 0xF3, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xBF, 0xE0,
  0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFD, 0xE3, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x08, 0xFE, 0x3C, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0xEF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x07,
  0xFE, 0xF0, 0x1F, 0xF7, 0xC0, 0x3F, 0x9F, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x8F, 0xCF, 0xC1, 0xF7, 0xE0, 0x7D,
  0xF0, 0x3F, 0xFC, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x06, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC8, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF,
  0xBE, 0x1F, 0xFF, 0xE1, 0xFE, 0xFF, 0x0F, 0xC3, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F,
  0x3F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFB, 0xE0, 0x7F, 0xFF, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x80, 0x7F, 0x07, 0x87,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0xFB,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF7, 0xF1, 0xFC, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3,
  0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7C,
  0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xF8, 0x0F,
  0x80, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xE0, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x80, 0x0F, 0x0F, 0x81, 0xF8, 0x1E, 0x7F, 0x87, 0xF8, 0x3D, 0xFF,
  0x9F, 0xF8, 0xFB, 0xFF, 0x7F, 0xF1, 0xFF, 0x7F, 0xE7, 0xE3, 0xF8, 0x7F,
  0x87, 0xC7, 0xE0, 0xFE, 0x0F, 0x8F, 0xC1, 0xF8, 0x1F, 0x3F, 0x03, 0xF0,
  0x3E, 0x7E, 0x07, 0xE0, 0xFC, 0xFC, 0x0F, 0x81, 0xF9, 0xF0, 0x3F, 0x03,
  0xF7, 0xE0, 0x7E, 0x07, 0xCF, 0xC0, 0xF8, 0x0F, 0x9F, 0x81, 0xF0, 0x3F,
  0x3E, 0x07, 0xE0, 0x7E, 0x7C, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0x81, 0xF3,
  0xF0, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x0F, 0xCF, 0x81, 0xF8, 0x1F, 0x80,
  0x0F, 0x0F, 0x80, 0xF3, 0xFE, 0x0F, 0x7F, 0xE1, 0xF7, 0xFF, 0x1F, 0xF7,
  0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x81, 0xF3, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD,
  0xF0, 0x1F, 0xBE, 0x07, 0xE7, 0xE0, 0xFC, 0xFE, 0x7F, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xC7, 0xE0, 0x0F, 0x3F,
  0xC0, 0x3D, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x83, 0xEF, 0xFC, 0x0F,
  0xBF, 0xE0, 0x3E, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xF0, 0x7F, 0x9F, 0x0F,
  0xFD, 0xE1, 0xFF, 0xFE, 0x3F, 0xDF, 0xE3, 0xF0, 0xFE, 0x7E, 0x07, 0xE7,
  0xE0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF8, 0xFE, 0x7F,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x3F, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0x8F, 0x0F,
  0xBF, 0x0F, 0x7F, 0x1F, 0x7F, 0x1F, 0xFE, 0x1F, 0xF1, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xF8, 0x70, 0xF8, 0x08, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF9, 0x00,
  0x7C, 0xE0, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x23, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0x01, 0xF1, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F,
  0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x03, 0xDF, 0x80,
  0x3D, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x7F,
  0x03, 0xEF, 0xC1, 0xFC, 0x1F, 0xBF, 0x0F, 0xF0, 0x7C, 0x7C, 0x3F, 0xC3,
  0xF1, 0xF0, 0xFF, 0x0F, 0x87, 0xC7, 0xBC, 0x7E, 0x1F, 0x1E, 0xF1, 0xF0,
  0x7C, 0xFB, 0xC7, 0xC1, 0xF3, 0xCF, 0x3F, 0x07, 0xDF, 0x3C, 0xF8, 0x1F,
  0x78, 0xF7, 0xE0, 0x7D, 0xE3, 0xDF, 0x01, 0xFF, 0x8F, 0x7C, 0x07, 0xBC,
  0x3F, 0xE0, 0x1E, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF1,
  0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0x80, 0x07, 0xEF,
  0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x87, 0xE0, 0x7F, 0x07,
  0xE0, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F,
  0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x6F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xE0,
};

const GFXglyph NotoSans_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 28, 11, 0, -27 },
  { 43, 14, 10, 17, 4, -27 },
  { 61, 24, 27, 25, 1, -27 },
  { 142, 20, 31, 21, 1, -29 },
  { 220, 29, 28, 33, 2, -28 },
  { 322, 26, 28, 27, 1, -28 },
  { 413, 6, 10, 10, 4, -27 },
  { 421, 15, 33, 13, 1, -27 },
  { 483, 15, 34, 13, -3, -28 },
  { 547, 18, 18, 21, 3, -29 },
  { 588, 18, 19, 22, 2, -23 },
  { 631, 9, 9, 11, -2, -4 },
  { 642, 10, 5, 12, 1, -13 },
  { 649, 7, 7, 11, 0, -6 },
  { 656, 21, 27, 16, -2, -27 },
  { 727, 20, 28, 21, 1, -28 },
  { 797, 16, 27, 21, 3, -27 },
  { 851, 21, 28, 21, -1, -28 },
  { 925, 20, 28, 21, 0, -28 },
  { 995, 20, 27, 21, 0, -27 },
  { 1063, 21, 27, 21, 0, -27 },
  { 1134, 19, 28, 21, 2, -28 },
  { 1201, 22, 27, 21, 1, -27 },
  { 1276, 20, 28, 21, 1, -28 },
  { 1346, 18, 28, 21, 2, -28 },
  { 1409, 10, 22, 11, 0, -21 },
  { 1437, 12, 26, 11, -2, -21 },
  { 1476, 18, 20, 22, 2, -24 },
  { 1521, 18, 11, 22, 2, -19 },
  { 1546, 18, 20, 22, 2, -24 },
  { 1591, 16, 29, 17, 3, -28 },
  { 1649, 30, 30, 33, 2, -27 },
  { 1762, 24, 27, 24, -2, -27 },
  { 1843, 22, 27, 24, 1, -27 },
  { 1918, 23, 28, 23, 2, -28 },
  { 1999, 24, 27, 26, 1, -27 },
  { 2080, 21, 27, 21, 1, -27 },
  { 2151, 21, 27, 20, 1, -27 },
  { 2222, 24, 28, 26, 2, -28 },
  { 2306, 26, 27, 27, 1, -27 },
  { 2394, 18, 27, 15, -1, -27 },
  { 2455, 19, 35, 13, -6, -27 },
  { 2539, 26, 27, 23, 1, -27 },
  { 2627, 16, 27, 20, 1, -27 },
  { 2681, 33, 27, 33, 1, -27 },
  { 2793, 28, 27, 29, 1, -27 },
  { 2888, 25, 28, 28, 2, -28 },
  { 2976, 22, 27, 23, 1, -27 },
  { 3051, 25, 34, 28, 2, -28 },
  { 3158, 22, 27, 24, 1, -27 },
  { 3233, 20, 28, 20, 1, -28 },
  { 3303, 20, 27, 20, 3, -27 },
  { 3371, 24, 27, 26, 3, -27 },
  { 3452, 23, 27, 22, 3, -27 },
  { 3530, 35, 27, 34, 3, -27 },
  { 3649, 28, 27, 23, -2, -27 },
  { 3744, 22, 27, 21, 3, -27 },
  { 3819, 23, 27, 20, -1, -27 },
  { 3897, 16, 33, 13, -1, -27 },
  { 3963, 9, 27, 16, 4, -27 },
  { 3994, 16, 33, 13, -3, -27 },
  { 4060, 19, 17, 21, 1, -27 },
  { 4101, 15, 3, 15, -3, 3 },
  { 4107, 7, 6, 12, 6, -29 },
  { 4113, 20, 21, 23, 2, -21 },
  { 4166, 20, 29, 23, 1, -29 },
  { 4239, 17, 21, 18, 2, -21 },
  { 4284, 22, 29, 23, 2, -29 },
  { 4364, 18, 21, 21, 2, -21 },
  { 4412, 22, 38, 14, -4, -29 },
  { 4517, 21, 30, 23, 1, -21 },
  { 4596, 20, 29, 23, 1, -29 },
  { 4669, 11, 29, 11, 1, -29 },
  { 4709, 17, 38, 11, -5, -29 },
  { 4790, 22, 29, 22, 1, -29 },
  { 4870, 11, 29, 11, 1, -29 },
  { 4910, 31, 21, 34, 1, -21 },
  { 4992, 20, 21, 23, 1, -21 },
  { 5045, 19, 21, 22, 2, -21 },
  { 5095, 22, 30, 23, -1, -21 },
  { 5178, 20, 30, 23, 2, -21 },
  { 5253, 16, 21, 16, 1, -21 },
  { 5295, 17, 21, 18, 0, -21 },
  { 5340, 14, 25, 16, 2, -25 },
  { 5384, 20, 21, 23, 2, -21 },
  { 5437, 20, 21, 19, 2, -21 },
  { 5490, 30, 21, 30, 2, -21 },
  { 5569, 24, 21, 20, -2, -21 },
  { 5632, 25, 30, 20, -3, -21 },
  { 5726, 19, 21, 18, -1, -21 },
  { 5776, 16, 33, 13, 0, -27 },
  { 5842, 5, 38, 21, 8, -29 },
  { 5866, 16, 33, 13, -2, -27 },
  { 5932, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_BOLDITALIC38PT7B_H_
