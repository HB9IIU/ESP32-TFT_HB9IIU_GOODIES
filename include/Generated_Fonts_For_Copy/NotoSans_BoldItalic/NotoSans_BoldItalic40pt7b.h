#ifndef _NOTOSANS_BOLDITALIC40PT7B_H_
#define _NOTOSANS_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xC0,
  0x08, 0x00, 0x7E, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F,
  0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x7C, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xBC, 0x1F, 0x9C, 0x20, 0xFC, 0xE0, 0x07, 0xE6, 0x00, 0x3F,
  0x70, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xEF, 0xC0, 0x06,
  0x7E, 0x00, 0x73, 0xF3, 0x03, 0x9F, 0x9F, 0x1F, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0xE0,
  0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0x81, 0xFF, 0xE0, 0x3E, 0x03, 0xE7, 0xC0,
  0x78, 0x0F, 0x8F, 0x81, 0xF0, 0x1F, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x1F,
  0x00, 0x78, 0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0xF8, 0x03, 0xE1, 0xF3, 0xE0,
  0x07, 0xC7, 0xC7, 0x82, 0x0F, 0x8F, 0x9E, 0x7F, 0x9F, 0x3E, 0x7D, 0xFF,
  0x9F, 0xFD, 0xF7, 0xFF, 0x3F, 0xF3, 0xCF, 0xFF, 0x3F, 0xCF, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x01, 0xE3, 0xE1, 0xF0,
  0x07, 0xC7, 0xC3, 0xE0, 0x1F, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x1F, 0x00,
  0xF0, 0x3E, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x3E,
  0x00, 0xFF, 0xC0, 0x78, 0x01, 0xFF, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x01, 0xF8, 0x7F, 0xF0, 0x7E, 0x3F, 0xFF, 0x0F, 0xC7, 0xF7, 0xF3, 0xF1,
  0xF8, 0x7E, 0x7E, 0x3F, 0x0F, 0xFF, 0x8F, 0xE0, 0xFF, 0xE1, 0xF8, 0x0F,
  0xF8, 0x3F, 0x81, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0x80, 0xFF, 0xC3,
  0xF8, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1, 0xE3, 0xC0, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x20, 0x78, 0x03,
  0x87, 0x80, 0x7E, 0x78, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x10, 0xFF, 0x80, 0x3F, 0x3C,
  0x07, 0xF3, 0xC0, 0x1E, 0x3E, 0x00, 0xC3, 0xE0, 0x04, 0x1F, 0x00, 0x01,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFC, 0x3E,
  0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x3F, 0x3F,
  0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3,
  0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFE, 0xFC,
  0xF1, 0xF8, 0xC3, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0x87, 0xF0, 0x3C, 0x0F, 0xC0, 0x40, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0E, 0x07, 0xE0, 0x20, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x30, 0x03, 0xF8, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBE,
  0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0x7E, 0x07,
  0xC1, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x18, 0x03, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x82, 0x00,
  0xFD, 0xFE, 0x07, 0xDF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xE1,
  0xF8, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x8F,
  0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFF, 0x7F,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x87, 0xE0, 0xFC,
  0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x83, 0xF0,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F, 0x81, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFF,
  0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0xFC, 0x3F, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x3F, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0xE7, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xC1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE0, 0xF8, 0x04, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xFC, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x01, 0xFC, 0x1E, 0x3E, 0x07,
  0xFF, 0x1F, 0x3C, 0x1F, 0xFF, 0x1F, 0x7C, 0x3F, 0xFE, 0x1F, 0x78, 0x7E,
  0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF0, 0xF8,
  0x3C, 0x1F, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x7C, 0x1E, 0xF1, 0xF0,
  0x7C, 0x3E, 0xF1, 0xF0, 0x7C, 0x3C, 0xF0, 0xF0, 0xFC, 0x7C, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF8, 0xFF, 0xBF, 0xF0, 0xF8, 0x7F, 0x9F, 0xE0, 0x78, 0x3E,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x02, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x3E, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xDF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x3F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03,
  0xF8, 0x7E, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F,
  0x03, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3E, 0x0F,
  0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x60, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0x1F, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xF0, 0xFC, 0x1F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xE0, 0xF0, 0x3F, 0xC0, 0x08, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0xF9, 0xF8, 0x1F, 0xF9, 0xFC, 0x1F, 0xFC, 0xFE, 0x0F, 0xFE,
  0x7F, 0x07, 0xFF, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFF, 0x01, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x07,
  0xEF, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xBE,
  0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xEF, 0x00, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x1E, 0x7C, 0x0F, 0xBE, 0x0F, 0xBF, 0x07, 0xEF, 0x83,
  0xCF, 0xC1, 0xF3, 0xE1, 0xF3, 0xE0, 0x7C, 0xF8, 0x78, 0xF8, 0x1F, 0x3E,
  0x3E, 0x7E, 0x0F, 0xCF, 0x8F, 0x1F, 0x83, 0xF1, 0xE7, 0xC7, 0xE0, 0xF8,
  0x79, 0xE1, 0xF0, 0x3E, 0x1E, 0xF8, 0x7C, 0x0F, 0x87, 0xBC, 0x3F, 0x07,
  0xE1, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F, 0x83, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8,
  0x1F, 0x07, 0xF0, 0x3E, 0x07, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x81, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x01,
  0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C,
  0x0F, 0xBF, 0x03, 0xF0, 0x3E, 0xFC, 0x0F, 0xC0, 0xF9, 0xF0, 0x3E, 0x03,
  0xE7, 0xE0, 0xF8, 0x1F, 0x9F, 0x87, 0xE0, 0x7E, 0x3E, 0x1F, 0x81, 0xF8,
  0xFC, 0x7E, 0x07, 0xC3, 0xF1, 0xF0, 0x1F, 0x07, 0xC7, 0xC0, 0xFC, 0x1F,
  0xBF, 0x03, 0xF0, 0x7E, 0xFC, 0x0F, 0x80, 0xFB, 0xF0, 0x3E, 0x03, 0xFF,
  0x80, 0xF8, 0x0F, 0xFE, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0x7F, 0xE0,
  0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x3F,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFE, 0x07,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE1, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0x81,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xE7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x70, 0x7F, 0x00,
  0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC2, 0x00, 0x7E, 0x18, 0x07, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x00,
  0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F,
  0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0xF8, 0x03, 0xF0, 0x07,
  0xEF, 0x80, 0x7F, 0x00, 0xFC, 0xF8, 0x07, 0xF0, 0x0F, 0xCF, 0x80, 0x7F,
  0x01, 0xF8, 0xF8, 0x0F, 0xF0, 0x1F, 0x8F, 0x80, 0xFF, 0x01, 0xF0, 0xF8,
  0x1F, 0xF0, 0x3F, 0x0F, 0x81, 0xEF, 0x03, 0xF0, 0xF8, 0x3E, 0xF0, 0x7E,
  0x0F, 0x83, 0xEF, 0x07, 0xE0, 0xF8, 0x7C, 0xF0, 0xFC, 0x0F, 0x87, 0xCF,
  0x0F, 0xC0, 0xF8, 0xFC, 0xF0, 0xF8, 0x0F, 0x8F, 0x8F, 0x1F, 0x80, 0xF8,
  0xF8, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0xBF, 0x00, 0xF9, 0xF0, 0xFB, 0xF0,
  0x0F, 0xBE, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0xF7, 0xE0, 0x0F, 0xBC, 0x0F,
  0x7C, 0x00, 0xFF, 0xC0, 0xF7, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0x7E, 0x07,
  0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x80,
  0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x3C, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xE7,
  0x80, 0x1F, 0xF8, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xFC,
  0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x01, 0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC,
  0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xDF, 0x07, 0xFE, 0xF8,
  0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x7E, 0xFF, 0x03, 0xEF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0xFE, 0x3F,
  0xFF, 0xF1, 0xF7, 0xFF, 0x0F, 0xBF, 0xF0, 0x78, 0x7E, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xE0, 0x47,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x04,
  0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01,
  0xF9, 0xF8, 0x0F, 0xFB, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1,
  0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0xF8, 0x03,
  0xF9, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFC, 0x7E, 0x7E, 0x07, 0xDF, 0xC0, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0x81, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0x1F, 0xE0, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x04, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xF9, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x83, 0xF8, 0x7E, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x82, 0x00, 0xFE, 0x0E, 0x07, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x7E, 0xFF,
  0x83, 0xEF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0xFC, 0x7F,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7C, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x09, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F,
  0x8F, 0xC0, 0x7E, 0x07, 0xCF, 0xF0, 0xFF, 0x83, 0xEF, 0xFC, 0xFF, 0xC1,
  0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFC,
  0x7F, 0x07, 0xF0, 0x7E, 0x3F, 0x03, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x1F,
  0x9F, 0x80, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0x80,
  0xFC, 0xFC, 0x0F, 0xC0, 0x7C, 0x7E, 0x07, 0xE0, 0x7E, 0x3F, 0x03, 0xF0,
  0x3F, 0x3F, 0x01, 0xF8, 0x1F, 0x9F, 0x80, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC,
  0x07, 0xC7, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0x8F, 0xE0, 0x7C, 0xFF, 0x83,
  0xEF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7C, 0x7E, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xF7,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03,
  0xE3, 0xF0, 0x07, 0xDF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0xCF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xF7, 0xFC, 0x07,
  0xE7, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F, 0xE7,
  0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC3, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0xC7, 0xFB, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x8F, 0x87, 0xCF, 0xC3,
  0xEF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xC8, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0xC3, 0x87, 0xE0, 0x21, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x80, 0x3F, 0x3C, 0x1F, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xEC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xF3, 0xFE, 0x3F, 0xFD, 0xF0, 0xFF,
  0xCF, 0x07, 0xFC, 0xF8, 0x1F, 0xC7, 0xC0, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0,
  0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x7C, 0x0F, 0xE0,
  0x7E, 0x7C, 0x0F, 0xE0, 0x7C, 0x7C, 0x1F, 0xE0, 0xFC, 0x7C, 0x1F, 0xE0,
  0xFC, 0x7C, 0x3F, 0xE1, 0xF8, 0x7C, 0x3D, 0xE1, 0xF8, 0x7C, 0x7D, 0xE3,
  0xF0, 0x7C, 0x79, 0xE3, 0xF0, 0x7C, 0x79, 0xE7, 0xE0, 0x7C, 0xF9, 0xE7,
  0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0x7D, 0xF1, 0xEF, 0xC0, 0x7D, 0xE1, 0xEF,
  0x80, 0x7D, 0xE1, 0xEF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07,
  0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xF8,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 30, 11, 0, -29 },
  { 50, 15, 11, 18, 4, -29 },
  { 71, 25, 29, 26, 1, -29 },
  { 162, 21, 32, 22, 1, -30 },
  { 246, 31, 29, 34, 2, -29 },
  { 359, 27, 29, 28, 1, -29 },
  { 457, 7, 11, 10, 4, -29 },
  { 467, 15, 35, 14, 1, -29 },
  { 533, 15, 35, 14, -3, -29 },
  { 599, 20, 20, 22, 3, -31 },
  { 649, 20, 20, 23, 2, -24 },
  { 699, 10, 10, 11, -2, -5 },
  { 712, 11, 5, 13, 1, -13 },
  { 719, 7, 7, 11, 0, -6 },
  { 726, 22, 29, 17, -2, -29 },
  { 806, 21, 29, 22, 1, -29 },
  { 883, 15, 29, 22, 4, -29 },
  { 938, 22, 29, 22, -1, -29 },
  { 1018, 22, 29, 22, 0, -29 },
  { 1098, 22, 29, 22, 0, -29 },
  { 1178, 21, 29, 22, 1, -29 },
  { 1255, 21, 29, 22, 2, -29 },
  { 1332, 22, 29, 22, 2, -29 },
  { 1412, 21, 29, 22, 1, -29 },
  { 1489, 19, 29, 22, 2, -29 },
  { 1558, 11, 23, 11, 0, -22 },
  { 1590, 13, 27, 11, -2, -22 },
  { 1634, 20, 21, 23, 2, -25 },
  { 1687, 20, 12, 23, 2, -20 },
  { 1717, 20, 21, 23, 2, -25 },
  { 1770, 17, 30, 18, 3, -29 },
  { 1834, 32, 33, 34, 2, -29 },
  { 1966, 25, 29, 25, -2, -29 },
  { 2057, 23, 29, 25, 1, -29 },
  { 2141, 24, 29, 25, 2, -29 },
  { 2228, 25, 29, 27, 1, -29 },
  { 2319, 22, 29, 22, 1, -29 },
  { 2399, 22, 29, 21, 1, -29 },
  { 2479, 25, 29, 28, 2, -29 },
  { 2570, 27, 29, 28, 1, -29 },
  { 2668, 19, 29, 15, -1, -29 },
  { 2737, 20, 37, 13, -6, -29 },
  { 2830, 27, 29, 25, 1, -29 },
  { 2928, 17, 29, 21, 1, -29 },
  { 2990, 34, 29, 35, 1, -29 },
  { 3114, 30, 29, 30, 1, -29 },
  { 3223, 26, 29, 29, 2, -29 },
  { 3318, 24, 29, 24, 1, -29 },
  { 3405, 26, 36, 29, 2, -29 },
  { 3522, 23, 29, 25, 1, -29 },
  { 3606, 21, 29, 21, 1, -29 },
  { 3683, 21, 29, 21, 3, -29 },
  { 3760, 25, 29, 28, 3, -29 },
  { 3851, 23, 29, 24, 4, -29 },
  { 3935, 36, 29, 36, 4, -29 },
  { 4066, 30, 29, 24, -2, -29 },
  { 4175, 22, 29, 23, 4, -29 },
  { 4255, 24, 29, 21, -1, -29 },
  { 4342, 17, 35, 13, -1, -29 },
  { 4417, 10, 29, 17, 4, -29 },
  { 4454, 17, 35, 13, -3, -29 },
  { 4529, 20, 19, 22, 1, -29 },
  { 4577, 17, 2, 16, -4, 4 },
  { 4582, 8, 7, 13, 6, -31 },
  { 4589, 21, 22, 24, 2, -22 },
  { 4647, 21, 30, 24, 1, -30 },
  { 4726, 18, 22, 19, 2, -22 },
  { 4776, 23, 30, 24, 2, -30 },
  { 4863, 19, 22, 22, 2, -22 },
  { 4916, 23, 41, 15, -4, -31 },
  { 5034, 22, 32, 24, 1, -22 },
  { 5122, 21, 30, 24, 1, -30 },
  { 5201, 12, 30, 12, 1, -30 },
  { 5246, 18, 40, 12, -5, -30 },
  { 5336, 24, 30, 23, 1, -30 },
  { 5426, 12, 30, 12, 1, -30 },
  { 5471, 33, 22, 36, 1, -22 },
  { 5562, 21, 22, 24, 1, -22 },
  { 5620, 20, 22, 23, 2, -22 },
  { 5675, 23, 32, 24, -1, -22 },
  { 5767, 21, 32, 24, 2, -22 },
  { 5851, 17, 22, 17, 1, -22 },
  { 5898, 18, 22, 19, 0, -22 },
  { 5948, 15, 26, 16, 2, -26 },
  { 5997, 21, 22, 24, 2, -22 },
  { 6055, 21, 22, 20, 2, -22 },
  { 6113, 32, 22, 32, 2, -22 },
  { 6201, 25, 22, 21, -2, -22 },
  { 6270, 26, 32, 21, -3, -22 },
  { 6374, 20, 22, 19, -1, -22 },
  { 6429, 17, 35, 14, 0, -29 },
  { 6504, 4, 39, 22, 9, -30 },
  { 6524, 16, 35, 14, -2, -29 },
  { 6594, 20, 6, 23, 2, -17 },
};

const GFXfont NotoSans_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_BOLDITALIC40PT7B_H_
