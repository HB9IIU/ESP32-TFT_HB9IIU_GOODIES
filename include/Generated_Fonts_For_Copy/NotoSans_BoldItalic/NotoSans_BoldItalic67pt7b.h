#ifndef _NOTOSANS_BOLDITALIC67PT7B_H_
#define _NOTOSANS_BOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xC1,
  0xFF, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x3C, 0xFE, 0x01, 0xFF, 0xCF, 0x81, 0xC0, 0x3F, 0xF1, 0xF0, 0x08, 0x07,
  0xFE, 0x3E, 0x00, 0x00, 0xFF, 0x87, 0x80, 0x00, 0x1F, 0xF8, 0xF0, 0x00,
  0x03, 0xFF, 0x3E, 0x00, 0x00, 0x7F, 0xF7, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xEF,
  0xFF, 0x00, 0x00, 0x7C, 0xFF, 0xE0, 0x00, 0x0F, 0x8F, 0xFC, 0x00, 0x01,
  0xF1, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0xF1, 0x00, 0x07, 0x87, 0xFE, 0x38,
  0x01, 0xF1, 0xFF, 0x87, 0xE0, 0x3E, 0x7F, 0xF0, 0xFF, 0xF7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x9F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x81, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFE, 0x3F, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0x8F, 0xFF, 0xE7, 0xFC, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xC7, 0xF1, 0xFF, 0x0F,
  0xF1, 0xFF, 0xF1, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xF8, 0x7F, 0x8F, 0xF8,
  0x3F, 0xC0, 0x30, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xFB, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x20, 0x03, 0xF8, 0x00, 0x38, 0x03, 0xF8, 0x00,
  0x3E, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0xE3, 0xF0, 0x00,
  0xFF, 0xFB, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x3E,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x0F, 0xF9, 0xFC, 0x00,
  0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0xF1, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x03, 0x80, 0x7F, 0x80,
  0x01, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F, 0xCF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xDF, 0xF0, 0xFF, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFC, 0x1F, 0xF0,
  0x1F, 0x07, 0xFE, 0x01, 0x80, 0xFF, 0xC0, 0x20, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x0E, 0x00,
  0x0F, 0xFC, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x0F, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x03, 0xFF,
  0x8E, 0x00, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x1F, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0xE0,
  0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xBE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0xDF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x02, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF,
  0xE0, 0x3F, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x07,
  0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x1E, 0x00, 0x3F, 0xF0, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x03,
  0xFD, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x03, 0xFC,
  0x01, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xEF, 0xF0,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xBF, 0x81, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x3F, 0x81, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0x87, 0xFC, 0x3F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xFF, 0xE7, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0x1F,
  0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x10, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0E, 0x00, 0x3F, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xFF, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x3C, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE7,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xFC,
  0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x0F,
  0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xC7,
  0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFE, 0x01, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x7F, 0x83,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFE,
  0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xEF, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xF7,
  0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xF7, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xE3, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x0C, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x07, 0xFF, 0x07,
  0x80, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0x1F,
  0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xFE,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFD, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC,
  0x07, 0xF9, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0,
  0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0x9F, 0xF0, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFF,
  0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF, 0xF1, 0xFE, 0x01,
  0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0xFF, 0x80, 0x1F, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x07,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xFF,
  0x80, 0x1F, 0xFB, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xF1,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0xE0,
  0x07, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xE0,
  0x7F, 0xF8, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0x7F,
  0xF0, 0x07, 0x81, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE7, 0xF0, 0x00,
  0x1F, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F,
  0xF9, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x02, 0x07, 0xFF,
  0x00, 0x06, 0x03, 0xFF, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x78, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0xF1, 0xFE, 0x00, 0x7F,
  0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFD, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x08, 0x00,
  0x03, 0xFF, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFC,
  0x01, 0xFF, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x02, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x01, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xF0,
  0x00, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xFC, 0x01, 0xFE, 0x7F,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xFF,
  0x80, 0x00, 0x7F, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x03,
  0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0xFC,
  0x00, 0x3F, 0xE7, 0xFF, 0xF0, 0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xEF, 0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xCF, 0xFE,
  0x01, 0xFF, 0x7F, 0xF8, 0x07, 0xFB, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x40, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0xFC, 0x0F, 0xFC, 0x00,
  0xE0, 0x7F, 0xE0, 0x01, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0x00, 0x01, 0xFF, 0x8C, 0x00, 0x1F,
  0xFC, 0x7C, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xEF,
  0xF8, 0x0F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF,
  0x87, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0x80, 0xFE, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xE0,
  0x7F, 0x81, 0xFE, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF,
  0xC0, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0x8F, 0xE1,
  0xFF, 0x80, 0x7F, 0x87, 0xF8, 0xFE, 0x1F, 0xF8, 0x07, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0xFE, 0x3F, 0xF0, 0x07, 0xF8, 0xFF,
  0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0xE0, 0x07, 0xF9,
  0xFE, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0xC0, 0x07,
  0xF9, 0xFC, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x80,
  0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x80, 0x00, 0xFF, 0xF8, 0x80, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_BoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 20, 49, 19, 1, -48 },
  { 124, 24, 17, 30, 7, -48 },
  { 175, 43, 48, 43, 1, -48 },
  { 433, 35, 55, 37, 2, -51 },
  { 674, 51, 50, 57, 4, -49 },
  { 993, 45, 50, 47, 2, -49 },
  { 1275, 11, 17, 17, 7, -48 },
  { 1299, 25, 59, 23, 2, -48 },
  { 1484, 25, 60, 23, -5, -49 },
  { 1672, 32, 32, 37, 6, -51 },
  { 1800, 32, 33, 38, 4, -40 },
  { 1932, 16, 17, 19, -3, -8 },
  { 1966, 19, 8, 22, 1, -22 },
  { 1985, 11, 11, 19, 1, -10 },
  { 2001, 36, 48, 28, -3, -48 },
  { 2217, 34, 50, 37, 2, -49 },
  { 2430, 27, 48, 37, 6, -48 },
  { 2592, 38, 49, 37, -2, -49 },
  { 2825, 36, 50, 37, 0, -49 },
  { 3050, 37, 48, 37, -1, -48 },
  { 3272, 36, 49, 37, 1, -48 },
  { 3493, 35, 50, 37, 3, -49 },
  { 3712, 37, 48, 37, 3, -48 },
  { 3934, 35, 50, 37, 2, -49 },
  { 4153, 33, 50, 37, 3, -49 },
  { 4360, 17, 38, 19, 1, -37 },
  { 4441, 22, 46, 19, -4, -37 },
  { 4568, 32, 35, 38, 4, -42 },
  { 4708, 32, 20, 38, 4, -34 },
  { 4788, 32, 35, 38, 4, -42 },
  { 4928, 28, 50, 31, 5, -49 },
  { 5103, 54, 54, 57, 3, -48 },
  { 5468, 42, 48, 42, -4, -48 },
  { 5720, 39, 48, 42, 2, -48 },
  { 5954, 40, 50, 41, 4, -49 },
  { 6204, 41, 48, 45, 2, -48 },
  { 6450, 37, 48, 36, 2, -48 },
  { 6672, 37, 48, 36, 2, -48 },
  { 6894, 42, 50, 46, 4, -49 },
  { 7157, 45, 48, 47, 2, -48 },
  { 7427, 31, 48, 26, -2, -48 },
  { 7613, 34, 62, 22, -11, -48 },
  { 7877, 45, 48, 41, 2, -48 },
  { 8147, 28, 48, 35, 2, -48 },
  { 8315, 57, 48, 59, 2, -48 },
  { 8657, 49, 48, 51, 2, -48 },
  { 8951, 43, 50, 49, 4, -49 },
  { 9220, 39, 48, 41, 2, -48 },
  { 9454, 43, 60, 49, 4, -49 },
  { 9777, 38, 48, 42, 2, -48 },
  { 10005, 35, 50, 36, 1, -49 },
  { 10224, 35, 48, 36, 5, -48 },
  { 10434, 42, 49, 46, 5, -48 },
  { 10692, 40, 48, 40, 6, -48 },
  { 10932, 60, 48, 60, 6, -48 },
  { 11292, 50, 48, 41, -4, -48 },
  { 11592, 38, 48, 38, 6, -48 },
  { 11820, 41, 48, 36, -2, -48 },
  { 12066, 28, 59, 22, -1, -48 },
  { 12273, 16, 48, 28, 7, -48 },
  { 12369, 27, 59, 22, -4, -48 },
  { 12569, 34, 31, 37, 1, -48 },
  { 12701, 28, 5, 27, -6, 6 },
  { 12719, 14, 10, 22, 10, -51 },
  { 12737, 36, 38, 40, 3, -37 },
  { 12908, 36, 52, 40, 1, -51 },
  { 13142, 30, 38, 32, 3, -37 },
  { 13285, 39, 52, 40, 3, -51 },
  { 13539, 33, 38, 37, 3, -37 },
  { 13696, 40, 67, 25, -7, -51 },
  { 14031, 38, 53, 40, 1, -37 },
  { 14283, 36, 51, 40, 1, -51 },
  { 14513, 21, 51, 20, 1, -51 },
  { 14647, 31, 67, 20, -9, -51 },
  { 14907, 40, 51, 38, 1, -51 },
  { 15162, 21, 51, 20, 1, -51 },
  { 15296, 56, 37, 61, 1, -37 },
  { 15555, 36, 37, 40, 1, -37 },
  { 15722, 33, 38, 39, 3, -37 },
  { 15879, 39, 53, 40, -2, -37 },
  { 16138, 36, 53, 40, 3, -37 },
  { 16377, 30, 37, 28, 1, -37 },
  { 16516, 29, 38, 32, 1, -37 },
  { 16654, 26, 45, 27, 3, -44 },
  { 16801, 35, 38, 40, 4, -37 },
  { 16968, 35, 37, 34, 3, -37 },
  { 17130, 52, 37, 53, 4, -37 },
  { 17371, 42, 37, 36, -3, -37 },
  { 17566, 43, 53, 35, -5, -37 },
  { 17851, 33, 37, 31, -1, -37 },
  { 18004, 28, 59, 24, 0, -48 },
  { 18211, 7, 66, 37, 15, -51 },
  { 18269, 27, 59, 24, -3, -48 },
  { 18469, 32, 11, 38, 4, -29 },
};

const GFXfont NotoSans_BoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_BOLDITALIC67PT7B_H_
