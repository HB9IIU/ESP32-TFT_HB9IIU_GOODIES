#ifndef _NOTOSANS_BOLDITALIC61PT7B_H_
#define _NOTOSANS_BOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xF9, 0xFE, 0x1F, 0xE7,
  0xF8, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0,
  0x7F, 0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC7, 0x87, 0x81, 0xFF, 0x1F, 0x02, 0x03, 0xFE, 0x3C, 0x00,
  0x07, 0xFC, 0x78, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x1F, 0xF9, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xF3, 0xFF, 0x00, 0x01,
  0xE3, 0xFE, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x0F, 0x8F, 0xF9, 0x00, 0x1E,
  0x1F, 0xF3, 0x80, 0x3C, 0x7F, 0xC7, 0xC0, 0x79, 0xFF, 0x8F, 0xFE, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x3F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0x03, 0xFC, 0x3F, 0xC7, 0xF1, 0xFF, 0x83, 0xF8, 0x7F, 0x1F, 0xC7,
  0xFF, 0xC7, 0xF1, 0xFE, 0x7F, 0x1F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xCF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x1F, 0xC1,
  0xFC, 0x1F, 0xE1, 0xFC, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x3F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x08, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x7F, 0xE1, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF9, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFE, 0x3F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x80, 0x1F, 0xC0, 0x07, 0x00, 0xFE, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xFC, 0x3F, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0E, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0xCF, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x3E,
  0x0F, 0xF0, 0x00, 0xE0, 0x7F, 0x80, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFC, 0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFB,
  0xFE, 0x7F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xC7,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE,
  0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x7F,
  0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0x7F, 0x87, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0x7E, 0x1F, 0xF0,
  0x3C, 0x0F, 0xF8, 0x0C, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x3F, 0xF0, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x18, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x20, 0x00,
  0x03, 0xFF, 0x1C, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x20,
  0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x06, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0x03, 0xFD,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x0F,
  0xF8, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xF9,
  0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F,
  0xC0, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0xF8, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0x87,
  0xFF, 0x3E, 0x00, 0xFF, 0x88, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x83, 0xF8, 0x7F,
  0x80, 0x7F, 0xFF, 0xE1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x7E, 0x3F,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xDF,
  0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0xFC, 0x07, 0xF7,
  0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xFB, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFB,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFD, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFE,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xBF, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x9F, 0x83, 0xF8, 0x07, 0xF0, 0x1F,
  0xCF, 0xC1, 0xFC, 0x03, 0xF8, 0x0F, 0xE7, 0xE0, 0xFE, 0x03, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x81, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xF8, 0x00,
  0x38, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x00, 0x7F, 0xFE,
  0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x04, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xE0, 0x3F, 0xFC, 0x00, 0x06, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x80,
  0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xBF, 0xE0,
  0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xDF, 0x80, 0x03, 0xFB, 0xFC, 0x03, 0xFD,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x03,
  0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8,
  0x07, 0xF9, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x3F,
  0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x1F, 0xC0,
  0x7F, 0x1F, 0xF0, 0x0F, 0xF1, 0xFC, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x1F, 0xE1, 0xFE, 0x01, 0xFF,
  0x1F, 0xC1, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFC, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFE, 0xFF, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xDF,
  0xE0, 0x03, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFD, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFF,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x38, 0x03, 0xFF, 0x00, 0x08, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x7F, 0xE0, 0xF0,
  0x00, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF3, 0xF8,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x8F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC1, 0xFC,
  0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x00, 0x1F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x7F, 0x00, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x03, 0xFF,
  0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF,
  0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0xC0, 0x0F, 0xFC, 0x3F, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x07, 0xF9, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xF0, 0x0F,
  0xE7, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFC, 0x1F, 0xFC, 0x01, 0x87, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x83, 0xFF, 0x80, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xEF,
  0xF8, 0x03, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0x00, 0x1F,
  0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xF3, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8,
  0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xCF, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xF9, 0xFF, 0x0F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x04, 0x3F, 0xF8, 0x00, 0xC0, 0xFF, 0xF0, 0x7E, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xF0,
  0x03, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xBF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x02, 0x00, 0x03, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF7, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x7E, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0xF0, 0x03, 0xFD,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xE3, 0xFF,
  0xFC, 0x07, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x3F, 0x9F, 0xFF, 0xC0, 0x3F,
  0xDF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0x07,
  0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF,
  0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0xE0,
  0x00, 0x3F, 0x8F, 0xFF, 0x00, 0x03, 0xF9, 0xFF, 0xF8, 0x00, 0x7F, 0xBF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0xF8, 0x00, 0xFF,
  0x3F, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0x00, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xFC, 0xFF,
  0x03, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x7F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x02, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF1, 0xFF, 0x80, 0xFE,
  0x7F, 0xE0, 0x3F, 0xDF, 0xFC, 0x07, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8,
  0x01, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x10, 0x00, 0x7F, 0xE3, 0x80,
  0x0F, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0xD0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0x00,
  0x3F, 0xFC, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F,
  0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xCF, 0xF8,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xCF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xFE, 0x03, 0xFE,
  0x3F, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFD, 0xF8, 0x0F, 0xF0,
  0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0xC3,
  0xFC, 0x0F, 0xCF, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xBF, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0x7F, 0x0F, 0xF8, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF0, 0x3F,
  0xC3, 0xF9, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xE3, 0xF8, 0xFF, 0x80, 0xFF,
  0x1F, 0xC7, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x8F, 0xE7, 0xFC, 0x01, 0xFC,
  0xFE, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0x81, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x13, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF2, 0x00, 0x03,
  0xFF, 0x88, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph NotoSans_BoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 45, 18, 1, -44 },
  { 103, 22, 16, 28, 6, -44 },
  { 147, 39, 44, 39, 1, -44 },
  { 362, 31, 50, 34, 2, -46 },
  { 556, 47, 45, 52, 3, -44 },
  { 821, 41, 45, 43, 2, -44 },
  { 1052, 10, 16, 16, 6, -44 },
  { 1072, 23, 54, 21, 2, -44 },
  { 1228, 23, 54, 21, -4, -44 },
  { 1384, 29, 30, 33, 5, -47 },
  { 1493, 30, 29, 35, 3, -36 },
  { 1602, 15, 15, 18, -3, -7 },
  { 1631, 17, 7, 20, 1, -20 },
  { 1646, 11, 10, 18, 0, -9 },
  { 1660, 33, 44, 26, -3, -44 },
  { 1842, 31, 45, 34, 2, -44 },
  { 2017, 25, 44, 34, 5, -44 },
  { 2155, 34, 44, 34, -1, -44 },
  { 2342, 33, 45, 34, 0, -44 },
  { 2528, 34, 44, 34, -1, -44 },
  { 2715, 33, 45, 34, 1, -44 },
  { 2901, 31, 45, 34, 3, -44 },
  { 3076, 34, 44, 34, 2, -44 },
  { 3263, 32, 45, 34, 2, -44 },
  { 3443, 30, 45, 34, 3, -44 },
  { 3612, 17, 35, 18, 0, -34 },
  { 3687, 20, 42, 18, -3, -34 },
  { 3792, 30, 32, 35, 3, -38 },
  { 3912, 30, 19, 35, 3, -31 },
  { 3984, 30, 32, 35, 3, -38 },
  { 4104, 25, 45, 28, 5, -44 },
  { 4245, 49, 50, 52, 3, -44 },
  { 4552, 39, 44, 38, -4, -44 },
  { 4767, 35, 44, 38, 2, -44 },
  { 4960, 36, 45, 37, 4, -44 },
  { 5163, 37, 44, 41, 2, -44 },
  { 5367, 33, 44, 33, 2, -44 },
  { 5549, 33, 44, 33, 2, -44 },
  { 5731, 37, 45, 42, 4, -44 },
  { 5940, 41, 44, 43, 2, -44 },
  { 6166, 29, 44, 23, -2, -44 },
  { 6326, 31, 57, 20, -10, -44 },
  { 6547, 41, 44, 37, 2, -44 },
  { 6773, 26, 44, 32, 2, -44 },
  { 6916, 52, 44, 54, 2, -44 },
  { 7202, 45, 44, 46, 2, -44 },
  { 7450, 39, 45, 45, 4, -44 },
  { 7670, 36, 44, 37, 2, -44 },
  { 7868, 39, 54, 45, 4, -44 },
  { 8132, 34, 44, 38, 2, -44 },
  { 8319, 32, 45, 32, 1, -44 },
  { 8499, 32, 44, 32, 5, -44 },
  { 8675, 39, 45, 42, 4, -44 },
  { 8895, 36, 44, 36, 5, -44 },
  { 9093, 55, 44, 55, 5, -44 },
  { 9396, 45, 44, 37, -3, -44 },
  { 9644, 34, 44, 34, 6, -44 },
  { 9831, 38, 44, 33, -2, -44 },
  { 10040, 25, 54, 20, -1, -44 },
  { 10209, 14, 44, 26, 7, -44 },
  { 10286, 25, 54, 20, -4, -44 },
  { 10455, 31, 29, 34, 1, -44 },
  { 10568, 26, 5, 24, -6, 5 },
  { 10585, 13, 10, 20, 9, -47 },
  { 10602, 32, 35, 36, 3, -34 },
  { 10742, 33, 47, 36, 1, -46 },
  { 10936, 27, 35, 30, 3, -34 },
  { 11055, 35, 47, 36, 3, -46 },
  { 11261, 29, 35, 34, 3, -34 },
  { 11388, 36, 62, 23, -6, -47 },
  { 11667, 34, 49, 36, 1, -34 },
  { 11876, 33, 46, 37, 1, -46 },
  { 12066, 19, 46, 18, 1, -46 },
  { 12176, 28, 61, 18, -8, -46 },
  { 12390, 37, 46, 35, 1, -46 },
  { 12603, 19, 46, 18, 1, -46 },
  { 12713, 51, 34, 55, 1, -34 },
  { 12930, 33, 34, 37, 1, -34 },
  { 13071, 30, 35, 36, 3, -34 },
  { 13203, 36, 49, 36, -2, -34 },
  { 13424, 32, 49, 36, 3, -34 },
  { 13620, 27, 34, 26, 1, -34 },
  { 13735, 27, 35, 29, 1, -34 },
  { 13854, 23, 41, 25, 3, -40 },
  { 13972, 33, 34, 37, 3, -33 },
  { 14113, 32, 33, 31, 3, -33 },
  { 14245, 47, 33, 48, 4, -33 },
  { 14439, 39, 33, 33, -3, -33 },
  { 14600, 39, 48, 32, -4, -33 },
  { 14834, 30, 33, 29, -1, -33 },
  { 14958, 26, 54, 22, 0, -44 },
  { 15134, 6, 60, 34, 14, -46 },
  { 15179, 25, 54, 22, -3, -44 },
  { 15348, 30, 11, 35, 3, -27 },
};

const GFXfont NotoSans_BoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_BOLDITALIC61PT7B_H_
