#ifndef _NOTOSANS_BOLDITALIC22PT7B_H_
#define _NOTOSANS_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC0, 0x00,
  0x0E, 0x3C, 0x78, 0x77, 0x77, 0x67, 0xE6, 0xE6, 0xCE, 0x03, 0x98, 0x0C,
  0xE0, 0x33, 0x01, 0xCC, 0x06, 0x70, 0xFF, 0xF3, 0xFF, 0xC3, 0x98, 0x0C,
  0xE1, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x19, 0xC0, 0xE6, 0x03, 0x98, 0x0C,
  0xE0, 0x01, 0x00, 0x60, 0x3F, 0x1F, 0xF3, 0xFC, 0xE4, 0x1D, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x06, 0xE8, 0xDD, 0xD7, 0xBF, 0xE7, 0xF8, 0x18,
  0x03, 0x00, 0x1C, 0x07, 0x1F, 0x07, 0x1D, 0xC3, 0x0C, 0xE3, 0x0E, 0x73,
  0x87, 0x3B, 0x83, 0x99, 0x99, 0xDD, 0xBE, 0x7D, 0xFF, 0x9D, 0xDD, 0xC0,
  0xCC, 0xE0, 0xC6, 0x70, 0xE7, 0x38, 0xE3, 0xB8, 0x60, 0xFC, 0xE0, 0x7C,
  0x07, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x81, 0xFC,
  0x07, 0xC0, 0x3F, 0x1D, 0xDE, 0xEE, 0x3B, 0xB8, 0xFC, 0xE1, 0xE3, 0xFF,
  0x8F, 0xFF, 0x1F, 0xDE, 0x77, 0x6E, 0xEC, 0x07, 0x0E, 0x1C, 0x1C, 0x38,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x60, 0x70, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x3C, 0x00,
  0x05, 0x01, 0x88, 0x63, 0xB8, 0xFF, 0xCF, 0xF1, 0xFD, 0xF8, 0xF7, 0x09,
  0xC0, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC3, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x39, 0xDC, 0xE6, 0x70, 0x7F, 0xF8,
  0x7F, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x0E, 0xE1, 0xFC, 0x3F,
  0x0F, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xEE, 0x39, 0xEF, 0x1F, 0xC3, 0xF0,
  0x03, 0x87, 0x8F, 0xCF, 0xEF, 0x73, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x18,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0x07, 0xC3, 0xFE, 0x1F,
  0xF1, 0x0F, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0xF8, 0x0F, 0x81, 0x1C, 0x00,
  0xE0, 0x0E, 0x81, 0xEE, 0x7C, 0xFF, 0xCF, 0xF0, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x3E, 0x07, 0xE0, 0xEE, 0x1D, 0xE1, 0xDC, 0x39, 0xC7, 0x1C, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80, 0x78, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xE0, 0x1E, 0x00,
  0xE0, 0x1E, 0x81, 0xEF, 0x7C, 0xFF, 0x87, 0xF0, 0x03, 0xE1, 0xFC, 0x7F,
  0x9E, 0x03, 0x80, 0xE0, 0x1D, 0xE7, 0x7E, 0xFB, 0xDE, 0x3B, 0x87, 0x70,
  0xEE, 0x3D, 0xEF, 0x1F, 0xE1, 0xF0, 0x3F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x83, 0xF8, 0xF7, 0x9C, 0x73,
  0x8E, 0x73, 0xCF, 0xF0, 0xF8, 0x3F, 0x8E, 0x7B, 0x87, 0x70, 0xEE, 0x1D,
  0xE7, 0xBF, 0xE3, 0xF8, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0xF7, 0x1F, 0xE3,
  0xFC, 0x7F, 0x9F, 0x7F, 0xCF, 0xF8, 0x07, 0x01, 0xC0, 0x79, 0x3E, 0x3F,
  0x87, 0xE0, 0x1C, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C, 0x0E,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE3, 0x87, 0x1C, 0x30,
  0x00, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x78, 0x7E, 0x3F, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x3E, 0x7F, 0xBF,
  0xE8, 0x70, 0x38, 0x38, 0x7C, 0x78, 0x38, 0x38, 0x1C, 0x00, 0x00, 0x07,
  0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0xF0, 0xF0, 0x70, 0x0E,
  0x38, 0x41, 0x9C, 0x7E, 0x66, 0x3B, 0x9F, 0x9C, 0xE7, 0xE6, 0x31, 0xB3,
  0x8C, 0x6C, 0xE7, 0x3B, 0x39, 0xCC, 0xE7, 0xFF, 0x38, 0xE7, 0x07, 0x00,
  0x00, 0xE0, 0x60, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xB0, 0x1C, 0xC0, 0x73, 0x83, 0x8E, 0x0E, 0x38,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x38, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0F,
  0x1F, 0xC1, 0xFF, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x39, 0xE7, 0xFC,
  0x7F, 0xC7, 0x1E, 0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0,
  0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x78, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xE0, 0xFF,
  0x03, 0xF8, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0x78, 0xF3, 0x87, 0x9C, 0x1C,
  0xE0, 0xEF, 0x07, 0x70, 0x3B, 0x83, 0xDC, 0x1E, 0xE1, 0xEF, 0x1F, 0x7F,
  0xF3, 0xFF, 0x1F, 0xC0, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xC0, 0x38, 0x03,
  0x80, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0xF8, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0xFC, 0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0x82, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x7E, 0xF1, 0xFB, 0xC7, 0xEF, 0x07, 0x3C,
  0x1C, 0x70, 0x71, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x1C, 0x1E, 0x38, 0x38,
  0xF0, 0x71, 0xE0, 0xE3, 0x83, 0xC7, 0x07, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C,
  0x70, 0x70, 0x0F, 0xE3, 0xF8, 0x3F, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x7C, 0x1F, 0xC7, 0xF0,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x8F, 0xC3,
  0xE0, 0xE0, 0x00, 0x1C, 0x3E, 0x38, 0x70, 0xF1, 0xE1, 0xC7, 0x83, 0x9E,
  0x07, 0x78, 0x0E, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xCE, 0x03,
  0x9E, 0x0F, 0x3C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0xF0, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0xFF, 0xFF, 0xFE, 0x1E, 0x03, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F,
  0x3E, 0x0D, 0xCF, 0xC7, 0xE3, 0x71, 0xB9, 0xDC, 0xEE, 0x77, 0x33, 0x9D,
  0xDC, 0xE7, 0x76, 0x71, 0x9F, 0x9C, 0xE7, 0xC7, 0x38, 0xF1, 0xCE, 0x38,
  0xE3, 0x8E, 0x38, 0x1E, 0x07, 0x1E, 0x07, 0x3E, 0x0E, 0x3F, 0x0E, 0x3F,
  0x0E, 0x3F, 0x0E, 0x33, 0x9C, 0x73, 0x9C, 0x73, 0x9C, 0x71, 0xDC, 0x71,
  0xDC, 0x71, 0xD8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0x03,
  0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0E, 0x70, 0x79, 0xFF, 0xC3,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0x70, 0xE3, 0x87, 0x9C,
  0x3C, 0xE1, 0xCF, 0x3E, 0x7F, 0xE3, 0xFE, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F,
  0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0E, 0x70, 0x79, 0xFF, 0xC3, 0xFE, 0x07, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x1F, 0x81, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0x73,
  0x87, 0x38, 0xF7, 0xFE, 0x7F, 0xC7, 0xF8, 0x73, 0x87, 0x3C, 0xF1, 0xCE,
  0x1C, 0xE1, 0xEE, 0x0E, 0x07, 0xC0, 0xFF, 0x1F, 0xE3, 0xC2, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x81, 0xCF,
  0xFC, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x3C, 0xE0,
  0xE7, 0x83, 0x9E, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0x70,
  0xF1, 0xFF, 0x87, 0xFC, 0x07, 0xE0, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1,
  0xCE, 0x0E, 0x70, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xFE, 0x0E,
  0x0E, 0xE1, 0xE1, 0xEE, 0x1E, 0x1C, 0xE3, 0xE1, 0xCE, 0x3E, 0x38, 0xE3,
  0x63, 0x8E, 0x76, 0x78, 0xE6, 0x67, 0x0E, 0xE7, 0x70, 0xEE, 0x6E, 0x0F,
  0xC6, 0xE0, 0xFC, 0x6C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x0E, 0x0E, 0x0F, 0x1C, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0x70,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x38, 0x70, 0x78, 0x78, 0xF0, 0x78, 0xE0, 0x7F, 0x0F, 0x71,
  0xE7, 0x1C, 0x73, 0xC7, 0x78, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xFF, 0x87, 0xFE, 0x3F, 0xF8,
  0x0F, 0x8F, 0xC7, 0xC3, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x7C, 0x3E, 0x00, 0xE1, 0x86,
  0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x87, 0x0F, 0x8F,
  0x87, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x7C, 0x3E, 0x00, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x7C, 0x0E, 0xC0, 0xCC, 0x18, 0xC3, 0x8E, 0x30, 0x6F, 0x07, 0xFF,
  0x80, 0xF3, 0x8C, 0x30, 0x1F, 0x73, 0xF6, 0x7D, 0xE7, 0x9E, 0xF0, 0xEF,
  0x1E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x7C, 0xFF, 0x87, 0x98, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xDE, 0x1F, 0xF3, 0xEF, 0x3C, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x78, 0xF7, 0x8E, 0x79, 0xE6, 0xFC, 0xEF, 0x80,
  0x1F, 0xCF, 0xE7, 0xD9, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x3E,
  0xC7, 0xF0, 0xFC, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F,
  0x78, 0xFF, 0x8F, 0xBC, 0x71, 0xE7, 0x87, 0x3C, 0x79, 0xC3, 0x8E, 0x1C,
  0x71, 0xE3, 0xDF, 0x0F, 0xF0, 0x7D, 0x80, 0x0F, 0x87, 0xF9, 0xE7, 0xB8,
  0x7F, 0x1D, 0xFF, 0xBF, 0xC7, 0x00, 0xE0, 0x1E, 0x31, 0xFE, 0x1F, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0x00, 0x38, 0x07, 0xF0, 0x7F, 0x80,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0x78, 0x0F, 0x80, 0x78, 0x00,
  0x0F, 0xB8, 0xFD, 0x8F, 0xBC, 0x79, 0xE7, 0x87, 0x3C, 0x79, 0xC3, 0x8E,
  0x1C, 0x71, 0xE3, 0xDF, 0x1F, 0xF0, 0x7B, 0x80, 0x1C, 0x01, 0xE3, 0x1E,
  0x1F, 0xF0, 0xFE, 0x00, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xDE, 0x1F, 0xF3, 0xEF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xE0, 0x0C, 0x1C, 0x78, 0x20, 0x03, 0x87,
  0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x01, 0xC0, 0x70,
  0x3C, 0x02, 0x00, 0x00, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC2, 0xF0, 0xFC, 0x3E,
  0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x71, 0xF1,
  0xCF, 0x0F, 0x78, 0x39, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81,
  0xCF, 0x07, 0x1C, 0x1C, 0x78, 0xF1, 0xE0, 0x0E, 0x1C, 0x78, 0xF1, 0xC3,
  0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x19, 0xE3,
  0xC3, 0x7F, 0xF8, 0xFB, 0xF7, 0x9E, 0x3C, 0x73, 0x87, 0x1E, 0x70, 0xE3,
  0x8E, 0x3C, 0x73, 0xC7, 0x0E, 0x70, 0xE1, 0xCE, 0x1C, 0x79, 0xC7, 0x8E,
  0x78, 0xE1, 0xC0, 0x19, 0xE1, 0xBF, 0x3E, 0xF3, 0xC7, 0x38, 0x73, 0x87,
  0x38, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xEF, 0x1E, 0x1F, 0x87, 0xF9,
  0xF7, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xDE, 0xF9, 0xFE,
  0x1F, 0x80, 0x0C, 0xF0, 0x6F, 0xC7, 0xDE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C,
  0x70, 0xE7, 0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0xF8, 0x77, 0x87, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x1F, 0x73, 0xF6, 0x7D, 0xE7, 0x1E,
  0xF0, 0xEF, 0x1E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x7C, 0x7F, 0x87, 0xB8,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x1D, 0xC6, 0xF3, 0xFC,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x1F,
  0x8F, 0xF3, 0x89, 0xE0, 0x3C, 0x0F, 0xC1, 0xF8, 0x1E, 0x03, 0xB1, 0xEF,
  0xF3, 0xF8, 0x0C, 0x1C, 0x1C, 0x7F, 0xFF, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF4, 0xFC, 0x7C, 0x38, 0x77, 0x8F, 0x78, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0xF1, 0xEE, 0x1C, 0xE3, 0xCF, 0x7C, 0xFD, 0xC7, 0x98, 0xE0,
  0xFE, 0x1E, 0xE1, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x03, 0x80, 0xE1, 0xE3, 0xF1, 0xF3, 0xF8, 0xF9, 0xCC,
  0xFC, 0xE6, 0x7E, 0xE3, 0x37, 0x71, 0xBB, 0xF0, 0xD9, 0xF8, 0x6C, 0xD8,
  0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x79, 0xE0, 0xEF,
  0x03, 0xB8, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1D, 0xC0, 0xF7,
  0x07, 0x9E, 0x3C, 0x38, 0x1C, 0x1E, 0x38, 0x78, 0x78, 0xE0, 0x73, 0xC0,
  0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xF8, 0x00,
  0x3F, 0xE7, 0xF8, 0xFF, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x1F, 0xF3, 0xFE, 0x7F, 0x80, 0x03, 0x83, 0xC3, 0xE1, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x78, 0x78, 0x3C, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70,
  0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x0F, 0x07,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0xC3, 0xC3, 0xC1, 0xC0,
  0xC0, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x00, 0x30, 0x3F, 0xCF, 0xFF, 0xC3,
  0xE0,
};

const GFXglyph NotoSans_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 10, 2, -16 },
  { 21, 14, 16, 14, 0, -16 },
  { 49, 11, 18, 12, 1, -17 },
  { 74, 17, 16, 19, 1, -16 },
  { 108, 14, 16, 16, 1, -16 },
  { 136, 4, 6, 6, 2, -16 },
  { 139, 8, 19, 7, 1, -16 },
  { 158, 9, 19, 8, -2, -16 },
  { 180, 10, 11, 12, 2, -17 },
  { 194, 11, 11, 13, 1, -13 },
  { 210, 5, 6, 6, -1, -3 },
  { 214, 7, 2, 7, 0, -7 },
  { 216, 4, 3, 6, 0, -3 },
  { 218, 12, 16, 9, -1, -16 },
  { 242, 11, 16, 12, 1, -16 },
  { 264, 9, 16, 12, 2, -16 },
  { 282, 13, 16, 12, -1, -16 },
  { 308, 12, 16, 12, 0, -16 },
  { 332, 12, 16, 12, 0, -16 },
  { 356, 12, 16, 12, 0, -16 },
  { 380, 11, 16, 12, 1, -16 },
  { 402, 12, 16, 12, 1, -16 },
  { 426, 11, 16, 12, 1, -16 },
  { 448, 11, 16, 12, 1, -16 },
  { 470, 6, 12, 6, 0, -12 },
  { 479, 7, 15, 6, -1, -12 },
  { 493, 11, 12, 13, 1, -14 },
  { 510, 11, 7, 13, 1, -11 },
  { 520, 11, 12, 13, 1, -14 },
  { 537, 9, 16, 10, 2, -16 },
  { 555, 18, 18, 19, 1, -16 },
  { 596, 14, 16, 14, -1, -16 },
  { 624, 12, 16, 14, 1, -16 },
  { 648, 13, 16, 13, 1, -16 },
  { 674, 13, 16, 15, 1, -16 },
  { 700, 12, 16, 12, 1, -16 },
  { 724, 12, 16, 12, 1, -16 },
  { 748, 14, 16, 15, 1, -16 },
  { 776, 15, 16, 15, 1, -16 },
  { 806, 11, 16, 8, -1, -16 },
  { 828, 10, 21, 7, -3, -16 },
  { 855, 15, 16, 13, 1, -16 },
  { 885, 9, 16, 11, 1, -16 },
  { 903, 18, 16, 19, 1, -16 },
  { 939, 16, 16, 17, 1, -16 },
  { 971, 14, 16, 16, 1, -16 },
  { 999, 13, 16, 13, 1, -16 },
  { 1025, 14, 20, 16, 1, -16 },
  { 1060, 12, 16, 14, 1, -16 },
  { 1084, 12, 16, 12, 0, -16 },
  { 1108, 11, 16, 12, 2, -16 },
  { 1130, 14, 16, 15, 1, -16 },
  { 1158, 13, 16, 13, 2, -16 },
  { 1184, 20, 16, 20, 2, -16 },
  { 1224, 16, 16, 13, -1, -16 },
  { 1256, 12, 16, 12, 2, -16 },
  { 1280, 14, 16, 12, -1, -16 },
  { 1308, 9, 19, 7, 0, -16 },
  { 1330, 6, 16, 9, 2, -16 },
  { 1342, 9, 19, 7, -1, -16 },
  { 1364, 12, 10, 12, 0, -16 },
  { 1379, 9, 1, 9, -2, 2 },
  { 1381, 5, 4, 7, 3, -17 },
  { 1384, 12, 12, 13, 1, -12 },
  { 1402, 12, 17, 13, 0, -17 },
  { 1428, 10, 12, 11, 1, -12 },
  { 1443, 13, 17, 13, 1, -17 },
  { 1471, 11, 12, 12, 1, -12 },
  { 1488, 13, 22, 8, -2, -17 },
  { 1524, 13, 17, 13, 0, -12 },
  { 1552, 12, 17, 13, 0, -17 },
  { 1578, 7, 17, 7, 0, -17 },
  { 1593, 10, 22, 7, -3, -17 },
  { 1621, 14, 17, 13, 0, -17 },
  { 1651, 7, 17, 7, 0, -17 },
  { 1666, 19, 12, 20, 0, -12 },
  { 1695, 12, 12, 13, 0, -12 },
  { 1713, 11, 12, 13, 1, -12 },
  { 1730, 13, 17, 13, -1, -12 },
  { 1758, 12, 17, 13, 1, -12 },
  { 1784, 10, 12, 9, 0, -12 },
  { 1799, 10, 12, 10, 0, -12 },
  { 1814, 8, 15, 9, 1, -15 },
  { 1829, 12, 12, 13, 1, -12 },
  { 1847, 12, 12, 11, 1, -12 },
  { 1865, 17, 12, 17, 1, -12 },
  { 1891, 14, 12, 12, -1, -12 },
  { 1912, 15, 17, 11, -2, -12 },
  { 1944, 11, 12, 10, 0, -12 },
  { 1961, 9, 19, 8, 0, -16 },
  { 1983, 2, 22, 12, 5, -17 },
  { 1989, 9, 19, 8, -1, -16 },
  { 2011, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_BOLDITALIC22PT7B_H_
