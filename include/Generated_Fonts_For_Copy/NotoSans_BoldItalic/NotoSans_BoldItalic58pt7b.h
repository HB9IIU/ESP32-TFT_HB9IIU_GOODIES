#ifndef _NOTOSANS_BOLDITALIC58PT7B_H_
#define _NOTOSANS_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC7, 0xFB, 0xFC, 0x3F,
  0x9F, 0xE1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xCF, 0xC0, 0x7F, 0xC7, 0x83, 0x00,
  0xFF, 0x1E, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x07,
  0xFC, 0xF0, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x79,
  0xFF, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x03, 0xC7,
  0xF8, 0xC0, 0x0F, 0x1F, 0xF1, 0xE0, 0x1E, 0x3F, 0xE3, 0xFC, 0x3D, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE1, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x1F, 0xC7, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0xFF, 0xF1, 0xFE,
  0x7F, 0x9F, 0xCF, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xCF,
  0xE3, 0xF8, 0xFE, 0x1F, 0xFC, 0x7E, 0x3F, 0xC3, 0xF8, 0x3F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x83,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0x80, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF,
  0x80, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF,
  0xFF, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xCF, 0xFC, 0x7F, 0xC7, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0,
  0x7F, 0xEF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0xFE, 0x00, 0x38, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xFE, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xC7,
  0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x3F,
  0xE7, 0xF0, 0x07, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xF8, 0x3F,
  0x80, 0x07, 0x03, 0xFC, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0x87, 0xF9, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xBF, 0xF3, 0xFE, 0x7F,
  0x83, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x00, 0xFF,
  0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0x7F,
  0x80, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xE3, 0xFE, 0x7F,
  0xC3, 0xF8, 0xFF, 0x83, 0xC1, 0xFE, 0x07, 0x03, 0xFC, 0x08, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFE, 0x03, 0xFF,
  0x00, 0x78, 0x01, 0xFF, 0x00, 0x30, 0x01, 0xFF, 0x00, 0x20, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0x00, 0x70, 0x03, 0xFE, 0x00,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0x80, 0x00, 0x7F, 0xE3,
  0xC0, 0x01, 0xFF, 0xC7, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE1, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x80,
  0x00, 0xFF, 0xE1, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x04, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xE7, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0x00,
  0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC,
  0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x0F, 0xFE,
  0x7F, 0xC0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFC,
  0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x20, 0x03, 0xFF, 0x81, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0x81, 0xFF,
  0x1E, 0x00, 0xFF, 0x10, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0xFF, 0xE1, 0xFC,
  0x7E, 0x01, 0xFF, 0xFF, 0x87, 0xF3, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFD, 0xF8,
  0x1F, 0xE0, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xFF, 0x83,
  0xF8, 0x07, 0xE0, 0x3F, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x7F,
  0x00, 0xFC, 0x07, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0xBF, 0x07, 0xF0,
  0x0F, 0xC0, 0x7E, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xFB, 0xF0, 0x7E, 0x01,
  0xF8, 0x0F, 0xEF, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F, 0xF8,
  0x7F, 0x8F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x83, 0xFF, 0xEF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F,
  0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0xFF, 0xE0, 0x00,
  0x60, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xF0,
  0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFC, 0x7F,
  0xC0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF,
  0x8F, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x40, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC0,
  0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFF, 0x80,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x7E, 0x00,
  0x3F, 0xBF, 0xC0, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xE0, 0x3F, 0xDF, 0xC0,
  0x1F, 0xCF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF0,
  0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFC,
  0x07, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x7F,
  0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x80, 0x7F, 0x1F,
  0xC1, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xE0, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xF0, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFC, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7E, 0x3F, 0x83, 0xFC, 0x07, 0xF8,
  0x3F, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0x9F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xDF, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF7, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x07, 0xF8, 0x07,
  0xF9, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xBF,
  0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x5F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x3F,
  0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFC, 0x03,
  0xFE, 0x00, 0x70, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x7F, 0xC3, 0x80, 0x03, 0xFE,
  0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFE, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0xCF, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0xFC, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x8F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC0,
  0x07, 0xF8, 0xFE, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0xFE, 0x7F,
  0x80, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0xFE,
  0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xC1,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0xFE, 0x01, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7,
  0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0xFF, 0x3F, 0xFC, 0x01, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x80, 0xFE, 0xFF, 0xFE, 0x03,
  0xF8, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x18, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x20, 0xFF, 0xC0, 0x38, 0x3F, 0xFE, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0x1F, 0xE0, 0x07, 0xFF,
  0xCF, 0xF0, 0x07, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xBF,
  0x00, 0x1F, 0xFF, 0x9F, 0x80, 0x07, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x0F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x3F, 0xF0,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE,
  0x7F, 0x80, 0x7F, 0xEF, 0xF8, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x0F, 0xFE, 0x03,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x30, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x1F, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF,
  0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFE,
  0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x06, 0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xCF,
  0xFE, 0x00, 0xFF, 0x3F, 0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x08, 0x7F, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x01, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x83,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0,
  0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xE0, 0x3F, 0xBF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0x83, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x0F,
  0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xEF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x81,
  0xFF, 0xCF, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x0F,
  0xC3, 0xFF, 0x00, 0x07, 0xF3, 0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFD, 0xFF,
  0xF8, 0x01, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE0,
  0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xFC, 0x03, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0xFF, 0xFE,
  0x7F, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3,
  0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFB, 0xFC, 0x01, 0xFF, 0xCF, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xC1,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF,
  0xF8, 0x0F, 0xE7, 0xFE, 0x03, 0xFB, 0xFF, 0x80, 0xFE, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7C, 0x3F, 0xE0, 0x0C,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0xC0, 0x07, 0xFC, 0x7C, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF9, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x0A, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xDF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xF3, 0xF8, 0x07,
  0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x00,
  0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F,
  0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x81, 0xFF, 0x00, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xF0, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xCF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0xE0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x3F, 0x7E, 0x07, 0xF8, 0x3F,
  0xC1, 0xFB, 0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xDF, 0x83, 0xFC, 0x0F, 0xF0,
  0xFC, 0xFC, 0x1F, 0xE0, 0x7F, 0x8F, 0xE7, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0x3F, 0x0F, 0xF0, 0x1F, 0xE3, 0xF1, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0x8F,
  0xC7, 0xF8, 0x07, 0xF9, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0xDF, 0xC3, 0xF3,
  0xFC, 0x01, 0xFE, 0xFE, 0x1F, 0x9F, 0xE0, 0x0F, 0xF7, 0xE0, 0xFD, 0xFE,
  0x00, 0x3F, 0x7F, 0x07, 0xEF, 0xF0, 0x01, 0xFB, 0xF0, 0x3F, 0x7F, 0x00,
  0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x13, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x80,
  0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 42, 17, 1, -41 },
  { 91, 21, 15, 26, 6, -41 },
  { 131, 37, 41, 37, 1, -41 },
  { 321, 31, 47, 32, 1, -44 },
  { 504, 45, 43, 50, 3, -42 },
  { 746, 38, 43, 41, 2, -42 },
  { 951, 10, 15, 15, 6, -41 },
  { 970, 22, 50, 20, 2, -41 },
  { 1108, 22, 51, 20, -4, -42 },
  { 1249, 28, 28, 32, 5, -44 },
  { 1347, 28, 29, 33, 3, -35 },
  { 1449, 14, 14, 17, -3, -7 },
  { 1474, 16, 7, 19, 1, -19 },
  { 1488, 11, 10, 17, 0, -9 },
  { 1502, 32, 42, 25, -3, -42 },
  { 1670, 29, 43, 32, 2, -42 },
  { 1826, 23, 41, 32, 5, -41 },
  { 1944, 32, 42, 32, -1, -42 },
  { 2112, 31, 43, 32, 0, -42 },
  { 2279, 32, 41, 32, -1, -41 },
  { 2443, 31, 42, 32, 1, -41 },
  { 2606, 31, 43, 32, 2, -42 },
  { 2773, 32, 41, 32, 2, -41 },
  { 2937, 30, 43, 32, 2, -42 },
  { 3099, 29, 43, 32, 2, -42 },
  { 3255, 16, 33, 17, 0, -32 },
  { 3321, 19, 39, 17, -3, -32 },
  { 3414, 28, 30, 33, 3, -36 },
  { 3519, 28, 17, 33, 3, -29 },
  { 3579, 28, 30, 33, 3, -36 },
  { 3684, 24, 43, 27, 4, -42 },
  { 3813, 46, 46, 50, 3, -41 },
  { 4078, 36, 41, 36, -3, -41 },
  { 4263, 33, 41, 36, 2, -41 },
  { 4433, 35, 43, 36, 3, -42 },
  { 4622, 35, 41, 39, 2, -41 },
  { 4802, 31, 41, 32, 2, -41 },
  { 4961, 31, 41, 31, 2, -41 },
  { 5120, 36, 43, 40, 3, -42 },
  { 5314, 39, 41, 41, 2, -41 },
  { 5514, 27, 41, 22, -2, -41 },
  { 5653, 29, 53, 19, -9, -41 },
  { 5846, 39, 41, 36, 2, -41 },
  { 6046, 24, 41, 30, 2, -41 },
  { 6169, 49, 41, 51, 2, -41 },
  { 6421, 43, 41, 44, 1, -41 },
  { 6642, 38, 43, 42, 3, -42 },
  { 6847, 34, 41, 35, 2, -41 },
  { 7022, 38, 52, 42, 3, -42 },
  { 7269, 32, 41, 36, 2, -41 },
  { 7433, 30, 43, 31, 1, -42 },
  { 7595, 30, 41, 31, 5, -41 },
  { 7749, 37, 42, 40, 4, -41 },
  { 7944, 34, 41, 34, 5, -41 },
  { 8119, 52, 41, 52, 5, -41 },
  { 8386, 43, 41, 35, -3, -41 },
  { 8607, 33, 41, 33, 5, -41 },
  { 8777, 36, 41, 31, -2, -41 },
  { 8962, 24, 50, 19, -1, -41 },
  { 9112, 14, 42, 25, 6, -42 },
  { 9186, 24, 50, 19, -4, -41 },
  { 9336, 30, 27, 32, 1, -42 },
  { 9438, 24, 4, 23, -5, 5 },
  { 9450, 13, 9, 19, 8, -44 },
  { 9465, 31, 33, 34, 3, -32 },
  { 9593, 31, 45, 35, 1, -44 },
  { 9768, 26, 33, 28, 3, -32 },
  { 9876, 33, 45, 34, 3, -44 },
  { 10062, 28, 33, 32, 3, -32 },
  { 10178, 34, 58, 22, -6, -44 },
  { 10425, 33, 46, 35, 1, -32 },
  { 10615, 31, 44, 35, 1, -44 },
  { 10786, 18, 44, 17, 1, -44 },
  { 10885, 26, 58, 17, -7, -44 },
  { 11074, 35, 44, 33, 1, -44 },
  { 11267, 18, 44, 17, 1, -44 },
  { 11366, 49, 32, 52, 1, -32 },
  { 11562, 31, 32, 35, 1, -32 },
  { 11686, 28, 33, 34, 3, -32 },
  { 11802, 34, 46, 35, -2, -32 },
  { 11998, 30, 46, 34, 3, -32 },
  { 12171, 26, 32, 24, 1, -32 },
  { 12275, 25, 33, 28, 1, -32 },
  { 12379, 22, 39, 24, 3, -38 },
  { 12487, 31, 33, 35, 3, -32 },
  { 12615, 30, 32, 30, 3, -32 },
  { 12735, 45, 32, 46, 4, -32 },
  { 12915, 37, 32, 31, -3, -32 },
  { 13063, 37, 46, 30, -4, -32 },
  { 13276, 29, 32, 27, -1, -32 },
  { 13392, 24, 50, 21, 0, -41 },
  { 13542, 6, 57, 32, 13, -44 },
  { 13585, 24, 50, 21, -3, -41 },
  { 13735, 28, 9, 33, 3, -25 },
};

const GFXfont NotoSans_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_BOLDITALIC58PT7B_H_
