#ifndef _NOTOSANS_BOLDITALIC12PT7B_H_
#define _NOTOSANS_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB5, 0x20, 0x1A, 0x12, 0x14,
  0x7F, 0x34, 0xFE, 0xFE, 0x68, 0x58, 0x08, 0x7D, 0xB3, 0x83, 0x83, 0xA7,
  0x7E, 0x20, 0x40, 0x61, 0x79, 0x2D, 0x97, 0x8E, 0xBE, 0xBC, 0xD6, 0xCA,
  0xC7, 0x00, 0x1C, 0x3E, 0x36, 0x3C, 0x39, 0x7B, 0xCE, 0xEE, 0x7F, 0x7E,
  0x19, 0x88, 0xC4, 0x23, 0x18, 0x42, 0x18, 0x30, 0x86, 0x31, 0x8C, 0x46,
  0x33, 0x30, 0x13, 0x47, 0xDC, 0xD0, 0x60, 0x21, 0x3E, 0x42, 0x10, 0x6B,
  0x00, 0xFE, 0xF0, 0x06, 0x08, 0x30, 0x41, 0x86, 0x0C, 0x30, 0xC0, 0x18,
  0x79, 0x93, 0x34, 0x59, 0xB3, 0x2C, 0x78, 0x19, 0xFD, 0x63, 0x18, 0xC4,
  0x60, 0x19, 0xF4, 0x43, 0x0C, 0x66, 0x3F, 0xF8, 0x19, 0xF0, 0x43, 0x38,
  0x30, 0xE7, 0xF8, 0x04, 0x31, 0xCF, 0x6F, 0x2F, 0xC6, 0x18, 0x3E, 0x78,
  0x83, 0x07, 0xC1, 0x83, 0x4E, 0xF8, 0x1D, 0xF4, 0x34, 0xFA, 0x69, 0xB6,
  0xF0, 0x7E, 0xFC, 0x30, 0x61, 0x83, 0x0C, 0x30, 0xE0, 0x18, 0x79, 0x99,
  0x63, 0x8D, 0xB3, 0x66, 0x78, 0x19, 0xF6, 0x51, 0x6D, 0xF0, 0xE6, 0xF0,
  0x2C, 0x01, 0xB0, 0x13, 0x00, 0x00, 0x64, 0xC0, 0x08, 0xDD, 0x8E, 0x1C,
  0x20, 0xF8, 0x3F, 0xF0, 0x86, 0x1C, 0x33, 0xF2, 0x00, 0x77, 0xC6, 0x76,
  0x20, 0x18, 0xC0, 0x0C, 0x1F, 0x90, 0x73, 0xDB, 0x4D, 0x26, 0xB5, 0x6C,
  0xC2, 0x3E, 0x00, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x3E, 0x3F, 0x63, 0xC3,
  0x38, 0x7C, 0x9B, 0x37, 0xCC, 0xD9, 0xBE, 0xFC, 0x1C, 0xFD, 0x86, 0x0C,
  0x18, 0x30, 0x74, 0x78, 0x38, 0x3E, 0x33, 0x63, 0x63, 0x63, 0x66, 0x7E,
  0xF8, 0x3E, 0x7C, 0xC3, 0x07, 0xCC, 0x18, 0x3C, 0xF8, 0x3E, 0x7C, 0x83,
  0x07, 0xCF, 0x98, 0x20, 0xC0, 0x1C, 0xFD, 0x86, 0x0D, 0xFB, 0xB3, 0x76,
  0x7C, 0x31, 0x33, 0x33, 0x63, 0x7F, 0x62, 0x66, 0x46, 0xC6, 0x7B, 0xCC,
  0x62, 0x31, 0x8C, 0xF0, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xCF,
  0x10, 0x33, 0x37, 0x26, 0x6C, 0x78, 0x78, 0x6C, 0x4C, 0xC6, 0x31, 0x88,
  0xC6, 0x31, 0x8F, 0xF8, 0x30, 0xE7, 0x18, 0xE7, 0x3C, 0xE7, 0xBC, 0xF5,
  0x97, 0xA2, 0x6C, 0xCD, 0x80, 0x30, 0x9C, 0xCE, 0x6D, 0x36, 0xD3, 0x79,
  0x3C, 0x8E, 0xC6, 0x00, 0x1C, 0xFD, 0x9E, 0x1C, 0x78, 0xF1, 0xF6, 0x78,
  0x38, 0x7C, 0x8B, 0x37, 0xEF, 0x98, 0x20, 0xC0, 0x1C, 0xFD, 0x9E, 0x1C,
  0x78, 0xF1, 0xF6, 0x78, 0x30, 0x30, 0x38, 0x7C, 0xDB, 0x37, 0xEF, 0x1B,
  0x26, 0xC6, 0x1E, 0x79, 0x83, 0x03, 0x83, 0x03, 0x4C, 0xF8, 0xFF, 0xF3,
  0x0C, 0x61, 0x86, 0x18, 0x40, 0x62, 0xCD, 0x1E, 0x3C, 0x78, 0xB3, 0x6E,
  0x78, 0xC7, 0x8F, 0x36, 0x6D, 0x8B, 0x1C, 0x38, 0x60, 0xC4, 0x79, 0x8B,
  0x33, 0x6E, 0x6D, 0x59, 0xEB, 0x39, 0x47, 0x38, 0xE6, 0x00, 0x31, 0x8D,
  0x86, 0xC3, 0xC0, 0xC0, 0xE0, 0xD8, 0xCC, 0xE7, 0x00, 0xC7, 0x99, 0x23,
  0xC7, 0x0C, 0x18, 0x30, 0x60, 0x3E, 0xFC, 0x30, 0xC3, 0x86, 0x18, 0x7E,
  0xF8, 0x39, 0xC8, 0xC6, 0x21, 0x08, 0xC6, 0x38, 0xD9, 0x24, 0xDB, 0x20,
  0x39, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x38, 0x08, 0x63, 0x8B, 0x67, 0x10,
  0xF8, 0xD0, 0x2F, 0xFC, 0xF2, 0x9B, 0x6F, 0x80, 0x30, 0x60, 0xB3, 0xE6,
  0x6C, 0xD3, 0x36, 0xF8, 0x33, 0xF1, 0x08, 0x6B, 0xC0, 0x04, 0x32, 0xDF,
  0xCA, 0x29, 0xB6, 0xF8, 0x33, 0xF3, 0xF8, 0x67, 0xC0, 0x0E, 0x30, 0x71,
  0xE3, 0x06, 0x0C, 0x18, 0x20, 0xC3, 0x86, 0x00, 0x16, 0x7D, 0x9B, 0x24,
  0xCD, 0x9F, 0x04, 0xF9, 0xE0, 0x30, 0x60, 0xB3, 0xF6, 0x6C, 0x9B, 0x26,
  0xCC, 0x32, 0x26, 0x66, 0x64, 0xC0, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x84,
  0x30, 0xCF, 0x38, 0x30, 0x60, 0x9B, 0x67, 0x8F, 0x1E, 0x24, 0xCC, 0x33,
  0x26, 0x66, 0x64, 0xC0, 0x2C, 0x9F, 0x76, 0x6D, 0x93, 0x6C, 0xD3, 0x3C,
  0xC8, 0x2C, 0xFD, 0x9B, 0x26, 0xC9, 0xB3, 0x00, 0x37, 0xF3, 0x19, 0xEF,
  0xC0, 0x2C, 0xF9, 0x9B, 0x34, 0xCD, 0xBE, 0x60, 0xC1, 0x00, 0x25, 0xFC,
  0xA2, 0x9B, 0x6F, 0x84, 0x30, 0xC0, 0x2D, 0xE6, 0x18, 0x61, 0x0C, 0x00,
  0x3B, 0xD8, 0xE1, 0xCF, 0xC0, 0x67, 0xFC, 0xCC, 0xEE, 0x4F, 0x3C, 0xF2,
  0x9B, 0x6F, 0x80, 0x8E, 0x69, 0xBC, 0xF3, 0x8E, 0x00, 0x99, 0xCC, 0xEE,
  0xD5, 0x6A, 0xA7, 0x73, 0x30, 0x33, 0x36, 0x1C, 0x18, 0x3C, 0x3C, 0xE6,
  0x23, 0x26, 0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0xF0, 0xC0, 0x7D, 0xF1,
  0x8C, 0x63, 0x0F, 0x80, 0x09, 0xCC, 0x42, 0x61, 0x8C, 0x43, 0x18, 0xFF,
  0xF0, 0x21, 0x86, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xFC, 0xC0,
};

const GFXglyph NotoSans_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 7, 10, 7, 0, -9 },
  { 27, 9, 9, 10, 1, -9 },
  { 38, 8, 9, 9, 0, -9 },
  { 47, 2, 4, 3, 1, -9 },
  { 48, 5, 11, 4, 0, -9 },
  { 55, 5, 11, 4, -1, -9 },
  { 62, 6, 6, 7, 1, -9 },
  { 67, 5, 6, 7, 1, -7 },
  { 71, 3, 3, 3, -1, -1 },
  { 73, 4, 2, 4, 0, -4 },
  { 74, 2, 2, 3, 0, -2 },
  { 75, 7, 9, 5, -1, -9 },
  { 83, 7, 9, 7, 0, -9 },
  { 91, 5, 9, 7, 1, -9 },
  { 97, 6, 9, 7, 0, -9 },
  { 104, 6, 9, 7, 0, -9 },
  { 111, 6, 9, 7, 0, -9 },
  { 118, 7, 9, 7, 0, -9 },
  { 126, 6, 9, 7, 1, -9 },
  { 133, 7, 9, 7, 0, -9 },
  { 141, 7, 9, 7, 0, -9 },
  { 149, 6, 9, 7, 0, -9 },
  { 156, 3, 7, 3, 0, -7 },
  { 159, 4, 9, 3, -1, -7 },
  { 164, 5, 7, 7, 1, -8 },
  { 169, 5, 4, 7, 1, -6 },
  { 172, 5, 7, 7, 1, -8 },
  { 177, 5, 9, 6, 1, -9 },
  { 183, 9, 10, 10, 1, -9 },
  { 195, 8, 9, 8, -1, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 7, 9, 7, 1, -9 },
  { 220, 8, 9, 8, 0, -9 },
  { 229, 7, 9, 7, 0, -9 },
  { 237, 7, 9, 6, 0, -9 },
  { 245, 7, 9, 8, 1, -9 },
  { 253, 8, 9, 8, 0, -9 },
  { 262, 5, 9, 5, 0, -9 },
  { 268, 6, 12, 4, -2, -9 },
  { 277, 8, 9, 7, 0, -9 },
  { 286, 5, 9, 6, 0, -9 },
  { 292, 11, 9, 11, 0, -9 },
  { 305, 9, 9, 9, 0, -9 },
  { 316, 7, 9, 9, 1, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 7, 11, 9, 1, -9 },
  { 342, 7, 9, 7, 0, -9 },
  { 350, 7, 9, 6, 0, -9 },
  { 358, 6, 9, 6, 1, -9 },
  { 365, 7, 9, 8, 1, -9 },
  { 373, 7, 9, 7, 1, -9 },
  { 381, 11, 9, 11, 1, -9 },
  { 394, 9, 9, 7, -1, -9 },
  { 405, 7, 9, 7, 1, -9 },
  { 413, 7, 9, 6, 0, -9 },
  { 421, 5, 11, 4, 0, -9 },
  { 428, 3, 9, 5, 1, -9 },
  { 432, 5, 11, 4, -1, -9 },
  { 439, 6, 6, 7, 0, -9 },
  { 444, 5, 1, 5, -1, 1 },
  { 445, 2, 2, 4, 2, -9 },
  { 446, 6, 7, 7, 1, -7 },
  { 452, 7, 9, 7, 0, -9 },
  { 460, 5, 7, 6, 1, -7 },
  { 465, 6, 9, 7, 1, -9 },
  { 472, 5, 7, 7, 1, -7 },
  { 477, 7, 12, 4, -1, -9 },
  { 488, 7, 10, 7, 0, -7 },
  { 497, 7, 9, 7, 0, -9 },
  { 505, 4, 9, 4, 0, -9 },
  { 510, 6, 12, 4, -2, -9 },
  { 519, 7, 9, 7, 0, -9 },
  { 527, 4, 9, 4, 0, -9 },
  { 532, 10, 7, 11, 0, -7 },
  { 541, 7, 7, 7, 0, -7 },
  { 548, 5, 7, 7, 1, -7 },
  { 553, 7, 10, 7, 0, -7 },
  { 562, 6, 10, 7, 1, -7 },
  { 570, 6, 7, 5, 0, -7 },
  { 576, 5, 7, 6, 0, -7 },
  { 581, 4, 8, 5, 1, -8 },
  { 585, 6, 7, 7, 1, -7 },
  { 591, 6, 7, 6, 1, -7 },
  { 597, 9, 7, 9, 1, -7 },
  { 605, 8, 7, 6, -1, -7 },
  { 612, 8, 10, 6, -1, -7 },
  { 622, 6, 7, 6, 0, -7 },
  { 628, 5, 11, 4, 0, -9 },
  { 635, 1, 12, 7, 3, -9 },
  { 637, 5, 11, 4, -1, -9 },
  { 644, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_BOLDITALIC12PT7B_H_
