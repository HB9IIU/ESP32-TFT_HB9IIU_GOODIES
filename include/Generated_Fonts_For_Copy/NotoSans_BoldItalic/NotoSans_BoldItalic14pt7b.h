#ifndef _NOTOSANS_BOLDITALIC14PT7B_H_
#define _NOTOSANS_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x60, 0xEC, 0x6D, 0x65, 0xB6, 0x09, 0x05, 0x86,
  0xCF, 0xF1, 0x21, 0xB3, 0xFC, 0x48, 0x2C, 0x36, 0x00, 0x04, 0x0C, 0x3F,
  0x7A, 0x78, 0x3C, 0x1E, 0x16, 0x96, 0xFC, 0x10, 0x30, 0x70, 0xF6, 0x6D,
  0xB3, 0x58, 0xF5, 0xFB, 0xD1, 0xB4, 0xC9, 0x22, 0xD8, 0xE0, 0x1E, 0x07,
  0xC3, 0x30, 0xD8, 0x1C, 0x5F, 0x66, 0xFB, 0x9C, 0x7F, 0x1F, 0xE0, 0x69,
  0x60, 0x1C, 0x63, 0x18, 0x61, 0x84, 0x10, 0xC1, 0x06, 0x18, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x11, 0x99, 0x80, 0x10, 0x33, 0x43, 0xF3, 0xAF, 0x13,
  0x00, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x00, 0x36, 0x6C, 0x7F, 0xF8, 0x03,
  0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1E, 0x3E, 0x77,
  0x63, 0x67, 0x66, 0xE6, 0xE6, 0x7C, 0x78, 0x1C, 0xEF, 0x96, 0x18, 0x63,
  0x0C, 0x30, 0xC0, 0x3E, 0x7E, 0x27, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xFE,
  0xFC, 0x7E, 0x3E, 0x07, 0x06, 0x3C, 0x3C, 0x06, 0x06, 0xFE, 0xF8, 0x07,
  0x0E, 0x1E, 0x16, 0x36, 0x6C, 0xFE, 0xFE, 0x0C, 0x1C, 0x3F, 0x3E, 0x30,
  0x20, 0x7C, 0x4E, 0x06, 0x06, 0xFC, 0xF8, 0x1E, 0xFD, 0x86, 0x8F, 0xD9,
  0xB3, 0x66, 0xFC, 0xF0, 0x7F, 0xFC, 0x30, 0x61, 0x87, 0x0C, 0x30, 0xE1,
  0x80, 0x1E, 0x37, 0x33, 0x36, 0x1C, 0x7C, 0x66, 0xC6, 0x6E, 0x7C, 0x7F,
  0xFC, 0xF3, 0xCF, 0xF0, 0xC6, 0xFB, 0xC0, 0x37, 0x20, 0x00, 0xEC, 0x19,
  0xC4, 0x00, 0x00, 0xCC, 0x66, 0x00, 0x02, 0x1C, 0xE7, 0x0E, 0x07, 0x03,
  0x81, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0x81, 0xC0, 0xE1, 0xEF, 0x30, 0x40,
  0xF9, 0xF0, 0xC7, 0x39, 0x86, 0x00, 0xE3, 0x00, 0x0F, 0x87, 0x19, 0x81,
  0xE7, 0xB9, 0xB7, 0x66, 0xEC, 0x95, 0xFE, 0xC9, 0x0C, 0x20, 0xFC, 0x00,
  0x07, 0x03, 0x83, 0xC1, 0xE1, 0x90, 0xC8, 0xFE, 0xFF, 0x61, 0xF0, 0xC0,
  0x3F, 0x1F, 0x8C, 0xE6, 0x63, 0xE3, 0xF1, 0x8C, 0xC6, 0x7E, 0x7E, 0x00,
  0x1F, 0x7F, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x3E, 0x1F,
  0x8C, 0x66, 0x33, 0x1B, 0x0D, 0x8E, 0xC6, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x7C, 0xFC, 0x3F, 0x3F, 0x30, 0x30,
  0x3E, 0x7E, 0x60, 0x60, 0x60, 0xE0, 0x1F, 0x9F, 0x98, 0x1C, 0x0C, 0xF6,
  0x7B, 0x1D, 0x8C, 0xFE, 0x3F, 0x00, 0x38, 0xCC, 0x73, 0x18, 0xC6, 0x3F,
  0x9F, 0xE6, 0x31, 0x8C, 0x63, 0x38, 0xC0, 0x3D, 0xE3, 0x0C, 0x30, 0xC7,
  0x18, 0x73, 0xC0, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0xC7, 0x8E, 0x00, 0x39, 0xCC, 0xE3, 0x70, 0xD8, 0x3C, 0x1F, 0x06, 0xC1,
  0x98, 0x66, 0x39, 0xC0, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x7F, 0xF0,
  0x38, 0x73, 0x87, 0x38, 0xF3, 0x8B, 0x2D, 0xA6, 0xD6, 0x6F, 0x66, 0xE6,
  0x6E, 0x6C, 0xCC, 0x38, 0x67, 0x18, 0xF3, 0x1E, 0x62, 0xCC, 0xCD, 0x99,
  0xE3, 0x3C, 0x63, 0x98, 0x70, 0x1E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x1F,
  0x0D, 0x8E, 0xFE, 0x3E, 0x00, 0x3E, 0x1F, 0x8C, 0xE6, 0x73, 0x33, 0xF1,
  0x80, 0xC0, 0x60, 0x70, 0x00, 0x1E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x1F,
  0x0D, 0x8E, 0xFE, 0x3E, 0x03, 0x01, 0xC0, 0x3E, 0x3F, 0x33, 0x33, 0x37,
  0x7E, 0x6C, 0x66, 0x66, 0xE7, 0x1F, 0x3E, 0x70, 0x70, 0x38, 0x1C, 0x0C,
  0x0C, 0xFC, 0xF8, 0xFF, 0xFC, 0xE1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC0,
  0x71, 0xB1, 0x98, 0xCC, 0x6E, 0x36, 0x1B, 0x19, 0x8C, 0xFE, 0x3E, 0x00,
  0xC3, 0xE1, 0xB1, 0x88, 0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x70, 0x38, 0x00,
  0xC6, 0x1E, 0x31, 0xB3, 0xCD, 0x9E, 0xCC, 0xB6, 0x6D, 0xE3, 0x4F, 0x1E,
  0x78, 0x73, 0x83, 0x1C, 0x00, 0x18, 0xE3, 0x30, 0x6E, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x81, 0x98, 0x73, 0x1C, 0x70, 0xE3, 0x66, 0x6C, 0x6C, 0x78,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x3F, 0x7F, 0x06, 0x0C, 0x18, 0x38, 0x70,
  0x60, 0xFE, 0xFC, 0x3C, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x38,
  0x93, 0x6D, 0x92, 0x6C, 0x1C, 0xB0, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x38, 0x0C, 0x38, 0x51, 0xB6, 0x7C, 0x40, 0xFC, 0xCC, 0x80, 0x36, 0xFF,
  0xBE, 0x6C, 0xD9, 0xBF, 0x76, 0x38, 0x30, 0x30, 0x36, 0x3E, 0x73, 0x63,
  0x67, 0x66, 0x7E, 0xDC, 0x39, 0xFE, 0x30, 0xC3, 0x0F, 0x9E, 0x03, 0x06,
  0x06, 0x36, 0x7E, 0xEE, 0xCC, 0xCC, 0xCC, 0xFC, 0xEC, 0x39, 0xFC, 0xF7,
  0xFB, 0x0C, 0x9E, 0x07, 0x0E, 0x1C, 0x1E, 0x3E, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x60, 0xE0, 0x1B, 0x3F, 0x77, 0x66, 0x66, 0x66, 0x7E,
  0x76, 0x0C, 0x8C, 0xF8, 0x38, 0x30, 0x30, 0x36, 0x3F, 0x73, 0x63, 0x66,
  0x66, 0x66, 0xC6, 0x11, 0xC0, 0x63, 0x39, 0x8C, 0x63, 0x30, 0x04, 0x1C,
  0x00, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x1C, 0x00, 0x38,
  0x18, 0x0C, 0x06, 0x73, 0x73, 0x71, 0xF0, 0xF8, 0x6C, 0x36, 0x31, 0x80,
  0x39, 0x8C, 0x63, 0x39, 0x8C, 0x63, 0x30, 0x26, 0x62, 0xEF, 0x73, 0x36,
  0x73, 0x66, 0x36, 0x66, 0x66, 0x6C, 0x66, 0x26, 0x2F, 0x73, 0x63, 0x66,
  0x66, 0x66, 0xC6, 0x38, 0xFB, 0x3E, 0x7C, 0xD9, 0xBF, 0x3C, 0x2E, 0x3E,
  0x73, 0x63, 0x67, 0x66, 0x7E, 0xDC, 0xC0, 0xC0, 0xC0, 0x36, 0xFF, 0xBE,
  0x6C, 0xD9, 0xBF, 0x76, 0x18, 0x30, 0x60, 0x34, 0xB7, 0x18, 0x61, 0x86,
  0x30, 0x3D, 0xF6, 0x1C, 0x38, 0x7D, 0xFE, 0x23, 0xFE, 0xCC, 0x63, 0x1E,
  0xF0, 0x66, 0xCF, 0x1E, 0x7C, 0xD9, 0xBF, 0x76, 0xC7, 0x9B, 0x36, 0xCD,
  0x9E, 0x3C, 0x30, 0xCC, 0x79, 0x9B, 0x73, 0x6A, 0xCF, 0x59, 0xCA, 0x39,
  0xC7, 0x30, 0x31, 0x8D, 0x87, 0x83, 0xC1, 0xC1, 0xF0, 0xD9, 0xCE, 0x31,
  0x99, 0x8C, 0xC6, 0xC3, 0x61, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x38, 0x00,
  0x3E, 0xF8, 0x70, 0xC3, 0x0C, 0x3F, 0x7C, 0x1C, 0x73, 0x0C, 0x33, 0x8E,
  0x18, 0x61, 0x86, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xE1, 0x86, 0x18,
  0x71, 0xCC, 0x30, 0xC6, 0x38, 0xF3, 0x7C,
};

const GFXglyph NotoSans_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 6, 4, 6, 1, -10 },
  { 9, 9, 10, 9, 0, -10 },
  { 21, 8, 12, 8, 0, -11 },
  { 33, 10, 10, 12, 1, -10 },
  { 46, 10, 10, 10, 0, -10 },
  { 59, 3, 4, 4, 1, -10 },
  { 61, 6, 12, 5, 0, -10 },
  { 70, 5, 12, 5, -1, -10 },
  { 78, 7, 7, 8, 1, -11 },
  { 85, 7, 6, 8, 1, -8 },
  { 91, 4, 4, 4, -1, -2 },
  { 93, 4, 2, 5, 0, -5 },
  { 94, 3, 2, 4, 0, -2 },
  { 95, 8, 10, 6, -1, -10 },
  { 105, 8, 10, 8, 0, -10 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 8, 10, 8, 0, -10 },
  { 133, 8, 10, 8, 0, -10 },
  { 143, 8, 10, 8, 0, -10 },
  { 153, 8, 10, 8, 0, -10 },
  { 163, 7, 10, 8, 1, -10 },
  { 172, 7, 10, 8, 1, -10 },
  { 181, 8, 10, 8, 0, -10 },
  { 191, 6, 10, 8, 1, -10 },
  { 199, 4, 8, 4, 0, -8 },
  { 203, 5, 10, 4, -1, -8 },
  { 210, 7, 8, 8, 1, -9 },
  { 217, 7, 4, 8, 1, -7 },
  { 221, 7, 8, 8, 1, -9 },
  { 228, 6, 10, 6, 1, -10 },
  { 236, 11, 11, 12, 1, -10 },
  { 252, 9, 10, 9, -1, -10 },
  { 264, 9, 10, 9, 0, -10 },
  { 276, 8, 10, 9, 1, -10 },
  { 286, 9, 10, 9, 0, -10 },
  { 298, 8, 10, 8, 0, -10 },
  { 308, 8, 10, 7, 0, -10 },
  { 318, 9, 10, 10, 1, -10 },
  { 330, 10, 10, 10, 0, -10 },
  { 343, 6, 10, 5, 0, -10 },
  { 351, 7, 13, 5, -2, -10 },
  { 363, 10, 10, 9, 0, -10 },
  { 376, 6, 10, 7, 0, -10 },
  { 384, 12, 10, 12, 0, -10 },
  { 399, 11, 10, 11, 0, -10 },
  { 413, 9, 10, 10, 1, -10 },
  { 425, 9, 10, 9, 0, -10 },
  { 437, 9, 12, 10, 1, -10 },
  { 451, 8, 10, 9, 0, -10 },
  { 461, 8, 10, 7, 0, -10 },
  { 471, 7, 10, 7, 1, -10 },
  { 480, 9, 10, 10, 1, -10 },
  { 492, 9, 10, 8, 1, -10 },
  { 504, 13, 10, 13, 1, -10 },
  { 521, 11, 10, 9, -1, -10 },
  { 535, 8, 10, 8, 1, -10 },
  { 545, 8, 10, 8, 0, -10 },
  { 555, 6, 12, 5, 0, -10 },
  { 564, 3, 10, 6, 2, -10 },
  { 568, 6, 12, 5, -1, -10 },
  { 577, 7, 6, 8, 0, -10 },
  { 583, 6, 1, 6, -1, 1 },
  { 584, 3, 3, 5, 2, -11 },
  { 586, 7, 8, 8, 1, -8 },
  { 593, 8, 11, 8, 0, -11 },
  { 604, 6, 8, 7, 1, -8 },
  { 610, 8, 11, 8, 1, -11 },
  { 621, 6, 8, 8, 1, -8 },
  { 627, 8, 14, 5, -1, -11 },
  { 641, 8, 11, 8, 0, -8 },
  { 652, 8, 11, 8, 0, -11 },
  { 663, 5, 11, 4, 0, -11 },
  { 670, 7, 14, 4, -2, -11 },
  { 683, 9, 11, 8, 0, -11 },
  { 696, 5, 11, 4, 0, -11 },
  { 703, 12, 8, 13, 0, -8 },
  { 715, 8, 8, 8, 0, -8 },
  { 723, 7, 8, 8, 1, -8 },
  { 730, 8, 11, 8, 0, -8 },
  { 741, 7, 11, 8, 1, -8 },
  { 751, 6, 8, 6, 0, -8 },
  { 757, 6, 8, 7, 0, -8 },
  { 763, 5, 9, 6, 1, -9 },
  { 769, 7, 8, 8, 1, -8 },
  { 776, 7, 8, 7, 1, -8 },
  { 783, 11, 8, 11, 1, -8 },
  { 794, 9, 8, 7, -1, -8 },
  { 803, 9, 11, 7, -1, -8 },
  { 816, 7, 8, 7, 0, -8 },
  { 823, 6, 12, 5, 0, -10 },
  { 832, 2, 14, 8, 3, -11 },
  { 836, 6, 12, 5, -1, -10 },
  { 845, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_BOLDITALIC14PT7B_H_
