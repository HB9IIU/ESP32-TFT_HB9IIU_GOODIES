#ifndef _NOTOSANS_BOLDITALIC13PT7B_H_
#define _NOTOSANS_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x5E, 0xF4, 0x1B, 0x1A, 0x7F, 0x7F,
  0x34, 0xFF, 0x2C, 0x68, 0x68, 0x08, 0x3C, 0xFB, 0x47, 0x87, 0x87, 0xCA,
  0xFC, 0x40, 0x80, 0x71, 0xB4, 0xC9, 0x62, 0xD6, 0xEB, 0xC7, 0xB3, 0x6C,
  0x9A, 0xC3, 0x80, 0x1E, 0x1B, 0x0D, 0x87, 0x83, 0x9B, 0x7B, 0x3C, 0xFC,
  0x7F, 0x00, 0x7C, 0x19, 0x88, 0xC6, 0x23, 0x18, 0x42, 0x18, 0x10, 0xC6,
  0x31, 0x8C, 0x66, 0x33, 0x30, 0x1A, 0x4F, 0x4F, 0xF1, 0x60, 0x30, 0xC3,
  0x3F, 0x30, 0xC3, 0x00, 0x36, 0x6C, 0xF0, 0xF0, 0x06, 0x08, 0x30, 0x41,
  0x86, 0x0C, 0x30, 0xE0, 0x3E, 0xED, 0x9B, 0x34, 0x78, 0xF3, 0x3E, 0x78,
  0x3B, 0xF6, 0x33, 0x18, 0xC6, 0x60, 0x3E, 0xCC, 0x18, 0x71, 0xC7, 0x18,
  0x7E, 0xFC, 0x7E, 0x4C, 0x18, 0xE3, 0x81, 0x83, 0x6E, 0xF8, 0x0E, 0x1C,
  0x51, 0xE6, 0xD9, 0xBF, 0x84, 0x18, 0x3E, 0x60, 0x83, 0xC7, 0xC1, 0x83,
  0x6E, 0xF8, 0x3D, 0x8C, 0x3E, 0xFF, 0x38, 0xF6, 0xF0, 0x7F, 0x06, 0x0E,
  0x0C, 0x18, 0x18, 0x30, 0x70, 0xE0, 0x3E, 0x4C, 0x99, 0xE3, 0xCD, 0xB1,
  0xF6, 0x7C, 0x7B, 0x3C, 0xF3, 0xFD, 0xA1, 0xAE, 0xE0, 0x76, 0x00, 0x0C,
  0xC0, 0x39, 0x80, 0x00, 0x11, 0x88, 0xC0, 0x04, 0x77, 0x30, 0x70, 0x70,
  0x40, 0xFF, 0xF0, 0x3F, 0x83, 0x83, 0x83, 0x7B, 0x08, 0x00, 0xFC, 0xC6,
  0x76, 0x20, 0x18, 0xC0, 0x1F, 0x98, 0x2C, 0xEE, 0x69, 0xB2, 0x6D, 0xBB,
  0xFA, 0x6C, 0xC2, 0x1F, 0x80, 0x07, 0x0F, 0x0B, 0x1B, 0x13, 0x3F, 0x3F,
  0x63, 0xC3, 0x3E, 0x33, 0x33, 0x3E, 0x7E, 0x66, 0x66, 0x7E, 0xFC, 0x3E,
  0xE7, 0x86, 0x0C, 0x18, 0x30, 0x7E, 0x7C, 0x3E, 0x37, 0x33, 0x23, 0x63,
  0x63, 0x67, 0x7E, 0xFC, 0x3F, 0x30, 0x30, 0x3E, 0x7C, 0x60, 0x60, 0x7C,
  0xFC, 0x3E, 0x60, 0xC1, 0x07, 0xCC, 0x18, 0x30, 0xC0, 0x3F, 0x72, 0xE0,
  0xC0, 0xCE, 0xD6, 0xC6, 0xFE, 0x7C, 0x31, 0x98, 0xCC, 0x67, 0xE7, 0xF3,
  0x19, 0x8C, 0xC6, 0xC6, 0x00, 0x7C, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0xF0,
  0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0xCF, 0x38, 0x33, 0x9B, 0x8D,
  0x85, 0x87, 0xC3, 0x61, 0xB0, 0xCC, 0xC6, 0x00, 0x30, 0xC3, 0x08, 0x61,
  0x86, 0x1F, 0xFC, 0x38, 0xF3, 0x8E, 0x29, 0xE2, 0x96, 0x6B, 0x46, 0xA4,
  0x6E, 0xC4, 0xCC, 0xCC, 0xC0, 0x38, 0xCE, 0x32, 0x89, 0xB6, 0x6D, 0x99,
  0x66, 0x71, 0x1C, 0xC3, 0x00, 0x3E, 0x77, 0xE3, 0xC3, 0xC3, 0xC3, 0xC6,
  0xFE, 0x7C, 0x3E, 0x33, 0x33, 0x23, 0x7E, 0x7C, 0x60, 0x60, 0xC0, 0x3E,
  0x77, 0xE3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0x7C, 0x0C, 0x0E, 0x3E, 0x37,
  0x33, 0x26, 0x7E, 0x6C, 0x6C, 0x66, 0xC6, 0x3E, 0xE5, 0x81, 0x83, 0x81,
  0x83, 0x7E, 0xF8, 0xFE, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x63,
  0x63, 0x63, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0xC7, 0xC6, 0xCC, 0xCC,
  0x48, 0x58, 0x50, 0x70, 0x60, 0xC6, 0x3C, 0xE6, 0xCE, 0x6D, 0xEC, 0xDE,
  0xCD, 0x68, 0xF7, 0x8E, 0x70, 0xE3, 0x00, 0x39, 0xC6, 0xE1, 0xB0, 0x38,
  0x0E, 0x07, 0x83, 0x61, 0xCC, 0xE3, 0x00, 0xC7, 0x6C, 0x6C, 0x78, 0x70,
  0x30, 0x60, 0x60, 0x60, 0x7F, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xFC,
  0xFC, 0x39, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x38, 0xC4, 0x46, 0x66, 0x62,
  0x30, 0x3C, 0x21, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x8E, 0x00, 0x08, 0x38,
  0xD1, 0x26, 0x58, 0xC0, 0xF8, 0xCC, 0x77, 0xDB, 0x36, 0x6C, 0xDB, 0x3E,
  0x00, 0x30, 0x60, 0xC1, 0x77, 0x6C, 0xD9, 0xB3, 0x6D, 0xF8, 0x7F, 0x71,
  0x8C, 0x6B, 0xC0, 0x06, 0x0C, 0x1B, 0xAE, 0xD9, 0xB3, 0x66, 0xD9, 0xD0,
  0x7F, 0xBC, 0xFE, 0xC3, 0x2F, 0x80, 0x0E, 0x3C, 0x61, 0xE1, 0x86, 0x0C,
  0x18, 0x30, 0x61, 0x87, 0x0C, 0x00, 0x3B, 0x76, 0x66, 0x66, 0x66, 0x6C,
  0x7C, 0x0C, 0x9C, 0xF8, 0x30, 0x60, 0xC1, 0x77, 0x6C, 0xD9, 0xB3, 0x47,
  0x98, 0x33, 0x03, 0x66, 0x66, 0x4C, 0x0C, 0x30, 0x03, 0x18, 0x61, 0x86,
  0x18, 0xC3, 0x3C, 0xE0, 0x30, 0x30, 0x30, 0x37, 0x6C, 0x78, 0x78, 0x7C,
  0x4C, 0xCE, 0x33, 0x33, 0x66, 0x66, 0x4C, 0x2E, 0xEE, 0xED, 0x99, 0xB3,
  0x36, 0x66, 0x88, 0xB3, 0x30, 0x2E, 0xED, 0x9B, 0x36, 0x68, 0xF3, 0x00,
  0x7B, 0xBC, 0xF3, 0xCF, 0x6F, 0x00, 0x2E, 0xED, 0x9B, 0x36, 0x6D, 0xB7,
  0x60, 0xC1, 0x80, 0x77, 0xDB, 0x36, 0x6C, 0xDB, 0x3E, 0x0C, 0x18, 0x60,
  0x2D, 0xF6, 0x18, 0x61, 0x0C, 0x00, 0x7D, 0x96, 0x0E, 0x1A, 0x6F, 0x80,
  0x23, 0x3E, 0x8C, 0x63, 0x1A, 0xE0, 0x67, 0x9B, 0x36, 0x6C, 0xDB, 0x3A,
  0x00, 0xCF, 0x3D, 0xB4, 0xF3, 0x8E, 0x00, 0xDC, 0xF7, 0x6D, 0xDB, 0xFC,
  0xEF, 0x3B, 0x8C, 0xE0, 0x33, 0x8F, 0x07, 0x03, 0x83, 0xC1, 0xB3, 0x98,
  0x33, 0x33, 0x36, 0x36, 0x3C, 0x38, 0x18, 0x30, 0xF0, 0xE0, 0x7C, 0x31,
  0x8C, 0x63, 0xEF, 0x80, 0x19, 0x8C, 0x66, 0x61, 0x8C, 0x63, 0x18, 0xFF,
  0xF8, 0x38, 0x61, 0x84, 0x18, 0x73, 0x0C, 0x21, 0x8E, 0x00, 0xC7, 0xF8,
  0x00,
};

const GFXglyph NotoSans_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 3, 6, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 10, 9, 11, 1, -9 },
  { 39, 9, 9, 9, 0, -9 },
  { 50, 2, 3, 3, 1, -9 },
  { 51, 5, 11, 4, 0, -9 },
  { 58, 5, 11, 4, -1, -9 },
  { 65, 6, 6, 7, 1, -10 },
  { 70, 6, 7, 7, 1, -8 },
  { 76, 4, 4, 4, -1, -2 },
  { 78, 4, 1, 4, 0, -4 },
  { 79, 2, 2, 4, 0, -2 },
  { 80, 7, 9, 6, -1, -9 },
  { 88, 7, 9, 7, 0, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 7, 9, 7, 0, -9 },
  { 110, 7, 9, 7, 0, -9 },
  { 118, 7, 9, 7, 0, -9 },
  { 126, 7, 9, 7, 0, -9 },
  { 134, 6, 9, 7, 1, -9 },
  { 141, 8, 9, 7, 0, -9 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 6, 9, 7, 1, -9 },
  { 165, 4, 7, 4, 0, -7 },
  { 169, 5, 9, 4, -1, -7 },
  { 175, 6, 7, 7, 1, -8 },
  { 181, 6, 4, 7, 1, -7 },
  { 184, 6, 7, 7, 1, -8 },
  { 190, 5, 9, 6, 1, -9 },
  { 196, 10, 10, 11, 1, -9 },
  { 209, 8, 9, 8, -1, -9 },
  { 218, 8, 9, 8, 0, -9 },
  { 227, 7, 9, 8, 1, -9 },
  { 235, 8, 9, 9, 0, -9 },
  { 244, 8, 9, 7, 0, -9 },
  { 253, 7, 9, 7, 0, -9 },
  { 261, 8, 9, 9, 1, -9 },
  { 270, 9, 9, 9, 0, -9 },
  { 281, 6, 9, 5, 0, -9 },
  { 288, 6, 12, 4, -2, -9 },
  { 297, 9, 9, 8, 0, -9 },
  { 308, 6, 9, 7, 0, -9 },
  { 315, 12, 9, 11, 0, -9 },
  { 329, 10, 9, 10, 0, -9 },
  { 341, 8, 9, 10, 1, -9 },
  { 350, 8, 9, 8, 0, -9 },
  { 359, 8, 11, 10, 1, -9 },
  { 370, 8, 9, 8, 0, -9 },
  { 379, 7, 9, 7, 0, -9 },
  { 387, 7, 9, 7, 1, -9 },
  { 395, 8, 9, 9, 1, -9 },
  { 404, 8, 9, 8, 1, -9 },
  { 413, 12, 9, 12, 1, -9 },
  { 427, 10, 9, 8, -1, -9 },
  { 439, 8, 9, 7, 1, -9 },
  { 448, 8, 9, 7, 0, -9 },
  { 457, 5, 11, 4, 0, -9 },
  { 464, 4, 9, 6, 1, -9 },
  { 469, 6, 11, 4, -1, -9 },
  { 478, 7, 6, 7, 0, -9 },
  { 484, 5, 1, 5, -1, 1 },
  { 485, 3, 2, 4, 2, -10 },
  { 486, 7, 7, 8, 1, -7 },
  { 493, 7, 10, 8, 0, -10 },
  { 502, 5, 7, 6, 1, -7 },
  { 507, 7, 10, 8, 1, -10 },
  { 516, 6, 7, 7, 1, -7 },
  { 522, 7, 13, 5, -1, -10 },
  { 534, 8, 10, 8, 0, -7 },
  { 544, 7, 10, 8, 0, -10 },
  { 553, 4, 10, 4, 0, -10 },
  { 558, 6, 13, 4, -2, -10 },
  { 568, 8, 10, 7, 0, -10 },
  { 578, 4, 10, 4, 0, -10 },
  { 583, 11, 7, 12, 0, -7 },
  { 593, 7, 7, 8, 0, -7 },
  { 600, 6, 7, 8, 1, -7 },
  { 606, 7, 10, 8, 0, -7 },
  { 615, 7, 10, 8, 1, -7 },
  { 624, 6, 7, 5, 0, -7 },
  { 630, 6, 7, 6, 0, -7 },
  { 636, 5, 9, 5, 1, -9 },
  { 642, 7, 7, 8, 1, -7 },
  { 649, 6, 7, 7, 1, -7 },
  { 655, 10, 7, 10, 1, -7 },
  { 664, 9, 7, 7, -1, -7 },
  { 672, 8, 10, 7, -1, -7 },
  { 682, 6, 7, 6, 0, -7 },
  { 688, 5, 11, 5, 0, -9 },
  { 695, 1, 13, 7, 3, -10 },
  { 697, 6, 11, 5, -1, -9 },
  { 706, 6, 3, 7, 1, -6 },
};

const GFXfont NotoSans_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_BOLDITALIC13PT7B_H_
