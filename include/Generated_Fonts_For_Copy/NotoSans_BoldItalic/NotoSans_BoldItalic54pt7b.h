#ifndef _NOTOSANS_BOLDITALIC54PT7B_H_
#define _NOTOSANS_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x3F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F,
  0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF3,
  0xC1, 0x80, 0x7F, 0x9E, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x3F, 0xC7, 0x80,
  0x01, 0xFF, 0x38, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x1E, 0x7F, 0x80,
  0x00, 0xF3, 0xFC, 0x00, 0x07, 0x1F, 0xE3, 0x00, 0x78, 0xFF, 0x1F, 0x03,
  0xCF, 0xF8, 0xFF, 0xDF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x01,
  0xFE, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x3F,
  0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x8F, 0xC1, 0xE0, 0xFE, 0x3F, 0x8F, 0xC7,
  0xFC, 0x7F, 0x1F, 0xCF, 0xC7, 0xFF, 0x3F, 0x9F, 0xCF, 0xE7, 0xFF, 0xCF,
  0xFF, 0xE7, 0xE7, 0xFF, 0xF7, 0xFF, 0xE7, 0xE7, 0xFF, 0xF9, 0xFF, 0xE7,
  0xE3, 0xF9, 0xFC, 0x7F, 0xE7, 0xF3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x01, 0xF8,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xFE, 0x01, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8,
  0x3F, 0xEF, 0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0xE0,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF3,
  0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x08, 0x07, 0xE0, 0x07, 0x81, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0xFF, 0x9F, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFC, 0x3E, 0x07, 0xFF, 0x80, 0x03, 0xFB, 0xE0, 0x01, 0xFC, 0xFC, 0x01,
  0xFF, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF0, 0x7F,
  0x00, 0x18, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00,
  0x1F, 0x8F, 0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFC, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F,
  0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9,
  0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF8, 0xFF, 0x3F, 0xC3, 0xF1, 0xFE, 0x1E,
  0x0F, 0xF0, 0x60, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFC, 0x01, 0x80, 0x0F, 0xF0, 0x04, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1E, 0x01, 0xFF, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x02, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF2,
  0x00, 0x00, 0xFF, 0x1C, 0x00, 0x1F, 0xF8, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC2, 0x00, 0x03, 0xFE, 0x18, 0x00, 0x3F, 0xF0, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0xFF, 0xC0,
  0x3F, 0x9F, 0xFF, 0x03, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xE7, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0x83, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80,
  0x7F, 0xEF, 0xF8, 0x0F, 0xF8, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xF0, 0x7F, 0xF9,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xF3, 0xFF, 0x1F, 0x01, 0xFE, 0x10, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF3, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0xFF, 0x87, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x1F, 0x81, 0xFF, 0xFF,
  0x83, 0xF3, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x3F, 0x03, 0xF8, 0x3F, 0x03,
  0xF3, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0x03, 0xF7,
  0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE7, 0xE1,
  0xF8, 0x07, 0xE0, 0x7E, 0x7C, 0x1F, 0x80, 0x7E, 0x07, 0xEF, 0xC1, 0xF8,
  0x0F, 0xC0, 0x7E, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F,
  0xC0, 0xFC, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0xC3,
  0xF8, 0x7E, 0x1F, 0xCF, 0xFC, 0x7F, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7E, 0x0F, 0xFF, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x80, 0x7F,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xF0, 0x0E, 0x00, 0x30, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7C, 0x07,
  0xFE, 0x00, 0x08, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x3F,
  0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x3F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x78, 0x07, 0xFF, 0x00,
  0x06, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x1F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xF8,
  0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF,
  0xE3, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0xC0, 0x1F, 0xE0, 0x3F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7B, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0x80,
  0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x03, 0xF9, 0xF8, 0x07,
  0xF7, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x81, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0x03, 0xF1, 0xFE, 0x01, 0xFC, 0x7E, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x7F, 0x1F,
  0xE0, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF3, 0xF8, 0x7F,
  0x80, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xDF, 0x81, 0xFC,
  0x01, 0xFC, 0x1F, 0xBF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0x80,
  0x3F, 0x81, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x01,
  0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFC, 0x03,
  0xF9, 0xFC, 0x03, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x07, 0xF9, 0xFE,
  0x03, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE0, 0x3F, 0xCF, 0xE0, 0x1F,
  0xE0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x07, 0xFE, 0x07, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3C, 0x07, 0xFC,
  0x00, 0x40, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x80, 0x01, 0xFF, 0x0E, 0x00, 0x3F, 0xE0, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x90, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x1F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xE0, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFB, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF3, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xF3, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF3, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xE3, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE3, 0xF0,
  0xFF, 0x00, 0xFF, 0x1F, 0xC3, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC3, 0xF1,
  0xFE, 0x00, 0x7F, 0x1F, 0x83, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0x83, 0xF1,
  0xFC, 0x00, 0x7F, 0x3F, 0x03, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x03, 0xF3,
  0xF8, 0x00, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x03, 0xF7,
  0xF0, 0x00, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0,
  0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFC,
  0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0xFF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xC0,
  0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFC, 0xFE, 0x01, 0xFF, 0xC7,
  0xE0, 0x07, 0xFC, 0x3F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x7C, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0xE0,
  0x0F, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFD, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F,
  0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE,
  0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0x7F, 0xFF, 0x03, 0xF9, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0x00, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFD, 0xF8, 0x3F, 0xF0, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x40, 0xFF, 0xC1, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x7F, 0xE7, 0xF8, 0x01,
  0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x1F, 0xFE, 0x7E, 0x00, 0x07,
  0xF8, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE7,
  0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x83, 0xFE, 0x00, 0xE0, 0x7F, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC7, 0xF0,
  0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF,
  0xE0, 0x0F, 0xFE, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x08,
  0x00, 0x3F, 0xE0, 0x30, 0x01, 0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0xCF, 0xFC, 0x01, 0xFC, 0xFF,
  0xF0, 0x0F, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x87, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8,
  0x07, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0xFF, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0x87, 0xFE, 0x00, 0xFC, 0x7F, 0xF8, 0x07, 0xE7, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xF0, 0xFF, 0xC1, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0xF0, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0x7E, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0x80, 0x1F, 0xE7,
  0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x1F, 0xE0, 0x20, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC7,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xCF, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x06,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0xFF, 0x03, 0xF9, 0xFE, 0x03, 0xF3, 0xFE, 0x07, 0xF7,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF0,
  0x3C, 0x1F, 0xE0, 0x08, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x07,
  0xF8, 0xE0, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x83, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xF3,
  0xF0, 0x1F, 0xFF, 0x1F, 0x80, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF8, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF9, 0xFE, 0x00,
  0x3F, 0x9F, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF8,
  0x07, 0xFB, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x7F, 0x03, 0xFF, 0x80, 0xFF,
  0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0x87, 0xF0, 0x3E, 0xF8, 0x1F, 0xE1, 0xFC,
  0x1F, 0xBE, 0x07, 0xF8, 0x7F, 0x07, 0xEF, 0x83, 0xFC, 0x1F, 0xC3, 0xF3,
  0xE0, 0xFF, 0x07, 0xF0, 0xFC, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x7E, 0x1F,
  0xE0, 0x7F, 0x1F, 0x9F, 0x8F, 0xF0, 0x1F, 0xC7, 0xE7, 0xE3, 0xFC, 0x07,
  0xF3, 0xF1, 0xF8, 0xFE, 0x01, 0xFC, 0xFC, 0x7E, 0x7F, 0x80, 0x7F, 0x7F,
  0x1F, 0x9F, 0xC0, 0x1F, 0xDF, 0x87, 0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0xFB,
  0xF8, 0x01, 0xFF, 0xF0, 0x3E, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xBF, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x16, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x80, 0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 40, 16, 1, -39 },
  { 81, 20, 14, 24, 5, -39 },
  { 116, 34, 39, 35, 1, -39 },
  { 282, 29, 44, 30, 1, -41 },
  { 442, 41, 39, 46, 3, -39 },
  { 642, 36, 40, 38, 2, -39 },
  { 822, 9, 14, 14, 5, -39 },
  { 838, 20, 48, 18, 2, -39 },
  { 958, 20, 48, 18, -4, -39 },
  { 1078, 26, 26, 29, 5, -41 },
  { 1163, 26, 26, 31, 3, -32 },
  { 1248, 13, 13, 16, -3, -6 },
  { 1270, 15, 7, 17, 1, -18 },
  { 1284, 10, 9, 16, 0, -8 },
  { 1296, 29, 39, 23, -2, -39 },
  { 1438, 27, 40, 30, 2, -39 },
  { 1573, 21, 39, 30, 5, -39 },
  { 1676, 30, 39, 30, -1, -39 },
  { 1823, 29, 40, 30, 0, -39 },
  { 1968, 30, 39, 30, -1, -39 },
  { 2115, 29, 40, 30, 1, -39 },
  { 2260, 28, 40, 30, 2, -39 },
  { 2400, 30, 39, 30, 2, -39 },
  { 2547, 29, 40, 30, 1, -39 },
  { 2692, 27, 40, 30, 2, -39 },
  { 2827, 15, 31, 16, 0, -30 },
  { 2886, 18, 37, 16, -3, -30 },
  { 2970, 26, 29, 31, 3, -34 },
  { 3065, 26, 16, 31, 3, -27 },
  { 3117, 26, 29, 31, 3, -34 },
  { 3212, 23, 40, 25, 4, -39 },
  { 3327, 44, 44, 46, 2, -39 },
  { 3569, 34, 39, 34, -3, -39 },
  { 3735, 32, 39, 33, 1, -39 },
  { 3891, 32, 40, 33, 3, -39 },
  { 4051, 34, 39, 37, 1, -39 },
  { 4217, 30, 39, 29, 1, -39 },
  { 4364, 30, 39, 29, 1, -39 },
  { 4511, 34, 40, 37, 3, -39 },
  { 4681, 37, 39, 38, 1, -39 },
  { 4862, 26, 39, 21, -2, -39 },
  { 4989, 27, 50, 18, -9, -39 },
  { 5158, 37, 39, 33, 1, -39 },
  { 5339, 23, 39, 28, 1, -39 },
  { 5452, 47, 39, 48, 1, -39 },
  { 5682, 40, 39, 41, 1, -39 },
  { 5877, 35, 40, 39, 3, -39 },
  { 6052, 32, 39, 33, 1, -39 },
  { 6208, 35, 48, 39, 3, -39 },
  { 6418, 31, 39, 33, 1, -39 },
  { 6570, 28, 40, 29, 1, -39 },
  { 6710, 29, 39, 29, 4, -39 },
  { 6852, 34, 40, 37, 4, -39 },
  { 7022, 32, 39, 32, 5, -39 },
  { 7178, 48, 39, 48, 5, -39 },
  { 7412, 40, 39, 33, -3, -39 },
  { 7607, 30, 39, 30, 5, -39 },
  { 7754, 34, 39, 29, -2, -39 },
  { 7920, 23, 48, 18, -1, -39 },
  { 8058, 13, 39, 23, 6, -39 },
  { 8122, 23, 48, 18, -4, -39 },
  { 8260, 27, 25, 30, 1, -39 },
  { 8345, 23, 4, 22, -5, 5 },
  { 8357, 11, 8, 18, 8, -41 },
  { 8368, 29, 31, 32, 2, -30 },
  { 8481, 29, 42, 32, 1, -41 },
  { 8634, 25, 31, 26, 2, -30 },
  { 8731, 32, 42, 32, 2, -41 },
  { 8899, 27, 31, 30, 2, -30 },
  { 9004, 32, 54, 20, -6, -41 },
  { 9220, 30, 43, 32, 1, -30 },
  { 9382, 29, 41, 33, 1, -41 },
  { 9531, 16, 41, 16, 1, -41 },
  { 9613, 24, 54, 16, -7, -41 },
  { 9775, 32, 41, 31, 1, -41 },
  { 9939, 17, 41, 16, 1, -41 },
  { 10027, 45, 30, 49, 1, -30 },
  { 10196, 29, 30, 33, 1, -30 },
  { 10305, 27, 31, 32, 2, -30 },
  { 10410, 32, 43, 32, -2, -30 },
  { 10582, 29, 43, 32, 2, -30 },
  { 10738, 24, 30, 23, 1, -30 },
  { 10828, 24, 31, 26, 1, -30 },
  { 10921, 21, 37, 22, 2, -36 },
  { 11019, 29, 30, 33, 3, -29 },
  { 11128, 28, 29, 28, 3, -29 },
  { 11230, 42, 29, 43, 3, -29 },
  { 11383, 34, 29, 29, -3, -29 },
  { 11507, 35, 42, 28, -4, -29 },
  { 11691, 27, 29, 25, -1, -29 },
  { 11789, 23, 48, 19, 0, -39 },
  { 11927, 6, 53, 30, 12, -41 },
  { 11967, 22, 48, 19, -3, -39 },
  { 12099, 26, 9, 31, 3, -24 },
};

const GFXfont NotoSans_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_BOLDITALIC54PT7B_H_
