#ifndef _NOTOSANS_BOLDITALIC51PT7B_H_
#define _NOTOSANS_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x3F,
  0x8F, 0xE7, 0xE1, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x04, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0x3E, 0x07, 0xF9, 0xE0, 0xC0, 0xFF,
  0x3C, 0x00, 0x1F, 0xE7, 0x80, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0x9C, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xCF, 0xF0, 0x00, 0x79,
  0xFE, 0x00, 0x0F, 0x3F, 0xC8, 0x01, 0xC7, 0xF9, 0xC0, 0x38, 0xFE, 0x3F,
  0x0F, 0x7F, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x10, 0x0F, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xE0, 0x1F, 0xC7, 0xE0,
  0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x01,
  0xFC, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x8F, 0xC7, 0xF8, 0xFC, 0x7F,
  0x3F, 0x3F, 0xF9, 0xFD, 0xFC, 0xFC, 0xFF, 0xFB, 0xFF, 0xF9, 0xF3, 0xFF,
  0xF3, 0xFF, 0xE7, 0xE7, 0xFF, 0xE7, 0xFF, 0x9F, 0x9F, 0xCF, 0xE7, 0xFE,
  0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0xFE, 0x1F, 0x80, 0x03, 0xF1, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE1, 0xFC, 0x00,
  0x7E, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xFE, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8,
  0x03, 0xF8, 0x3F, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF,
  0xFC, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF,
  0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x9F, 0xF0, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0x80, 0xFC, 0x00, 0xF0,
  0x7C, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0xDF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xF7, 0xC0,
  0x0F, 0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x38, 0x3F,
  0x00, 0x08, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0x1F, 0xDF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF,
  0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0xCF, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xF9, 0xFC, 0x7F, 0x3F, 0xC3, 0xC3, 0xF8, 0x38, 0x3F,
  0x82, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x1F, 0xF8, 0x07, 0x00, 0xFF, 0x00,
  0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0x80, 0x01,
  0xFF, 0x3C, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x88, 0x00, 0x3F,
  0xE1, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xF0, 0x30, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x87, 0x80, 0x0F, 0xE7, 0xFE, 0x01, 0xFD, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0x87,
  0xFC, 0x0F, 0xF1, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03,
  0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFD,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB,
  0xF8, 0x3F, 0xFB, 0xFC, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC2, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFC, 0x3F, 0xE7, 0x00, 0xFF,
  0x20, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xFF, 0x87, 0xE3, 0xF0, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0x1F, 0xFF,
  0xE1, 0xF9, 0xF8, 0x1F, 0xFF, 0xF0, 0x7C, 0xF8, 0x1F, 0xC1, 0xF0, 0x3E,
  0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xBE, 0x0F,
  0xC0, 0x7E, 0x0F, 0xDF, 0x07, 0xE0, 0x3E, 0x07, 0xEF, 0x83, 0xE0, 0x3F,
  0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0x81, 0xF7, 0xE1, 0xF8, 0x0F, 0xC1, 0xFB,
  0xF0, 0xFC, 0x0F, 0xC0, 0xFD, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0xFC, 0x3F,
  0x07, 0xF0, 0x7E, 0x7E, 0x1F, 0x87, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xE1, 0xFF, 0xCF, 0xFF, 0x03,
  0xF0, 0x7F, 0xC3, 0xFE, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x3C, 0x0F,
  0xFC, 0x00, 0x20, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x08, 0x07, 0xFF, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xF0,
  0x3F, 0x87, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x38,
  0x0F, 0xFC, 0x00, 0x08, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFC,
  0x7F, 0x80, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF8,
  0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF8,
  0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x0F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0x7F,
  0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0x7E, 0x00, 0xFD, 0xFC,
  0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x7E, 0x01, 0xFB, 0xF8, 0x07,
  0xF7, 0xE0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xE7,
  0xE0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0,
  0xFC, 0x7F, 0x00, 0xFE, 0x3E, 0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7F, 0x01, 0xFC, 0x3E, 0x1F, 0x8F, 0xF0, 0x1F, 0xC3, 0xE3, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF7, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x3F,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xC0,
  0x3F, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF3, 0xF8,
  0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x7F, 0x07, 0xF8, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8,
  0x7F, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x0F,
  0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x07, 0xF3,
  0xF8, 0x07, 0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0xFE,
  0x00, 0xFE, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0xC1, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x18, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x08, 0x00, 0x1F, 0xC1, 0x80, 0x07, 0xF8, 0x3E, 0x03, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xEF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xE0, 0x0F,
  0xF3, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xF8,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFF, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0x7E, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF7, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xBF, 0x07, 0xF8, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xCF,
  0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x7E, 0x1F, 0xC0, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFE, 0x01, 0xFC, 0x7F, 0x1F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F,
  0x00, 0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0x03, 0xF9, 0xF8, 0x3F, 0x3F, 0x80,
  0x1F, 0xDF, 0xC1, 0xF9, 0xFC, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x07,
  0xF7, 0xE0, 0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x1F,
  0xCF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xC0, 0x03,
  0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x00, 0x7F, 0x87, 0xE0, 0x3F, 0xF8, 0xFC, 0x0F, 0xFF, 0x9F, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x1F,
  0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xE3, 0xF0, 0x07, 0xF8, 0x7E, 0x00,
  0x08, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xBF, 0xF0, 0x0F,
  0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xE0,
  0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x07, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0x81, 0xF8, 0xFF, 0xE0, 0x3F,
  0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFE, 0x06, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x02, 0x0F, 0xF8, 0x1C, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xBF, 0x80, 0x7F,
  0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFC,
  0x00, 0x7F, 0xF3, 0xF0, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0xC0, 0xFE, 0x3F, 0xC0,
  0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xC1, 0xFF, 0x83, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xC1, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x0F,
  0xFE, 0x3F, 0x01, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xEF, 0xE0, 0x0F, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x80,
  0x07, 0xF8, 0x0E, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x9F, 0xF8, 0x0F,
  0xEF, 0xFF, 0x81, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFC, 0x3F, 0xF0, 0x3F, 0x87, 0xFC, 0x07, 0xF0, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0x9F, 0xFF, 0x1F, 0xFE, 0x03, 0xF3, 0xFF,
  0xE7, 0xFF, 0xE0, 0x7E, 0xFF, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0xFF, 0x00, 0x7C, 0x3F, 0xF0, 0x1F, 0x9F, 0xFF, 0x03, 0xF3,
  0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xF8,
  0x7F, 0xE0, 0x7F, 0x0F, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xF8, 0xFF, 0x81,
  0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xF1, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0x00, 0x3F, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFC, 0x01,
  0xFC, 0xFF, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xE0, 0x1F, 0xF8, 0xFC, 0x0F,
  0xFF, 0x9F, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x80, 0x7F, 0xE7, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x3F, 0xC1, 0xFD, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0x83, 0xE1, 0xFC, 0x03, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF3, 0x00, 0x7F,
  0x8F, 0x87, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0x0F, 0xE0, 0x7F, 0xE1, 0xFE,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0xE0, 0xFF, 0xFC, 0xFC,
  0x0F, 0xFF, 0x9F, 0x80, 0xFF, 0xC7, 0xE0, 0x0F, 0xF0, 0xFC, 0x00, 0x30,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0,
  0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0xFE, 0x03, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0xFE, 0x07,
  0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0x07,
  0xF0, 0x7E, 0x0F, 0xFF, 0x0F, 0xF0, 0x7E, 0x0F, 0xBF, 0x0F, 0xE0, 0x7E,
  0x1F, 0xBF, 0x0F, 0xE0, 0x7E, 0x1F, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x3F,
  0x1F, 0xC0, 0x7E, 0x3F, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x3F, 0x3F, 0x80,
  0x7E, 0x7E, 0x3F, 0x3F, 0x80, 0x7E, 0x7C, 0x3F, 0x7F, 0x00, 0x7E, 0xFC,
  0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x3F, 0xFE, 0x00, 0x7E, 0xF8, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xF8, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xFC,
};

const GFXglyph NotoSans_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 37, 15, 1, -36 },
  { 71, 19, 13, 23, 5, -36 },
  { 102, 32, 36, 33, 1, -36 },
  { 246, 27, 42, 28, 1, -39 },
  { 388, 39, 37, 44, 3, -37 },
  { 569, 34, 38, 36, 2, -37 },
  { 731, 9, 13, 13, 5, -36 },
  { 746, 19, 44, 17, 2, -36 },
  { 851, 20, 45, 17, -4, -37 },
  { 964, 25, 25, 28, 4, -39 },
  { 1043, 24, 24, 29, 3, -30 },
  { 1115, 12, 13, 15, -2, -6 },
  { 1135, 14, 7, 16, 1, -17 },
  { 1148, 9, 9, 15, 0, -8 },
  { 1159, 27, 37, 22, -2, -37 },
  { 1284, 26, 38, 28, 2, -37 },
  { 1408, 20, 36, 28, 5, -36 },
  { 1498, 28, 37, 28, -1, -37 },
  { 1628, 27, 38, 28, 0, -37 },
  { 1757, 28, 36, 28, -1, -36 },
  { 1883, 27, 37, 28, 1, -36 },
  { 2008, 27, 38, 28, 2, -37 },
  { 2137, 28, 36, 28, 2, -36 },
  { 2263, 27, 38, 28, 1, -37 },
  { 2392, 25, 38, 28, 2, -37 },
  { 2511, 14, 29, 15, 0, -28 },
  { 2562, 17, 35, 15, -3, -28 },
  { 2637, 24, 27, 29, 3, -32 },
  { 2718, 24, 16, 29, 3, -26 },
  { 2766, 24, 27, 29, 3, -32 },
  { 2847, 21, 38, 23, 4, -37 },
  { 2947, 41, 41, 44, 2, -36 },
  { 3158, 32, 36, 32, -3, -36 },
  { 3302, 30, 36, 32, 1, -36 },
  { 3437, 30, 38, 31, 3, -37 },
  { 3580, 32, 36, 35, 1, -36 },
  { 3724, 28, 36, 28, 1, -36 },
  { 3850, 28, 36, 27, 1, -36 },
  { 3976, 32, 38, 35, 3, -37 },
  { 4128, 35, 36, 36, 1, -36 },
  { 4286, 23, 36, 20, -1, -36 },
  { 4390, 25, 47, 17, -8, -36 },
  { 4537, 35, 36, 31, 1, -36 },
  { 4695, 22, 36, 26, 1, -36 },
  { 4794, 44, 36, 45, 1, -36 },
  { 4992, 38, 36, 39, 1, -36 },
  { 5163, 33, 38, 37, 3, -37 },
  { 5320, 30, 36, 31, 1, -36 },
  { 5455, 33, 46, 37, 3, -37 },
  { 5645, 29, 36, 32, 1, -36 },
  { 5776, 27, 38, 27, 1, -37 },
  { 5905, 27, 36, 27, 4, -36 },
  { 6027, 33, 37, 35, 3, -36 },
  { 6180, 30, 36, 30, 5, -36 },
  { 6315, 45, 36, 46, 5, -36 },
  { 6518, 38, 36, 31, -3, -36 },
  { 6689, 28, 36, 29, 5, -36 },
  { 6815, 32, 36, 27, -2, -36 },
  { 6959, 21, 44, 17, -1, -36 },
  { 7075, 12, 37, 22, 6, -37 },
  { 7131, 21, 44, 17, -3, -36 },
  { 7247, 26, 24, 28, 1, -37 },
  { 7325, 22, 3, 20, -5, 5 },
  { 7334, 11, 8, 17, 7, -39 },
  { 7345, 27, 29, 30, 2, -28 },
  { 7443, 27, 40, 30, 1, -39 },
  { 7578, 23, 29, 25, 2, -28 },
  { 7662, 30, 40, 30, 2, -39 },
  { 7812, 25, 29, 28, 2, -28 },
  { 7903, 30, 51, 19, -5, -39 },
  { 8095, 28, 40, 30, 1, -28 },
  { 8235, 27, 39, 31, 1, -39 },
  { 8367, 15, 39, 15, 1, -39 },
  { 8441, 23, 51, 15, -7, -39 },
  { 8588, 30, 39, 29, 1, -39 },
  { 8735, 16, 39, 15, 1, -39 },
  { 8813, 43, 28, 46, 1, -28 },
  { 8964, 27, 28, 31, 1, -28 },
  { 9059, 26, 29, 30, 2, -28 },
  { 9154, 30, 40, 30, -2, -28 },
  { 9304, 27, 40, 30, 2, -28 },
  { 9439, 22, 28, 22, 1, -28 },
  { 9516, 22, 29, 24, 1, -28 },
  { 9596, 20, 35, 21, 2, -34 },
  { 9684, 27, 29, 31, 3, -28 },
  { 9782, 26, 28, 26, 3, -28 },
  { 9873, 40, 28, 40, 3, -28 },
  { 10013, 33, 28, 27, -3, -28 },
  { 10129, 33, 40, 26, -4, -28 },
  { 10294, 25, 28, 24, -1, -28 },
  { 10382, 21, 44, 18, 0, -36 },
  { 10498, 6, 51, 28, 11, -39 },
  { 10537, 21, 44, 18, -3, -36 },
  { 10653, 24, 8, 29, 3, -22 },
};

const GFXfont NotoSans_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_BOLDITALIC51PT7B_H_
