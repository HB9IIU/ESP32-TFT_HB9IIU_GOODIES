#ifndef _NOTOSANS_BOLDITALIC57PT7B_H_
#define _NOTOSANS_BOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x87, 0xFB, 0xFC, 0x3F,
  0x9F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x07, 0xF1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xBC,
  0x3C, 0x07, 0xF8, 0xF0, 0x20, 0x1F, 0xE3, 0xC0, 0x00, 0x7F, 0x8F, 0x00,
  0x01, 0xFE, 0x38, 0x00, 0x07, 0xFD, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xEF,
  0xFC, 0x00, 0x07, 0x9F, 0xF0, 0x00, 0x1E, 0x7F, 0xC0, 0x00, 0xF1, 0xFF,
  0x30, 0x03, 0xC7, 0xFC, 0xF0, 0x0F, 0x1F, 0xE3, 0xF8, 0x3D, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xE3, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x3F, 0xF8,
  0xFE, 0x3F, 0xCF, 0xE7, 0xFF, 0xC7, 0xFF, 0xF9, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFE,
  0x7F, 0x3F, 0xC7, 0xF1, 0xFF, 0xCF, 0xE3, 0xF8, 0x7F, 0x0F, 0xF0, 0xFC,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x07,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xF3, 0xFE, 0x1F, 0xE1, 0xFF,
  0x8F, 0xFC, 0xFF, 0x87, 0xFC, 0x1F, 0xF3, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0xDF, 0xEF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0C, 0x03, 0xF0,
  0x01, 0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xF1, 0xF0, 0x03, 0xFF,
  0xBE, 0x00, 0x7F, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0C, 0x1F, 0xFF, 0x00, 0x07, 0xFB, 0xF0, 0x01, 0xFE, 0x7E, 0x00,
  0xFF, 0x8F, 0xE0, 0x0F, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0x03,
  0xF8, 0x00, 0x60, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x0F, 0xF7, 0xFD, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0x7F, 0x87, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE,
  0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE,
  0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xDF, 0xE3, 0xFF, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xE1, 0xFE, 0x07, 0x03,
  0xFC, 0x0C, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFE,
  0x00, 0xFC, 0x03, 0xFE, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x20, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x60, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0xFF, 0xC3,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x30, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x80, 0x00, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0x0F, 0xFB,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0x00, 0xFF, 0x7F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xF8, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0,
  0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xCF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE,
  0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF,
  0x00, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xF3, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD, 0xFE,
  0x07, 0xFF, 0x9F, 0xE0, 0x3F, 0xF3, 0xFE, 0x00, 0x78, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0x01, 0xFF,
  0x18, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x07, 0xE1, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xE1,
  0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xE7, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x7F, 0x03, 0xFE, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xDF,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xFF, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0xF0, 0x7F,
  0x01, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x0F, 0xC0, 0x7E, 0xFC, 0x1F, 0x80,
  0x7E, 0x03, 0xF7, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0xBF, 0x07, 0xE0, 0x3F,
  0x81, 0xF9, 0xF8, 0x3F, 0x03, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0x1F, 0xC0,
  0xFC, 0x7E, 0x0F, 0xE1, 0xFF, 0x1F, 0xE3, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x3F, 0xFE, 0x07,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0x06, 0x01, 0xFF,
  0x80, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x20, 0x0F, 0xFE, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFE, 0x03,
  0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xC0,
  0x3F, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x8F,
  0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF,
  0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x3F,
  0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0x80, 0x0F, 0xDF, 0xE0, 0x1F,
  0xEF, 0xC0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x07,
  0xF3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xFC, 0x03,
  0xFC, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x7E, 0x01, 0xF8, 0xFF, 0x00,
  0xFF, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x80,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x3F, 0x83, 0xFC,
  0x03, 0xFC, 0x3F, 0x9F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xDF, 0xC0, 0xFE,
  0x00, 0xFF, 0x07, 0xEF, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x7F,
  0x80, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0,
  0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE3, 0xF8, 0x03, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF7, 0xF8, 0x07,
  0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x00, 0x20, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x20, 0x00, 0x3F, 0xE0, 0xC0,
  0x00, 0xFF, 0x83, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xEF, 0xE0, 0x7F, 0xC0, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x80, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x1F, 0xC3, 0xFC, 0x00,
  0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x80, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x07, 0xF3,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x41, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFC, 0xFE, 0x07,
  0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0x00, 0xFF, 0xF9, 0xFC,
  0x03, 0xFF, 0xC7, 0xF0, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x83, 0x80, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF3, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07,
  0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xE0, 0x7E, 0x7F, 0xFF, 0x03, 0xF8, 0xFF,
  0xF0, 0x0F, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3C, 0x3F, 0xF8,
  0x02, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x10,
  0xFF, 0xC0, 0x30, 0x7F, 0xF0, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0xE7,
  0xFC, 0x03, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F,
  0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7F,
  0x00, 0x1F, 0xFE, 0x7F, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x06, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x08, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0xF8, 0x7F,
  0x00, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xBF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x38, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0x9F, 0xFE, 0x00, 0xFF,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x47, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x07,
  0xF8, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xF9, 0xFF, 0xF8,
  0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x0F, 0xE3,
  0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0x03,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x1F,
  0xC7, 0xFF, 0x00, 0x0F, 0xE7, 0xFF, 0xC0, 0x07, 0xF7, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x1F, 0xE0, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0x1F, 0xC0,
  0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x1F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x3F, 0xE0, 0x7F, 0x3F, 0xF0, 0x3F, 0xBF, 0xF0, 0x1F, 0xDF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xE2, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xF3, 0xF8, 0x3F, 0xE0, 0x1C, 0x1F, 0xF0,
  0x02, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x80, 0x07, 0xFC, 0x78, 0x07, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x60, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x03, 0xFF, 0x0F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFE, 0x3F,
  0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFD, 0xFE,
  0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x8F,
  0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFB, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0x80, 0xFF,
  0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x0F, 0xE0, 0x7F, 0xFC,
  0x0F, 0xF0, 0x7F, 0x03, 0xF7, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xBF, 0x07,
  0xF8, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xCF, 0xC3, 0xFC,
  0x07, 0xF0, 0xFE, 0x7E, 0x1F, 0xE0, 0x3F, 0x87, 0xE3, 0xF1, 0xFE, 0x01,
  0xFC, 0x7F, 0x1F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0xFC, 0xFF, 0x00, 0x7F,
  0x1F, 0x87, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x3F, 0x3F, 0x80, 0x1F, 0xCF,
  0xC1, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x0F, 0xDF, 0xE0, 0x07, 0xF7, 0xE0,
  0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x41,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x80, 0x03, 0xFF, 0x88, 0x00, 0x03,
  0xC0,
};

const GFXglyph NotoSans_BoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 42, 16, 1, -41 },
  { 91, 21, 15, 26, 6, -41 },
  { 131, 36, 41, 37, 1, -41 },
  { 316, 30, 46, 31, 1, -43 },
  { 489, 44, 42, 49, 3, -41 },
  { 720, 38, 42, 40, 2, -41 },
  { 920, 9, 15, 15, 6, -41 },
  { 937, 21, 50, 19, 2, -41 },
  { 1069, 21, 50, 19, -4, -41 },
  { 1201, 27, 28, 31, 5, -44 },
  { 1296, 28, 28, 33, 3, -34 },
  { 1394, 14, 14, 16, -3, -7 },
  { 1419, 16, 7, 18, 1, -19 },
  { 1433, 10, 10, 16, 0, -9 },
  { 1446, 31, 41, 24, -3, -41 },
  { 1605, 29, 42, 31, 2, -41 },
  { 1758, 23, 41, 31, 5, -41 },
  { 1876, 32, 41, 31, -1, -41 },
  { 2040, 31, 42, 31, 0, -41 },
  { 2203, 32, 41, 31, -1, -41 },
  { 2367, 30, 42, 31, 1, -41 },
  { 2525, 30, 42, 31, 2, -41 },
  { 2683, 32, 41, 31, 2, -41 },
  { 2847, 29, 42, 31, 2, -41 },
  { 3000, 28, 42, 31, 2, -41 },
  { 3147, 16, 33, 16, 0, -32 },
  { 3213, 19, 39, 16, -3, -32 },
  { 3306, 28, 30, 33, 3, -36 },
  { 3411, 28, 17, 33, 3, -29 },
  { 3471, 28, 30, 33, 3, -36 },
  { 3576, 24, 42, 26, 4, -41 },
  { 3702, 45, 46, 49, 3, -41 },
  { 3961, 35, 41, 36, -3, -41 },
  { 4141, 34, 41, 35, 1, -41 },
  { 4316, 34, 42, 35, 3, -41 },
  { 4495, 36, 41, 39, 1, -41 },
  { 4680, 32, 41, 31, 1, -41 },
  { 4844, 32, 41, 30, 1, -41 },
  { 5008, 36, 42, 39, 3, -41 },
  { 5197, 39, 41, 40, 1, -41 },
  { 5397, 27, 41, 22, -2, -41 },
  { 5536, 28, 53, 19, -9, -41 },
  { 5722, 39, 41, 35, 1, -41 },
  { 5922, 25, 41, 30, 1, -41 },
  { 6051, 49, 41, 50, 1, -41 },
  { 6303, 42, 41, 43, 1, -41 },
  { 6519, 37, 42, 42, 3, -41 },
  { 6714, 34, 41, 35, 1, -41 },
  { 6889, 37, 51, 42, 3, -41 },
  { 7125, 33, 41, 35, 1, -41 },
  { 7295, 30, 42, 30, 1, -41 },
  { 7453, 29, 41, 30, 5, -41 },
  { 7602, 36, 42, 39, 4, -41 },
  { 7791, 34, 41, 34, 5, -41 },
  { 7966, 51, 41, 51, 5, -41 },
  { 8228, 42, 41, 35, -3, -41 },
  { 8444, 32, 41, 32, 5, -41 },
  { 8608, 35, 41, 31, -2, -41 },
  { 8788, 24, 50, 19, -1, -41 },
  { 8938, 14, 41, 24, 6, -41 },
  { 9010, 24, 50, 19, -4, -41 },
  { 9160, 29, 27, 31, 1, -41 },
  { 9258, 24, 4, 23, -5, 5 },
  { 9270, 12, 9, 18, 8, -44 },
  { 9284, 30, 33, 34, 3, -32 },
  { 9408, 30, 44, 34, 1, -43 },
  { 9573, 25, 33, 28, 3, -32 },
  { 9677, 32, 44, 34, 3, -43 },
  { 9853, 27, 33, 32, 3, -32 },
  { 9965, 34, 58, 21, -6, -44 },
  { 10212, 32, 46, 34, 1, -32 },
  { 10396, 31, 43, 34, 1, -43 },
  { 10563, 17, 43, 17, 1, -43 },
  { 10655, 25, 57, 17, -7, -43 },
  { 10834, 34, 43, 32, 1, -43 },
  { 11017, 18, 43, 17, 1, -43 },
  { 11114, 48, 32, 52, 1, -32 },
  { 11306, 31, 32, 34, 1, -32 },
  { 11430, 28, 33, 33, 3, -32 },
  { 11546, 33, 46, 34, -2, -32 },
  { 11736, 30, 46, 34, 3, -32 },
  { 11909, 25, 32, 24, 1, -32 },
  { 12009, 25, 33, 27, 1, -32 },
  { 12113, 21, 39, 23, 3, -38 },
  { 12216, 30, 32, 34, 3, -31 },
  { 12336, 29, 31, 29, 3, -31 },
  { 12449, 45, 31, 45, 3, -31 },
  { 12624, 36, 31, 30, -3, -31 },
  { 12764, 37, 45, 30, -4, -31 },
  { 12973, 28, 31, 27, -1, -31 },
  { 13082, 24, 50, 20, 0, -41 },
  { 13232, 6, 56, 31, 13, -43 },
  { 13274, 23, 50, 20, -3, -41 },
  { 13418, 28, 10, 33, 3, -25 },
};

const GFXfont NotoSans_BoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_BOLDITALIC57PT7B_H_
