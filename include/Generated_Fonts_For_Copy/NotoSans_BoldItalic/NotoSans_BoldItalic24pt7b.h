#ifndef _NOTOSANS_BOLDITALIC24PT7B_H_
#define _NOTOSANS_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x00, 0x00, 0x20, 0x70, 0xF0, 0xF0, 0x73, 0xB9, 0xDC, 0xCC, 0xE6, 0x77,
  0x38, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x98, 0x03, 0x18, 0x07, 0x38, 0x3F,
  0xFF, 0x3F, 0xFE, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x7F, 0xFC, 0x7F,
  0xFC, 0x9C, 0xE0, 0x18, 0xC0, 0x19, 0xC0, 0x39, 0xC0, 0x39, 0x80, 0x01,
  0x80, 0x18, 0x0F, 0xF3, 0xFF, 0x3F, 0xE7, 0xB0, 0x7B, 0x03, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x04, 0xE8, 0xDE, 0xFF, 0xEF, 0xFC, 0x7F,
  0x00, 0x80, 0x18, 0x00, 0x1F, 0x03, 0x87, 0xE0, 0xE1, 0xCE, 0x38, 0x39,
  0xC7, 0x07, 0x39, 0xC1, 0xCE, 0x70, 0x39, 0xCC, 0x47, 0x3B, 0xBE, 0x7E,
  0xEF, 0xCF, 0xBB, 0x9C, 0x06, 0x73, 0x81, 0xCE, 0x70, 0x73, 0x9C, 0x1C,
  0x73, 0x83, 0x0E, 0x70, 0xE0, 0xFC, 0x38, 0x1F, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x3F, 0x0F, 0x7F, 0x9E, 0xF3, 0xDC, 0xF1, 0xFC, 0xE1, 0xF8, 0xF0,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x3E, 0x77, 0x76, 0x6E, 0x07, 0x87,
  0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x00, 0x07, 0x00,
  0x70, 0x47, 0x0F, 0x60, 0xFF, 0xF1, 0xFE, 0x1E, 0xE3, 0xF0, 0x73, 0x03,
  0x38, 0x23, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0xE7, 0x9C, 0x73,
  0x80, 0x7E, 0xFF, 0xF8, 0x2F, 0xFF, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xC1,
  0xFE, 0x3F, 0xF3, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00,
  0x03, 0xC3, 0xE3, 0xF9, 0xFE, 0xFF, 0x99, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC3, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x10, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x40, 0x7B, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x78, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3B, 0xC3, 0x9C, 0x38, 0xE3, 0xCF,
  0x3C, 0x7B, 0xFF, 0xEF, 0xFF, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x40, 0xF3, 0xFF,
  0x9F, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x87, 0xFC, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xDF, 0x0F, 0xFC, 0xFF, 0xE7, 0x87, 0x3C, 0x39, 0xE1, 0xCF,
  0x1E, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0xE1, 0xFF, 0x3C, 0xF3, 0x87, 0x38, 0x73, 0xCF, 0x3F, 0xE1, 0xFC,
  0x3F, 0x87, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xFB, 0xE7, 0xFC,
  0x3F, 0x80, 0x1F, 0xC3, 0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0,
  0xF7, 0x1F, 0x7F, 0xE7, 0xFE, 0x3C, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0xFF,
  0x8F, 0xF0, 0xFC, 0x00, 0x1C, 0x7C, 0xF0, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x43, 0xC7, 0x8F, 0x00, 0x0E, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x3F, 0x1F, 0xC7, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x7F,
  0x3F, 0xE7, 0xFD, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x7C, 0x3C, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xF0, 0x3C, 0x0F, 0x0E, 0x00, 0xE3, 0x82, 0x0E, 0xE3, 0xFD, 0xDC,
  0xFF, 0x1B, 0x1C, 0xE3, 0xE7, 0x1C, 0x7C, 0xE3, 0x9F, 0x98, 0x63, 0xF3,
  0x1C, 0xEE, 0x7F, 0xFD, 0xCF, 0xBF, 0x1C, 0x41, 0x83, 0x80, 0x00, 0x3C,
  0x0C, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCF, 0x03, 0x8E, 0x0E, 0x1C,
  0x3C, 0x38, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0x03, 0x9E, 0x07, 0x78,
  0x0E, 0xF0, 0x1E, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x8F, 0x0F, 0x3C, 0x3C,
  0xF0, 0xE3, 0x8F, 0x8F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0x87, 0x1C, 0x1C,
  0x70, 0x73, 0xC3, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF1, 0xF0, 0x23, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x02, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x83, 0x8E, 0x07, 0x9C, 0x0E, 0x78, 0x1C, 0xF0, 0x79,
  0xE0, 0xF3, 0x81, 0xE7, 0x07, 0x9E, 0x3E, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0xFC, 0x7F, 0xE3, 0xFE, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xFF, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFC, 0x7F, 0xE3, 0xFE, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF1, 0xF0, 0x23, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x7E,
  0x70, 0xFD, 0xE3, 0xFB, 0xC0, 0xF7, 0x81, 0xE7, 0x83, 0x8F, 0x07, 0x1F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xE0, 0x70, 0x0F, 0xF1, 0xFE, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3F, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x0F, 0xF0, 0xFE,
  0x0F, 0x80, 0x1E, 0x1F, 0x1C, 0x3E, 0x1C, 0x7C, 0x3C, 0x78, 0x3C, 0xF0,
  0x3D, 0xE0, 0x3B, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7B, 0xC0,
  0x73, 0xC0, 0x71, 0xE0, 0xF1, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xE0, 0xF0,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x01,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x7E, 0x3B, 0x07, 0xE3, 0xB0,
  0xEE, 0x3B, 0x0E, 0xE3, 0xB1, 0xDE, 0x7B, 0x1D, 0xC7, 0x3B, 0x9C, 0x73,
  0xB9, 0xC7, 0x3F, 0x3C, 0x73, 0xF3, 0xCF, 0x3E, 0x38, 0xE3, 0xE3, 0x8E,
  0x3C, 0x38, 0xE3, 0xC7, 0x80, 0x1F, 0x03, 0x8F, 0x81, 0xC7, 0xC1, 0xE7,
  0xF0, 0xF3, 0xB8, 0x71, 0xDC, 0x38, 0xEF, 0x1C, 0x77, 0x9E, 0x79, 0xCE,
  0x38, 0xF7, 0x1C, 0x7B, 0x8E, 0x1D, 0xC7, 0x0F, 0xE7, 0x87, 0xE3, 0x81,
  0xF1, 0xC0, 0xF8, 0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x8F, 0x0F, 0x3C,
  0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x1E, 0x7F, 0xF9, 0xFF, 0x87, 0xF8, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C,
  0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x78, 0xF3, 0xC3,
  0x9E, 0x3C, 0xE1, 0xE7, 0x3E, 0x7F, 0xF3, 0xFE, 0x1E, 0xF0, 0xE3, 0x87,
  0x1E, 0x78, 0xF3, 0xC3, 0xDE, 0x1E, 0xE0, 0xF8, 0x07, 0xF0, 0x7F, 0xC7,
  0xFC, 0x38, 0x23, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x40, 0xF3, 0xFF, 0x1F, 0xF8, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCF,
  0x07, 0x9C, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x03,
  0x8E, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xF0, 0x3F,
  0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1C, 0x70,
  0x73, 0xC1, 0xCE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x70, 0x3F, 0xC1, 0xE1, 0xEF, 0x0F, 0x87,
  0xBC, 0x3E, 0x1C, 0xF1, 0xF8, 0xF3, 0xC7, 0xE3, 0x8F, 0x3B, 0x9E, 0x3C,
  0xEE, 0x70, 0xF7, 0x39, 0xC3, 0xDC, 0xEE, 0x0F, 0x73, 0xB8, 0x1F, 0x8F,
  0xE0, 0x6E, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xC0, 0x71, 0xF0, 0x1C, 0x78,
  0x07, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x1E, 0x78, 0x0F, 0x1E, 0x07, 0xC3,
  0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0x7D, 0xC1, 0xE7, 0x0F, 0x1E,
  0x78, 0x79, 0xE0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x0F, 0xC3, 0xE1, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0xE7,
  0x39, 0xCE, 0x71, 0xCE, 0x73, 0x9C, 0xE3, 0x9C, 0xE7, 0x38, 0x07, 0xC3,
  0xF0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0xC1, 0xF0, 0xFC,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x6E, 0x07, 0x30, 0x71,
  0x83, 0x0E, 0x38, 0x73, 0x81, 0xBC, 0x0E, 0xFF, 0xFF, 0xF0, 0xF0, 0xE3,
  0xC0, 0x1F, 0x39, 0xFF, 0xCF, 0xFC, 0xF1, 0xE7, 0x8F, 0x78, 0x7B, 0xC3,
  0x9E, 0x1C, 0xF1, 0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0x87, 0xDC, 0x00, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0xF8, 0x7F, 0xE3, 0xFF,
  0x3C, 0x79, 0xE1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0xBC, 0x3D, 0xE3, 0xCF,
  0xFE, 0x7F, 0xE7, 0x3E, 0x00, 0x0F, 0xE7, 0xF8, 0xFF, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x13, 0xFE, 0x3F, 0xC3, 0xF8, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x3D, 0xE3, 0xFF, 0x8F,
  0xFC, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3F, 0xF8, 0x7E, 0xC0, 0xF7, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF7,
  0x8F, 0x70, 0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0xF0, 0x0F, 0x00, 0xF9, 0xC7,
  0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xD0, 0x0F, 0x00, 0x1C,
  0x00, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x38, 0x00,
  0x0F, 0x9C, 0x7F, 0xF1, 0xFF, 0x8F, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x87,
  0x1E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0x0F, 0xF8, 0x3E, 0xE0, 0x03,
  0x80, 0x1E, 0x30, 0xF0, 0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0xF8, 0x7F, 0xE3, 0xFF, 0x3E,
  0x39, 0xE1, 0xCF, 0x1E, 0x70, 0xF3, 0x87, 0xBC, 0x39, 0xE1, 0xCE, 0x1E,
  0x70, 0xF7, 0x87, 0x80, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x03, 0xC1, 0xF8, 0x3E, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC7, 0x1E, 0x0E, 0x78, 0x3D, 0xE0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1E, 0x78, 0x3C,
  0xF0, 0x70, 0xF1, 0xE1, 0xE0, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x1D,
  0xF1, 0xE0, 0xFF, 0xDF, 0x87, 0xFF, 0xFC, 0x7C, 0x78, 0xF3, 0xC3, 0x87,
  0x1E, 0x3C, 0x38, 0xE1, 0xE3, 0xC7, 0x0E, 0x1E, 0x78, 0x70, 0xF3, 0xC3,
  0x87, 0x1C, 0x3C, 0x38, 0xE1, 0xE3, 0xCF, 0x0E, 0x1E, 0x00, 0x1D, 0xF0,
  0xFF, 0xC7, 0xFE, 0x7C, 0x73, 0xC3, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x78,
  0x73, 0xC3, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F, 0x00, 0x0F, 0xC3, 0xFE, 0x3F,
  0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xFF,
  0xC7, 0xFC, 0x3F, 0x00, 0x0E, 0xF8, 0x3F, 0xF0, 0xFF, 0xC7, 0x8F, 0x1E,
  0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xFF, 0x8F,
  0xFC, 0x3B, 0xE1, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0x39, 0xFF, 0xCF, 0xFC, 0xF1, 0xE7, 0x0F, 0x78, 0x7B,
  0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0x83, 0xDC, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1D, 0xE3, 0xFC,
  0x7F, 0x1F, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x00, 0x1F, 0xC7, 0xFC, 0xF3, 0x1C, 0x03, 0xC0, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xD0, 0x7B, 0xFE, 0x7F, 0xCF, 0xF0, 0x0E, 0x0E, 0x07,
  0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0xF1, 0xF8, 0xFC, 0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xE7, 0x87, 0x38,
  0x79, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x8F, 0x3F, 0xF8, 0xFD, 0xC7, 0xCC,
  0x00, 0xF0, 0x7F, 0x87, 0x9C, 0x38, 0xE3, 0xC7, 0x1C, 0x39, 0xE1, 0xCE,
  0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x71,
  0xF1, 0xEE, 0x3E, 0x39, 0xC7, 0xCF, 0x39, 0xF9, 0xC7, 0x37, 0x78, 0xEE,
  0xEE, 0x1D, 0xDD, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0x8D, 0xC1, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x3C, 0x78, 0x39, 0xE0,
  0x7F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B,
  0xC0, 0xF3, 0x83, 0xC7, 0x8F, 0x0F, 0x00, 0x1E, 0x0F, 0x1E, 0x1E, 0x0E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x3F, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xCF, 0xF8, 0xFF, 0x80, 0x03, 0xC1, 0xF0, 0x7C, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x3C, 0x3E, 0x0F, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0xC1, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x38, 0x3E, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x0F, 0x83, 0xC0, 0xC0, 0x00, 0x7E, 0x1F, 0xFF, 0xC7,
  0xF8, 0x08,
};

const GFXglyph NotoSans_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 17, 7, 0, -17 },
  { 18, 9, 6, 11, 2, -17 },
  { 25, 16, 17, 16, 0, -17 },
  { 59, 12, 19, 13, 1, -18 },
  { 88, 19, 17, 21, 1, -17 },
  { 129, 16, 17, 17, 1, -17 },
  { 163, 4, 6, 6, 2, -17 },
  { 166, 9, 21, 8, 1, -17 },
  { 190, 9, 21, 8, -2, -17 },
  { 214, 12, 11, 13, 2, -18 },
  { 231, 12, 11, 14, 1, -14 },
  { 248, 6, 6, 7, -1, -3 },
  { 253, 7, 3, 8, 0, -8 },
  { 256, 4, 4, 7, 0, -4 },
  { 258, 13, 17, 10, -1, -17 },
  { 286, 12, 17, 13, 1, -17 },
  { 312, 10, 17, 13, 2, -17 },
  { 334, 14, 17, 13, -1, -17 },
  { 364, 13, 17, 13, 0, -17 },
  { 392, 13, 17, 13, 0, -17 },
  { 420, 13, 17, 13, 0, -17 },
  { 448, 13, 17, 13, 1, -17 },
  { 476, 13, 17, 13, 1, -17 },
  { 504, 12, 17, 13, 1, -17 },
  { 530, 12, 17, 13, 1, -17 },
  { 556, 7, 13, 7, 0, -13 },
  { 568, 8, 16, 7, -1, -13 },
  { 584, 12, 13, 14, 1, -15 },
  { 604, 12, 7, 14, 1, -12 },
  { 615, 12, 13, 14, 1, -15 },
  { 635, 10, 17, 11, 2, -17 },
  { 657, 19, 19, 21, 1, -17 },
  { 703, 15, 17, 15, -1, -17 },
  { 735, 14, 17, 15, 1, -17 },
  { 765, 15, 17, 15, 1, -17 },
  { 797, 15, 17, 16, 1, -17 },
  { 829, 13, 17, 13, 1, -17 },
  { 857, 13, 17, 13, 1, -17 },
  { 885, 15, 17, 17, 1, -17 },
  { 917, 16, 17, 17, 1, -17 },
  { 951, 12, 17, 9, -1, -17 },
  { 977, 12, 22, 8, -4, -17 },
  { 1010, 16, 17, 15, 1, -17 },
  { 1044, 10, 17, 12, 1, -17 },
  { 1066, 20, 17, 21, 1, -17 },
  { 1109, 17, 17, 18, 1, -17 },
  { 1146, 16, 17, 18, 1, -17 },
  { 1180, 14, 17, 15, 1, -17 },
  { 1210, 16, 21, 18, 1, -17 },
  { 1252, 13, 17, 15, 1, -17 },
  { 1280, 13, 17, 13, 0, -17 },
  { 1308, 12, 17, 13, 2, -17 },
  { 1334, 15, 17, 17, 2, -17 },
  { 1366, 14, 17, 14, 2, -17 },
  { 1396, 22, 17, 21, 2, -17 },
  { 1443, 18, 17, 15, -1, -17 },
  { 1482, 14, 17, 14, 2, -17 },
  { 1512, 15, 17, 13, -1, -17 },
  { 1544, 10, 21, 8, 0, -17 },
  { 1571, 5, 17, 10, 3, -17 },
  { 1582, 10, 21, 8, -2, -17 },
  { 1609, 13, 11, 13, 0, -17 },
  { 1627, 10, 2, 10, -2, 2 },
  { 1630, 6, 3, 8, 3, -18 },
  { 1633, 13, 13, 14, 1, -13 },
  { 1655, 13, 18, 14, 0, -18 },
  { 1685, 11, 13, 12, 1, -13 },
  { 1703, 14, 18, 14, 1, -18 },
  { 1735, 12, 13, 13, 1, -13 },
  { 1755, 15, 24, 9, -3, -18 },
  { 1800, 14, 19, 14, 0, -13 },
  { 1834, 13, 18, 15, 0, -18 },
  { 1864, 8, 18, 7, 0, -18 },
  { 1882, 11, 24, 7, -3, -18 },
  { 1915, 15, 18, 14, 0, -18 },
  { 1949, 8, 18, 7, 0, -18 },
  { 1967, 21, 13, 22, 0, -13 },
  { 2002, 13, 13, 15, 0, -13 },
  { 2024, 12, 13, 14, 1, -13 },
  { 2044, 14, 19, 14, -1, -13 },
  { 2078, 13, 19, 14, 1, -13 },
  { 2109, 11, 13, 10, 0, -13 },
  { 2127, 11, 13, 11, 0, -13 },
  { 2145, 9, 16, 10, 1, -16 },
  { 2163, 13, 13, 15, 1, -13 },
  { 2185, 13, 13, 12, 1, -13 },
  { 2207, 19, 13, 19, 1, -13 },
  { 2238, 15, 13, 13, -1, -13 },
  { 2263, 16, 19, 12, -2, -13 },
  { 2301, 12, 13, 11, 0, -13 },
  { 2321, 10, 21, 9, 0, -17 },
  { 2348, 3, 23, 13, 5, -18 },
  { 2357, 10, 21, 9, -1, -17 },
  { 2384, 12, 4, 14, 1, -10 },
};

const GFXfont NotoSans_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_BOLDITALIC24PT7B_H_
