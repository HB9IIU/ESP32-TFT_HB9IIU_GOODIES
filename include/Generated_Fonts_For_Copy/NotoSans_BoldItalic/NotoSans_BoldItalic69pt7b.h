#ifndef _NOTOSANS_BOLDITALIC69PT7B_H_
#define _NOTOSANS_BOLDITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE3, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xF1, 0xF8, 0x07, 0xFF, 0x1F, 0x03, 0x80,
  0x7F, 0xE1, 0xE0, 0x08, 0x07, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0xE3, 0xE0,
  0x00, 0x07, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x07, 0xFF,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x3F,
  0xF8, 0x00, 0x01, 0xE3, 0xFF, 0x80, 0x00, 0x1E, 0x1F, 0xF8, 0x00, 0x03,
  0xE1, 0xFF, 0x88, 0x00, 0x3E, 0x1F, 0xF8, 0xC0, 0x03, 0xE3, 0xFF, 0x0F,
  0x00, 0x3C, 0x3F, 0xF0, 0xFF, 0x07, 0xCF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0xE0, 0x7F,
  0x83, 0xFE, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xE3, 0xFC, 0x7F, 0xFF,
  0x1F, 0xF3, 0xFF, 0x3F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF3, 0xFF, 0x1F, 0xE1, 0xFF, 0xF8,
  0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x60, 0x03, 0xF8, 0x00, 0x3C, 0x03, 0xFC, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x81, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0x80, 0x0F, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x1E,
  0x03, 0xFE, 0x00, 0x06, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0x03,
  0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0x7F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD,
  0xFF, 0x87, 0xFF, 0x9F, 0xF8, 0x3F, 0xE1, 0xFF, 0x81, 0xFC, 0x3F, 0xF0,
  0x1F, 0x03, 0xFF, 0x00, 0xE0, 0x3F, 0xF0, 0x08, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0x00, 0x0F, 0xFE, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x10, 0x00, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x07, 0xFF, 0x87, 0xE0, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x00, 0x3F,
  0xFC, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC3, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x03, 0xFF, 0x1F, 0xFF, 0x00, 0x3F,
  0xF3, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xFC, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x1E, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x30, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xBD,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xF8, 0xFC, 0x01, 0xFF,
  0xC3, 0x80, 0x07, 0xFE, 0x10, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0x87, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xF9, 0xFE, 0x03, 0xFF, 0x83, 0xFC, 0x07, 0xF3, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xDF, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xDF, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xC1, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F,
  0xFC, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x1F,
  0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x38,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x7F, 0xF0,
  0x07, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x2A, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF,
  0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0x9F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0x87, 0xF0, 0x1F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xEF, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x01, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x0F, 0xFE, 0x0C, 0x00,
  0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x83,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF7,
  0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF7, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFC, 0x01, 0xFF, 0xFF,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF,
  0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0x80, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xDF, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0xFF, 0x80, 0x1F,
  0xE1, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xF0, 0x1F, 0xFE, 0x00, 0x20, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x08, 0x0F, 0xFF, 0x00, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFB, 0xFC, 0x00, 0x3F, 0xFF,
  0xF3, 0xFC, 0x00, 0x1F, 0xFF, 0xE7, 0xF8, 0x00, 0x0F, 0xFF, 0xC7, 0xF8,
  0x00, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x10, 0x1F, 0xFC, 0x00, 0x1C, 0x07, 0xFF, 0xC0, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xEF,
  0xFC, 0x00, 0x3F, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFF, 0xE0, 0x07,
  0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF3, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFB, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0xE3,
  0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xFF, 0xFC,
  0x00, 0x3F, 0xDF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xE3, 0xFC,
  0x01, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x70, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFC, 0x0F,
  0xFE, 0x00, 0xF0, 0x3F, 0xF0, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x80, 0x00, 0xFF, 0xE3, 0x80, 0x03, 0xFF, 0x8F, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x20, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xF0,
  0x7F, 0x80, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xFF, 0x07, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xC0, 0xFE, 0x7F, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xF9, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x7F, 0x0F, 0xFC, 0x01, 0xFF, 0x0F,
  0xF1, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x80, 0x1F,
  0xF1, 0xFE, 0x1F, 0xC7, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x7F, 0x1F, 0xF0,
  0x01, 0xFF, 0x3F, 0xC1, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x07, 0xF3,
  0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x1F, 0xCF, 0xF8, 0x00, 0x7F, 0xDF, 0xE0,
  0x7F, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x01, 0xFD, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x9F, 0xFF,
  0x80, 0x00, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x60, 0x00, 0x7F, 0xFF, 0x20,
  0x00, 0x07, 0xFE, 0x00,
};

const GFXglyph NotoSans_BoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 21, 50, 20, 1, -49 },
  { 133, 25, 18, 31, 7, -49 },
  { 190, 44, 49, 45, 1, -49 },
  { 460, 36, 56, 38, 2, -52 },
  { 712, 53, 51, 59, 4, -50 },
  { 1050, 46, 51, 49, 2, -50 },
  { 1344, 11, 18, 18, 7, -49 },
  { 1369, 26, 60, 23, 2, -49 },
  { 1564, 26, 61, 24, -5, -50 },
  { 1763, 33, 34, 38, 6, -53 },
  { 1904, 33, 33, 39, 4, -41 },
  { 2041, 16, 17, 20, -3, -8 },
  { 2075, 20, 9, 22, 1, -23 },
  { 2098, 12, 12, 20, 1, -11 },
  { 2116, 37, 50, 29, -3, -50 },
  { 2348, 35, 51, 38, 2, -50 },
  { 2572, 28, 49, 38, 6, -49 },
  { 2744, 39, 50, 38, -2, -50 },
  { 2988, 37, 51, 38, 0, -50 },
  { 3224, 38, 49, 38, -1, -49 },
  { 3457, 37, 50, 38, 1, -49 },
  { 3689, 36, 51, 38, 3, -50 },
  { 3919, 38, 49, 38, 3, -49 },
  { 4152, 36, 51, 38, 2, -50 },
  { 4382, 34, 51, 38, 3, -50 },
  { 4599, 18, 39, 20, 1, -38 },
  { 4687, 23, 47, 20, -4, -38 },
  { 4823, 33, 36, 39, 4, -43 },
  { 4972, 33, 21, 39, 4, -35 },
  { 5059, 33, 36, 39, 4, -43 },
  { 5208, 29, 51, 32, 5, -50 },
  { 5393, 55, 55, 59, 3, -49 },
  { 5772, 43, 49, 43, -4, -49 },
  { 6036, 40, 49, 43, 2, -49 },
  { 6281, 41, 51, 42, 4, -50 },
  { 6543, 43, 49, 47, 2, -49 },
  { 6807, 38, 49, 37, 2, -49 },
  { 7040, 38, 49, 37, 2, -49 },
  { 7273, 43, 51, 48, 4, -50 },
  { 7548, 47, 49, 48, 2, -49 },
  { 7836, 32, 49, 26, -2, -49 },
  { 8032, 34, 64, 23, -11, -49 },
  { 8304, 47, 49, 42, 2, -49 },
  { 8592, 29, 49, 36, 2, -49 },
  { 8770, 59, 49, 61, 2, -49 },
  { 9132, 51, 49, 52, 2, -49 },
  { 9445, 44, 51, 50, 4, -50 },
  { 9726, 40, 49, 42, 2, -49 },
  { 9971, 44, 62, 50, 4, -50 },
  { 10312, 39, 49, 43, 2, -49 },
  { 10551, 36, 51, 37, 1, -50 },
  { 10781, 36, 49, 37, 6, -49 },
  { 11002, 43, 50, 48, 5, -49 },
  { 11271, 41, 49, 41, 6, -49 },
  { 11523, 62, 49, 62, 6, -49 },
  { 11903, 51, 49, 42, -4, -49 },
  { 12216, 39, 49, 39, 6, -49 },
  { 12455, 42, 49, 37, -2, -49 },
  { 12713, 29, 60, 23, -1, -49 },
  { 12931, 17, 50, 29, 7, -50 },
  { 13038, 29, 60, 23, -5, -49 },
  { 13256, 35, 32, 38, 1, -50 },
  { 13396, 28, 5, 28, -6, 6 },
  { 13414, 15, 11, 22, 10, -53 },
  { 13435, 37, 39, 41, 3, -38 },
  { 13616, 37, 53, 41, 1, -52 },
  { 13862, 31, 39, 33, 3, -38 },
  { 14014, 40, 53, 41, 3, -52 },
  { 14279, 34, 39, 38, 3, -38 },
  { 14445, 40, 70, 26, -7, -53 },
  { 14795, 39, 55, 41, 1, -38 },
  { 15064, 37, 52, 42, 1, -52 },
  { 15305, 21, 53, 21, 1, -53 },
  { 15445, 31, 70, 21, -9, -53 },
  { 15717, 42, 52, 39, 1, -52 },
  { 15990, 22, 52, 21, 1, -52 },
  { 16133, 58, 38, 62, 1, -38 },
  { 16409, 37, 38, 42, 1, -38 },
  { 16585, 34, 39, 40, 3, -38 },
  { 16751, 40, 55, 41, -2, -38 },
  { 17026, 37, 55, 41, 3, -38 },
  { 17281, 31, 38, 29, 1, -38 },
  { 17429, 30, 39, 33, 1, -38 },
  { 17576, 27, 47, 28, 3, -46 },
  { 17735, 37, 39, 42, 4, -38 },
  { 17916, 36, 38, 35, 3, -38 },
  { 18087, 54, 38, 54, 4, -38 },
  { 18344, 43, 38, 37, -3, -38 },
  { 18549, 44, 55, 36, -5, -38 },
  { 18852, 34, 38, 32, -1, -38 },
  { 19014, 29, 60, 25, 0, -49 },
  { 19232, 8, 68, 38, 15, -52 },
  { 19300, 29, 60, 25, -4, -49 },
  { 19518, 33, 11, 39, 4, -30 },
};

const GFXfont NotoSans_BoldItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_BOLDITALIC69PT7B_H_
