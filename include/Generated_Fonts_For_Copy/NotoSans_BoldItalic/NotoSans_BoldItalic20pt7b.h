#ifndef _NOTOSANS_BOLDITALIC20PT7B_H_
#define _NOTOSANS_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8C, 0x70, 0x00, 0x1C, 0xF3, 0x80,
  0x67, 0xDF, 0xBE, 0x6C, 0xC0, 0x07, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC3,
  0xFF, 0xBF, 0xFC, 0x33, 0x03, 0xB8, 0x7F, 0xF7, 0xFF, 0x86, 0x60, 0x66,
  0x03, 0x30, 0x19, 0x80, 0x01, 0x00, 0xF0, 0x7F, 0x9F, 0xE3, 0xA0, 0x74,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xB8, 0x17, 0x62, 0xEF, 0xF8, 0xFE, 0x02,
  0x00, 0x40, 0x3C, 0x1C, 0xFC, 0x31, 0x98, 0xC7, 0x33, 0x0E, 0xEE, 0x1D,
  0xDB, 0xBF, 0x6F, 0xBD, 0xBB, 0x07, 0x66, 0x0C, 0xCC, 0x31, 0x98, 0xC7,
  0x73, 0x87, 0xCE, 0x0F, 0x00, 0x02, 0x00, 0x7C, 0x07, 0xF0, 0x73, 0x83,
  0x9C, 0x1D, 0xE0, 0x7E, 0x07, 0xC7, 0x7E, 0x37, 0x3B, 0xB9, 0xF9, 0xC7,
  0xCE, 0x3C, 0x7F, 0xF1, 0xFB, 0xC0, 0x7F, 0xEC, 0x0E, 0x38, 0xE1, 0x87,
  0x0C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0x1C,
  0x18, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x8E,
  0x18, 0x71, 0xC0, 0x0E, 0x06, 0x33, 0x1F, 0xB3, 0xF9, 0xED, 0xF1, 0xCC,
  0x26, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x3B, 0x9C, 0xCC, 0x00, 0x7D, 0xFF, 0xC0, 0x6F, 0xE0,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x00, 0x04, 0x07, 0xE3, 0xF9,
  0xE7, 0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xEE, 0x3B, 0x9E, 0xE7,
  0x3F, 0x87, 0xC0, 0x0F, 0x3E, 0x7E, 0xFE, 0x4E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x1F, 0xC7, 0xF8, 0xE7, 0x88, 0x70, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0xCF, 0xF9, 0xFF,
  0x00, 0x1F, 0xC7, 0xFC, 0x43, 0x80, 0x70, 0x1C, 0x07, 0x87, 0xC0, 0xFC,
  0x01, 0xC0, 0x38, 0x07, 0x61, 0xCF, 0xF9, 0xFC, 0x00, 0x01, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0xDC, 0x3B, 0x8E, 0x63, 0x9C, 0xE3, 0xBF, 0xFB, 0xFF,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x1F, 0xE3, 0xFC, 0x70, 0x0C, 0x03, 0x80,
  0x7E, 0x0F, 0xE1, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x63, 0xCF, 0xF9, 0xFC,
  0x00, 0x00, 0x83, 0xF1, 0xFC, 0xE0, 0x70, 0x1C, 0x0E, 0xF3, 0xFE, 0xF3,
  0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0x9F, 0xC3, 0xE0, 0x7F, 0xEF, 0xFC, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x00, 0x02, 0x07, 0xE3, 0xFD, 0xC7, 0x71, 0xDC, 0x73,
  0xF8, 0x78, 0x7F, 0x38, 0xEE, 0x3B, 0x0E, 0xE3, 0xBF, 0xC7, 0xE0, 0x04,
  0x0F, 0xC7, 0xF9, 0xCE, 0xE1, 0xF8, 0x7E, 0x3F, 0xDE, 0x7F, 0x8E, 0xE0,
  0x38, 0x1C, 0x8F, 0x3F, 0x8F, 0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x67,
  0xB8, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x18, 0xE3, 0x00,
  0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0xF0, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x30,
  0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x7C, 0x7C, 0x7C, 0x38, 0x08, 0x00,
  0xFE, 0xFF, 0xC7, 0x07, 0x0E, 0x1E, 0x38, 0x70, 0x60, 0x00, 0x00, 0xE0,
  0xE0, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x38, 0x0E, 0x30, 0x07, 0x63, 0xF3,
  0x67, 0x73, 0xCE, 0x63, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0xE6, 0xCF, 0xFC,
  0xE7, 0x38, 0x60, 0x00, 0x78, 0x20, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xE0,
  0x3E, 0x03, 0x60, 0x76, 0x07, 0x60, 0xE7, 0x0E, 0x71, 0xC7, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF7, 0x07, 0x70, 0x7E, 0x07, 0x3F, 0xC7, 0xFC, 0xE3, 0x9C,
  0x73, 0x8E, 0xFF, 0x9F, 0xC3, 0xFE, 0x71, 0xDC, 0x3B, 0x87, 0x7F, 0xEF,
  0xF9, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xC2, 0x78, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x79, 0x87, 0xF8,
  0x3F, 0x80, 0x3F, 0xC3, 0xFE, 0x39, 0xE3, 0x8F, 0x38, 0x77, 0x07, 0x70,
  0x77, 0x07, 0x70, 0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0x3F,
  0xE7, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xFC, 0x70, 0x1C,
  0x03, 0x80, 0x7F, 0x8F, 0xF1, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1F, 0xE3, 0xFC, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0xFC, 0x78, 0x27, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x7E, 0xE3, 0xF7, 0x07, 0x38, 0x39, 0xE1, 0xC7, 0x9E,
  0x3F, 0xE0, 0x7F, 0x00, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE,
  0x1C, 0x70, 0xE0, 0x1F, 0xC7, 0xE0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x7E, 0x3F, 0x80, 0x01, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE2, 0xF0, 0xFC, 0x3E, 0x00, 0x3C, 0x79, 0xC7, 0x8E,
  0x78, 0x77, 0x83, 0x38, 0x3B, 0x81, 0xF8, 0x0F, 0xE0, 0x77, 0x07, 0x38,
  0x38, 0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE0, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x9F,
  0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0x63, 0xF3, 0xB1, 0xB1, 0xD9, 0xD8,
  0xEC, 0xDC, 0x66, 0xEE, 0x73, 0x67, 0x39, 0xF3, 0x1C, 0xF3, 0x8E, 0x79,
  0xC6, 0x38, 0xE0, 0x1E, 0x0E, 0x3E, 0x1C, 0x7C, 0x38, 0xF8, 0x61, 0xB9,
  0xC7, 0x73, 0x8E, 0xE7, 0x1C, 0xEE, 0x31, 0xD8, 0xE3, 0xB1, 0xC3, 0xE3,
  0x87, 0xC7, 0x0F, 0x9C, 0x0E, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x78,
  0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1D,
  0xE1, 0xE7, 0x9E, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0xC7, 0xFC, 0xE3, 0x9C,
  0x73, 0x8E, 0xE1, 0xDF, 0xFB, 0xFE, 0x7F, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xE1, 0xE7, 0x9E,
  0x3F, 0xE0, 0x7E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x87, 0xF8,
  0xE7, 0x9C, 0x73, 0x8E, 0xE3, 0xDF, 0xF3, 0xFC, 0x7F, 0x1C, 0xE3, 0x8E,
  0x71, 0xCE, 0x3D, 0xC3, 0x80, 0x0F, 0xE3, 0xF8, 0xF1, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x0E, 0x63, 0xCF, 0xF0, 0xFC,
  0x00, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x1C,
  0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE7, 0x07, 0x38,
  0x78, 0xE7, 0x87, 0xF8, 0x1F, 0x80, 0xE0, 0xFE, 0x0E, 0xE1, 0xCE, 0x1C,
  0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0x6E, 0x06, 0xE0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xE1, 0xC3, 0xF8, 0x70, 0xEE, 0x3C, 0x3B, 0x8F, 0x1C,
  0xE7, 0xC7, 0x39, 0xB3, 0x8E, 0xEC, 0xE3, 0xB3, 0x30, 0xEC, 0xDC, 0x3F,
  0x36, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0xF3, 0x81, 0xC7, 0x07, 0x0F, 0x1E,
  0x0E, 0x00, 0xE1, 0xFC, 0x39, 0x8E, 0x3B, 0xC7, 0x70, 0xFC, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xC7, 0xFC, 0x7F, 0xE0, 0x1F, 0x1F, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0,
  0xF8, 0xF0, 0xE7, 0x18, 0xC6, 0x39, 0xCE, 0x31, 0x8C, 0x73, 0x9C, 0x1F,
  0x1F, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0xF8, 0xF0, 0x03, 0x00, 0xE0, 0x1E, 0x06, 0xC1, 0xD8, 0x33,
  0x8C, 0x33, 0x86, 0xE0, 0xE0, 0xFF, 0x80, 0xE7, 0x30, 0x1E, 0xE7, 0xF9,
  0xEF, 0x38, 0xEE, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xE7, 0x9F, 0xF1, 0xEC,
  0x00, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xBC, 0x7F, 0xCF, 0x39, 0xC7,
  0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0xE7, 0xBC, 0xFF, 0x3B, 0xC0, 0x1F, 0x9F,
  0xDE, 0x4E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF2, 0x3F, 0x1F, 0x80, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x71, 0xEC, 0x7F, 0x9E, 0xF3, 0x8E, 0xE1, 0xDC,
  0x33, 0x8E, 0x71, 0xCE, 0x79, 0xFF, 0x1E, 0xC0, 0x1F, 0x0F, 0xE7, 0x9D,
  0xC7, 0xE7, 0xBF, 0xCF, 0xC3, 0x80, 0xE1, 0x1F, 0xC3, 0xF0, 0x01, 0xF0,
  0x3E, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xFC, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x0F,
  0x80, 0xF8, 0x0E, 0x00, 0x0F, 0x71, 0xFE, 0x3D, 0xE3, 0x8E, 0x70, 0xE7,
  0x0C, 0x71, 0xC7, 0x1C, 0x73, 0xC7, 0xFC, 0x3F, 0x80, 0x38, 0x03, 0x8F,
  0xF0, 0xFF, 0x07, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xBC, 0x7F,
  0xCF, 0x39, 0xC7, 0x38, 0xE7, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xE3, 0xB8,
  0x70, 0x1C, 0x70, 0xC0, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xCE,
  0x00, 0x03, 0x81, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x7E, 0x3E, 0x1E, 0x00,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x73, 0x8E, 0x39, 0xC3, 0xB8,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0x78, 0x73, 0x87, 0x3C, 0xE1, 0xC0, 0x1E,
  0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x38,
  0x00, 0x1B, 0xCF, 0x1F, 0xFF, 0xCF, 0x3C, 0xE7, 0x1C, 0x73, 0x8E, 0x39,
  0x87, 0x1D, 0xC7, 0x0E, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE3, 0xB8, 0xF1,
  0xC0, 0x1B, 0xC7, 0xFC, 0xF3, 0x9C, 0x73, 0x8E, 0x71, 0xDC, 0x33, 0x8E,
  0x71, 0xCE, 0x3B, 0x87, 0x00, 0x1F, 0x0F, 0xE7, 0xBF, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x8E, 0xE7, 0x9F, 0xC3, 0xE0, 0x0D, 0xE1, 0xFF, 0x1E, 0x71,
  0xC7, 0x1C, 0x71, 0x87, 0x38, 0x73, 0x8E, 0x3D, 0xE3, 0xFC, 0x77, 0x87,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0xE7, 0xF9, 0xEF, 0x38,
  0xEE, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xE7, 0x9F, 0xF1, 0xEC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x1B, 0x9F, 0xCF, 0xE7, 0x83, 0x81, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x00, 0x1F, 0x9F, 0xDE, 0x4F, 0x03, 0xC1,
  0xF0, 0x3C, 0x0E, 0x87, 0x7F, 0xBF, 0x80, 0x18, 0x38, 0x7F, 0xFE, 0x70,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xE4, 0xFC, 0x7C, 0x78, 0xEE, 0x39, 0xC7,
  0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xE7, 0x9F, 0xF1, 0xEE, 0x00,
  0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x7C, 0x1E,
  0x07, 0x80, 0xE3, 0x87, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9C, 0xEF, 0x9C,
  0xED, 0xB8, 0x6D, 0xB8, 0x79, 0xB0, 0x79, 0xF0, 0x79, 0xE0, 0x71, 0xE0,
  0x3C, 0x78, 0xE7, 0x07, 0x78, 0x1F, 0x80, 0xF8, 0x03, 0x80, 0x3E, 0x03,
  0xF0, 0x3B, 0x83, 0xCE, 0x3C, 0x70, 0x38, 0x73, 0x87, 0x38, 0xE3, 0x8E,
  0x19, 0xC1, 0x9C, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xCF, 0xE0, 0x78, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x3F, 0xCF, 0xF0, 0x07, 0x0F, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0xF8, 0xE0, 0xF0, 0x30, 0x30, 0x30, 0x70, 0x70, 0x78,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0x1F, 0x18, 0x38, 0x38, 0x38, 0x30,
  0xF0, 0xE0, 0x70, 0x7F, 0xFD, 0xFE, 0x0C,
};

const GFXglyph NotoSans_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 6, 0, -14 },
  { 12, 7, 5, 9, 2, -14 },
  { 17, 13, 14, 13, 0, -14 },
  { 40, 11, 16, 11, 0, -15 },
  { 62, 15, 14, 17, 1, -14 },
  { 89, 13, 15, 14, 1, -15 },
  { 114, 3, 5, 5, 2, -14 },
  { 116, 7, 17, 7, 1, -14 },
  { 131, 7, 18, 7, -1, -15 },
  { 147, 9, 9, 11, 2, -15 },
  { 158, 10, 10, 11, 1, -12 },
  { 171, 5, 5, 6, -1, -2 },
  { 175, 6, 3, 6, 0, -7 },
  { 178, 4, 3, 6, 0, -3 },
  { 180, 11, 14, 8, -1, -14 },
  { 200, 10, 15, 11, 1, -15 },
  { 219, 8, 14, 11, 2, -14 },
  { 233, 11, 14, 11, 0, -14 },
  { 253, 11, 14, 11, 0, -14 },
  { 273, 11, 14, 11, 0, -14 },
  { 293, 11, 14, 11, 0, -14 },
  { 313, 10, 15, 11, 1, -15 },
  { 332, 11, 14, 11, 1, -14 },
  { 352, 10, 15, 11, 1, -15 },
  { 371, 10, 15, 11, 1, -15 },
  { 390, 5, 11, 6, 0, -11 },
  { 397, 6, 14, 6, -1, -11 },
  { 408, 10, 11, 11, 1, -13 },
  { 422, 10, 6, 11, 1, -10 },
  { 430, 10, 11, 11, 1, -13 },
  { 444, 8, 14, 9, 2, -14 },
  { 458, 16, 16, 17, 1, -14 },
  { 490, 12, 14, 13, -1, -14 },
  { 511, 11, 14, 12, 1, -14 },
  { 531, 12, 15, 12, 1, -15 },
  { 554, 12, 14, 14, 1, -14 },
  { 575, 11, 14, 11, 1, -14 },
  { 595, 11, 14, 11, 1, -14 },
  { 615, 13, 15, 14, 1, -15 },
  { 640, 13, 14, 14, 1, -14 },
  { 663, 10, 14, 8, -1, -14 },
  { 681, 10, 18, 7, -3, -14 },
  { 704, 13, 14, 12, 1, -14 },
  { 727, 8, 14, 10, 1, -14 },
  { 741, 17, 14, 18, 1, -14 },
  { 771, 15, 14, 15, 0, -14 },
  { 798, 13, 15, 15, 1, -15 },
  { 823, 11, 14, 12, 1, -14 },
  { 843, 13, 18, 15, 1, -15 },
  { 873, 11, 14, 12, 1, -14 },
  { 893, 11, 14, 11, 0, -14 },
  { 913, 10, 14, 11, 2, -14 },
  { 931, 13, 14, 14, 1, -14 },
  { 954, 12, 14, 12, 2, -14 },
  { 975, 18, 14, 18, 2, -14 },
  { 1007, 15, 14, 12, -1, -14 },
  { 1034, 11, 14, 11, 2, -14 },
  { 1054, 13, 14, 11, -1, -14 },
  { 1077, 8, 17, 7, 0, -14 },
  { 1094, 5, 14, 8, 2, -14 },
  { 1103, 8, 17, 7, -1, -14 },
  { 1120, 11, 9, 11, 0, -14 },
  { 1133, 9, 1, 8, -2, 2 },
  { 1135, 4, 3, 6, 3, -15 },
  { 1137, 11, 11, 12, 1, -11 },
  { 1153, 11, 15, 12, 0, -15 },
  { 1174, 9, 11, 10, 1, -11 },
  { 1187, 11, 15, 12, 1, -15 },
  { 1208, 10, 11, 11, 1, -11 },
  { 1222, 12, 20, 7, -2, -15 },
  { 1252, 12, 16, 12, 0, -11 },
  { 1276, 11, 15, 12, 0, -15 },
  { 1297, 6, 15, 6, 0, -15 },
  { 1309, 9, 20, 6, -3, -15 },
  { 1332, 12, 15, 11, 0, -15 },
  { 1355, 7, 15, 6, 0, -15 },
  { 1369, 17, 11, 18, 0, -11 },
  { 1393, 11, 11, 12, 0, -11 },
  { 1409, 10, 11, 12, 1, -11 },
  { 1423, 12, 16, 12, -1, -11 },
  { 1447, 11, 16, 12, 1, -11 },
  { 1469, 9, 11, 8, 0, -11 },
  { 1482, 9, 11, 10, 0, -11 },
  { 1495, 8, 13, 8, 1, -13 },
  { 1508, 11, 11, 12, 1, -11 },
  { 1524, 10, 11, 10, 1, -11 },
  { 1538, 16, 11, 16, 1, -11 },
  { 1560, 13, 11, 11, -1, -11 },
  { 1578, 12, 16, 10, -1, -11 },
  { 1602, 10, 11, 9, 0, -11 },
  { 1616, 8, 17, 7, 0, -14 },
  { 1633, 3, 20, 11, 4, -15 },
  { 1641, 8, 17, 7, -1, -14 },
  { 1658, 10, 4, 11, 1, -9 },
};

const GFXfont NotoSans_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_BOLDITALIC20PT7B_H_
