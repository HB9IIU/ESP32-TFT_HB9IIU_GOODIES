#ifndef _NOTOSANS_BOLDITALIC35PT7B_H_
#define _NOTOSANS_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0x7C, 0x00,
  0x3C, 0xFB, 0xE7, 0xDF, 0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8E,
  0x1C, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0xE1, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0xC3,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7E, 0xCE, 0x1F, 0x30, 0x07, 0xDC, 0x01, 0xF7,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x37, 0xE0, 0x1D, 0xF8, 0x07, 0x3E, 0xC1, 0x9F, 0x3F,
  0x7F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xF8, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x83, 0xFC, 0x03,
  0xC0, 0xFF, 0xC0, 0x78, 0x3E, 0xF8, 0x1E, 0x07, 0x8F, 0x07, 0x80, 0xF1,
  0xE1, 0xF0, 0x3E, 0x3C, 0x3C, 0x07, 0x87, 0x8F, 0x00, 0xF1, 0xF3, 0xC0,
  0x1E, 0x3C, 0xF8, 0x03, 0xC7, 0x9E, 0x7E, 0x7D, 0xF7, 0xBF, 0xEF, 0xFD,
  0xE7, 0xFC, 0xFF, 0x7D, 0xF7, 0xCF, 0xCF, 0x3C, 0xF8, 0x03, 0xCF, 0x9F,
  0x00, 0xF1, 0xE3, 0xE0, 0x1E, 0x3C, 0x7C, 0x07, 0x87, 0x8F, 0x01, 0xE0,
  0xF1, 0xE0, 0x78, 0x1E, 0x7C, 0x0F, 0x03, 0xDF, 0x03, 0xC0, 0x7F, 0xE0,
  0xF0, 0x0F, 0xF8, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x78,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xE3, 0xFF, 0x0F, 0xCF,
  0xFF, 0x1F, 0x3F, 0x3F, 0x7E, 0xFC, 0x3F, 0xF9, 0xF8, 0x7F, 0xE3, 0xF0,
  0x7F, 0xC7, 0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xF1, 0xFC, 0x3D, 0xF7, 0xDE, 0x79, 0xE7,
  0x9C, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x06, 0x1E, 0x03, 0xCF, 0x03, 0xFF, 0x01, 0xFF,
  0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC3, 0xF8, 0xE3, 0xFC, 0x03, 0xEF, 0x03,
  0xE7, 0x80, 0xF1, 0xE0, 0x30, 0xF0, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0xEF,
  0xFB, 0xFE, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x07,
  0xCF, 0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC3, 0xFE,
  0x3F, 0xF9, 0xFF, 0xEF, 0xEF, 0x9F, 0x7C, 0x31, 0xF0, 0x87, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xC7, 0xF0, 0x30, 0x3F, 0x02, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x47, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x70, 0x7E, 0x08, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x40, 0x0F, 0xCE, 0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xBC, 0x03,
  0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x7C,
  0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x18,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x40, 0x0F, 0xCE, 0x07, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xDF, 0x81, 0xF7, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE,
  0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF1, 0xF0,
  0x7E, 0x3E, 0x0F, 0x87, 0xE3, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x8F, 0x83, 0xF7, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xF3, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x7E, 0xFC, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFE, 0xF8, 0x3F, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x81, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x0F, 0x83, 0xF1, 0xF8, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x70, 0x7D, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0xFF, 0x1E, 0x78,
  0x3F, 0xF8, 0xE7, 0x87, 0xFF, 0x0F, 0xF0, 0xF8, 0xF0, 0xFF, 0x1F, 0x0F,
  0x0F, 0xF1, 0xE0, 0xF0, 0xEF, 0x1E, 0x1E, 0x1E, 0xF3, 0xC1, 0xE1, 0xEE,
  0x3C, 0x1E, 0x1E, 0xE3, 0xC3, 0xE3, 0xCE, 0x3C, 0x3E, 0x7C, 0xF1, 0xFF,
  0xFF, 0x8F, 0x1F, 0xEF, 0xF0, 0xF0, 0xFC, 0xFE, 0x0F, 0x82, 0x01, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x3F, 0x80, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3,
  0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x7E, 0x0F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x01, 0xF7, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x87, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x3F, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x0E, 0x0F, 0xC0,
  0x10, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x70, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xCF, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0,
  0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x03, 0xF8, 0x7C, 0x7F,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x10,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xF0, 0x70, 0x7F, 0x00, 0x43, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xFE, 0xFC, 0x1F, 0xF3,
  0xF0, 0xFF, 0xCF, 0xC3, 0xFF, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x3F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xFC, 0x0F,
  0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F,
  0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xE0, 0xF7, 0x01, 0xFF, 0x83, 0xDE, 0x07, 0xBC, 0x1F, 0x78,
  0x3F, 0xF0, 0x7D, 0xE0, 0xF7, 0xC1, 0xF7, 0x87, 0xDF, 0x07, 0x9E, 0x1E,
  0x7C, 0x1E, 0x78, 0xF9, 0xE0, 0xF9, 0xE3, 0xCF, 0x83, 0xE7, 0x9F, 0x3E,
  0x0F, 0x9E, 0x78, 0xF8, 0x3C, 0x7B, 0xE3, 0xC1, 0xF1, 0xEF, 0x1F, 0x07,
  0xC7, 0xFC, 0x7C, 0x1F, 0x1F, 0xE1, 0xF0, 0x7C, 0x7F, 0x87, 0xC1, 0xE1,
  0xFC, 0x1E, 0x0F, 0x87, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC1, 0xFC, 0x01, 0xE0, 0x7F, 0x00, 0xF8,
  0x3F, 0xC0, 0x3E, 0x0F, 0xF8, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0xFF, 0x80,
  0xF0, 0x3D, 0xF0, 0x7C, 0x1F, 0x7C, 0x1F, 0x07, 0xDF, 0x07, 0xC1, 0xF3,
  0xE1, 0xE0, 0x78, 0xF8, 0xF8, 0x1E, 0x3E, 0x3E, 0x0F, 0x87, 0xCF, 0x83,
  0xE1, 0xF3, 0xE0, 0xF8, 0x7C, 0xF0, 0x3C, 0x0F, 0xBC, 0x1F, 0x03, 0xFF,
  0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xF8, 0x1E, 0x01,
  0xFE, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E,
  0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8,
  0x7F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x81, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x1F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF0,
  0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x3F, 0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC7,
  0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0,
  0x3E, 0x1F, 0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x07,
  0xC1, 0xF8, 0x7C, 0x1F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0x83, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE2, 0x00, 0xF8,
  0xE0, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xC7, 0x80, 0x7E, 0x3E, 0x03,
  0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3E, 0xF8,
  0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0xFC, 0xF8,
  0x1F, 0xC0, 0xF8, 0xF8, 0x1F, 0xC0, 0xF8, 0xF8, 0x3F, 0xC1, 0xF0, 0xF8,
  0x3F, 0xC1, 0xF0, 0xF8, 0x7F, 0xC3, 0xE0, 0xF8, 0x7B, 0xC3, 0xE0, 0x78,
  0xFB, 0xC3, 0xE0, 0x78, 0xF3, 0xC7, 0xC0, 0x79, 0xF3, 0xC7, 0xC0, 0x79,
  0xE3, 0xCF, 0x80, 0x79, 0xE3, 0xCF, 0x80, 0x7B, 0xE3, 0xCF, 0x00, 0x7B,
  0xC3, 0xDF, 0x00, 0x7F, 0xC3, 0xDE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7C, 0x07,
  0xC7, 0xC0, 0xFC, 0x7C, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE7,
  0xE0, 0x3E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x41, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x87, 0x07, 0x83, 0xC3,
  0xC1, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xF9, 0xF1, 0xF1, 0xE1, 0xC0, 0x07, 0xE3,
  0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F, 0x87, 0xE7,
  0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xEF, 0x83, 0xF3, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xBF, 0x07, 0xDF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xCF, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0xFD,
  0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x07, 0xE7, 0xE3, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3D, 0xFF, 0x0F, 0x3F, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xE7, 0xF0, 0x4F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x04, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xE7, 0xC0, 0xFF, 0x7C, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFB, 0xC0, 0x3F,
  0x3C, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF3, 0xE7, 0xE0,
  0xFB, 0xE0, 0x7F, 0xF0, 0x7D, 0xF0, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x11, 0xFF, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF1, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC4, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF1, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x7E,
  0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7C, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x20, 0x3F, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xBF, 0x87, 0xDF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0x87, 0xCF, 0xE1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81,
  0xF7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xFB,
  0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x01, 0x81, 0xF0,
  0x7C, 0x3F, 0x07, 0xC0, 0x40, 0x00, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0x0F, 0x83,
  0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x1F,
  0xBF, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE0,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0x0F, 0x3F,
  0x07, 0xE0, 0xF3, 0xFC, 0x7F, 0x87, 0xBF, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF1, 0xF8, 0x7F, 0x1F, 0x9F, 0xC3, 0xF0, 0x7C, 0xFC, 0x1F, 0x83, 0xE7,
  0xE0, 0xF8, 0x3F, 0x3E, 0x07, 0xC1, 0xF1, 0xF0, 0x7E, 0x0F, 0x9F, 0x83,
  0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x3F, 0x3E, 0x07, 0xC1,
  0xF1, 0xF0, 0x7C, 0x0F, 0x9F, 0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xE7,
  0xC0, 0xF8, 0x3F, 0x3E, 0x0F, 0xC1, 0xF0, 0x0F, 0x3F, 0x87, 0x9F, 0xE1,
  0xEF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xCF, 0xE1, 0xF3, 0xF0, 0x7C, 0xFC,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC1, 0xFB, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xE1,
  0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xE1, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x79, 0xFE,
  0x07, 0xBF, 0xF0, 0x7F, 0xFF, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0,
  0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0x8F, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xEF, 0xF0, 0x3E, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xEF, 0x03, 0xF7, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x3E, 0x3E, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC7, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x9E,
  0x3F, 0x02, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0xC0, 0x7C, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x83, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xDE,
  0x0F, 0xF3, 0xC0, 0xFC, 0x78, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81,
  0xFB, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0x87, 0xC1, 0xE1, 0xF0,
  0x78, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x3F, 0x03, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0x7C,
  0x3F, 0x87, 0xEF, 0x87, 0x70, 0xF9, 0xF1, 0xEE, 0x1F, 0x3E, 0x3D, 0xC7,
  0xC7, 0xCF, 0x38, 0xF8, 0x79, 0xE7, 0x3E, 0x0F, 0x3C, 0xE7, 0xC1, 0xEF,
  0x1C, 0xF0, 0x3D, 0xE3, 0xBE, 0x07, 0xF8, 0x77, 0x80, 0xFF, 0x0E, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xE0,
  0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF8, 0x07,
  0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF4,
  0x00, 0x40,
};

const GFXglyph NotoSans_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 25, 10, 0, -25 },
  { 36, 13, 9, 16, 3, -25 },
  { 51, 22, 25, 23, 1, -25 },
  { 120, 18, 29, 19, 1, -27 },
  { 186, 27, 25, 30, 2, -25 },
  { 271, 23, 25, 25, 1, -25 },
  { 343, 6, 9, 9, 3, -25 },
  { 350, 13, 31, 12, 1, -25 },
  { 401, 13, 31, 12, -2, -25 },
  { 452, 17, 17, 19, 3, -27 },
  { 489, 17, 17, 20, 2, -21 },
  { 526, 9, 9, 10, -2, -4 },
  { 537, 10, 5, 11, 1, -12 },
  { 544, 6, 5, 10, 0, -5 },
  { 548, 19, 25, 15, -2, -25 },
  { 608, 18, 25, 19, 1, -25 },
  { 665, 14, 25, 19, 3, -25 },
  { 709, 20, 25, 19, -1, -25 },
  { 772, 19, 25, 19, 0, -25 },
  { 832, 19, 25, 19, 0, -25 },
  { 892, 19, 25, 19, 0, -25 },
  { 952, 19, 25, 19, 1, -25 },
  { 1012, 20, 25, 19, 1, -25 },
  { 1075, 18, 25, 19, 1, -25 },
  { 1132, 18, 25, 19, 1, -25 },
  { 1189, 10, 19, 10, 0, -19 },
  { 1213, 12, 24, 10, -2, -19 },
  { 1249, 17, 19, 20, 2, -22 },
  { 1290, 17, 11, 20, 2, -18 },
  { 1314, 17, 19, 20, 2, -22 },
  { 1355, 14, 25, 16, 3, -25 },
  { 1399, 28, 28, 30, 2, -25 },
  { 1497, 22, 25, 22, -2, -25 },
  { 1566, 20, 25, 22, 1, -25 },
  { 1629, 21, 25, 21, 2, -25 },
  { 1695, 22, 25, 24, 1, -25 },
  { 1764, 19, 25, 19, 1, -25 },
  { 1824, 19, 25, 19, 1, -25 },
  { 1884, 22, 25, 24, 2, -25 },
  { 1953, 24, 25, 25, 1, -25 },
  { 2028, 16, 25, 13, -1, -25 },
  { 2078, 18, 32, 12, -6, -25 },
  { 2150, 24, 25, 21, 1, -25 },
  { 2225, 15, 25, 18, 1, -25 },
  { 2272, 30, 25, 31, 1, -25 },
  { 2366, 26, 25, 27, 1, -25 },
  { 2448, 23, 25, 26, 2, -25 },
  { 2520, 21, 25, 21, 1, -25 },
  { 2586, 23, 31, 26, 2, -25 },
  { 2676, 20, 25, 22, 1, -25 },
  { 2739, 18, 25, 19, 1, -25 },
  { 2796, 18, 25, 19, 3, -25 },
  { 2853, 23, 25, 24, 2, -25 },
  { 2925, 21, 25, 21, 3, -25 },
  { 2991, 32, 25, 31, 3, -25 },
  { 3091, 26, 25, 21, -2, -25 },
  { 3173, 20, 25, 20, 3, -25 },
  { 3236, 22, 25, 19, -1, -25 },
  { 3305, 15, 31, 12, -1, -25 },
  { 3364, 8, 25, 15, 4, -25 },
  { 3389, 14, 31, 12, -2, -25 },
  { 3444, 17, 16, 19, 1, -25 },
  { 3478, 14, 3, 14, -3, 3 },
  { 3484, 7, 6, 11, 5, -27 },
  { 3490, 18, 19, 21, 2, -19 },
  { 3533, 18, 27, 21, 1, -27 },
  { 3594, 15, 19, 17, 2, -19 },
  { 3630, 20, 27, 21, 2, -27 },
  { 3698, 17, 19, 20, 2, -19 },
  { 3739, 21, 35, 13, -4, -27 },
  { 3831, 19, 27, 21, 1, -19 },
  { 3896, 18, 27, 21, 1, -27 },
  { 3957, 10, 27, 10, 1, -27 },
  { 3991, 15, 35, 10, -4, -27 },
  { 4057, 21, 27, 20, 1, -27 },
  { 4128, 10, 27, 10, 1, -27 },
  { 4162, 29, 19, 32, 1, -19 },
  { 4231, 18, 19, 21, 1, -19 },
  { 4274, 17, 19, 20, 2, -19 },
  { 4315, 20, 27, 21, -1, -19 },
  { 4383, 18, 27, 21, 2, -19 },
  { 4444, 15, 19, 15, 1, -19 },
  { 4480, 16, 19, 17, 0, -19 },
  { 4518, 13, 23, 14, 2, -23 },
  { 4556, 19, 19, 21, 2, -19 },
  { 4602, 18, 19, 18, 2, -19 },
  { 4645, 27, 19, 28, 2, -19 },
  { 4710, 22, 19, 19, -2, -19 },
  { 4763, 22, 27, 18, -2, -19 },
  { 4838, 18, 19, 16, -1, -19 },
  { 4881, 15, 31, 12, 0, -25 },
  { 4940, 4, 35, 19, 8, -27 },
  { 4958, 15, 31, 12, -2, -25 },
  { 5017, 17, 6, 20, 2, -15 },
};

const GFXfont NotoSans_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_BOLDITALIC35PT7B_H_
