#ifndef _NOTOSANS_BOLDITALIC8PT7B_H_
#define _NOTOSANS_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xB8, 0x29, 0x9E, 0xAF, 0xB0, 0x27, 0x63, 0xB6,
  0x64, 0xD2, 0xD2, 0xD2, 0xC9, 0x80, 0x31, 0x47, 0x1B, 0xD9, 0xE0, 0xC0,
  0x29, 0x49, 0x10, 0x24, 0x92, 0x70, 0x4F, 0xCA, 0x22, 0xF2, 0xE0, 0xC0,
  0x80, 0x12, 0x24, 0x48, 0x35, 0xD9, 0x96, 0x3D, 0x25, 0x80, 0x75, 0x12,
  0x4F, 0x75, 0x17, 0x1E, 0x13, 0x5F, 0xF2, 0x74, 0x61, 0x1E, 0x3A, 0x1D,
  0xAD, 0x30, 0x78, 0x8C, 0x46, 0x60, 0x35, 0x77, 0x97, 0x75, 0xD7, 0x1E,
  0x42, 0x42, 0x80, 0x16, 0xE1, 0xFF, 0xC2, 0x3C, 0xD5, 0xC1, 0x00, 0x18,
  0xC9, 0xED, 0x5B, 0xC8, 0x0E, 0x00, 0x31, 0x94, 0xAF, 0x4C, 0x72, 0x56,
  0xE5, 0xF8, 0x3B, 0x51, 0x84, 0x38, 0x72, 0x52, 0x95, 0xF8, 0x7A, 0x10,
  0xE4, 0x78, 0x7A, 0x10, 0xE4, 0x60, 0x3B, 0x51, 0xB4, 0xBC, 0x6D, 0x24,
  0x9E, 0x4B, 0x60, 0x76, 0x44, 0x4C, 0x32, 0x22, 0x26, 0x48, 0x6D, 0x67,
  0x18, 0x53, 0x40, 0x64, 0x44, 0x4F, 0x66, 0xCD, 0xAB, 0x67, 0x56, 0x80,
  0x65, 0x97, 0x56, 0x5A, 0x60, 0x39, 0xA4, 0xF2, 0x49, 0xC0, 0x72, 0x52,
  0xE4, 0x60, 0x39, 0xA4, 0xF2, 0x49, 0xC1, 0x80, 0x72, 0xD6, 0xE5, 0x6C,
  0x35, 0x43, 0x3E, 0xF4, 0x44, 0xC8, 0xDC, 0xA5, 0x2B, 0x70, 0x99, 0xAA,
  0xCC, 0x93, 0x6A, 0xD6, 0xCD, 0x93, 0x00, 0x4D, 0xE3, 0x1C, 0x52, 0x40,
  0x9A, 0xA4, 0xC8, 0x78, 0x88, 0xCC, 0x78, 0x69, 0x29, 0x30, 0xAA, 0x50,
  0x31, 0x22, 0x22, 0xC0, 0x22, 0x59, 0xF0, 0xC0, 0x7E, 0xB4, 0xE0, 0x64,
  0x75, 0xDF, 0x7C, 0xC6, 0x08, 0xDD, 0xAD, 0x38, 0x7F, 0xC7, 0x19, 0x1C,
  0x42, 0x31, 0x18, 0x7E, 0xB4, 0xE3, 0x70, 0x64, 0x75, 0xD9, 0x61, 0x2D,
  0x00, 0x30, 0x22, 0x64, 0x4C, 0x62, 0x54, 0xCE, 0x48, 0x69, 0x2D, 0x00,
  0x7E, 0xA7, 0x5C, 0xA0, 0x75, 0xD9, 0x7D, 0xD7, 0x75, 0xDF, 0x88, 0x7E,
  0xB4, 0xE3, 0x10, 0x74, 0xC8, 0x76, 0x2E, 0x7D, 0x2E, 0x5A, 0xB4, 0xE0,
  0xDB, 0x98, 0x80, 0xD6, 0xE9, 0xE2, 0xC0, 0x5B, 0x19, 0x60, 0x6C, 0xE3,
  0x0C, 0x23, 0x00, 0x76, 0x4E, 0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20,
  0xF0,
};

const GFXglyph NotoSans_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 6, 4, 0, -6 },
  { 12, 7, 6, 7, 0, -6 },
  { 18, 6, 6, 6, 0, -6 },
  { 23, 1, 2, 2, 1, -6 },
  { 24, 3, 7, 3, 0, -6 },
  { 27, 3, 7, 3, -1, -6 },
  { 30, 4, 4, 4, 1, -6 },
  { 32, 4, 4, 5, 0, -5 },
  { 34, 2, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 0, -1 },
  { 37, 4, 6, 3, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 3, 6, 4, 1, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 5, 6, 4, 0, -6 },
  { 62, 5, 6, 4, 0, -6 },
  { 66, 4, 6, 4, 0, -6 },
  { 69, 4, 6, 4, 0, -6 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 2, 5, 2, 0, -4 },
  { 75, 4, 4, 5, 0, -5 },
  { 77, 4, 2, 5, 0, -4 },
  { 78, 4, 4, 5, 0, -5 },
  { 80, 3, 6, 4, 1, -6 },
  { 83, 7, 7, 7, 0, -6 },
  { 90, 5, 6, 5, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 4, 0, -6 },
  { 110, 5, 6, 4, 0, -6 },
  { 114, 5, 6, 6, 0, -6 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 4, 6, 3, 0, -6 },
  { 126, 4, 8, 3, -1, -6 },
  { 130, 6, 6, 5, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 7, 6, 7, 0, -6 },
  { 144, 6, 6, 6, 0, -6 },
  { 149, 6, 6, 6, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 6, 7, 6, 0, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 4, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 1, -6 },
  { 174, 5, 6, 6, 1, -6 },
  { 178, 4, 6, 5, 1, -6 },
  { 181, 7, 6, 7, 1, -6 },
  { 187, 6, 6, 5, 0, -6 },
  { 192, 4, 6, 5, 1, -6 },
  { 195, 5, 6, 4, 0, -6 },
  { 199, 3, 7, 3, 0, -6 },
  { 202, 2, 6, 3, 1, -6 },
  { 204, 4, 7, 3, -1, -6 },
  { 208, 4, 4, 4, 0, -6 },
  { 210, 4, 1, 3, -1, 0 },
  { 211, 2, 1, 3, 1, -6 },
  { 212, 5, 4, 5, 0, -4 },
  { 215, 4, 6, 5, 0, -6 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 5, 6, 5, 0, -6 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 5, 8, 3, -1, -6 },
  { 231, 5, 6, 5, 0, -4 },
  { 235, 4, 6, 5, 0, -6 },
  { 238, 3, 6, 2, 0, -6 },
  { 241, 4, 8, 2, -1, -6 },
  { 245, 5, 6, 5, 0, -6 },
  { 249, 3, 6, 2, 0, -6 },
  { 252, 7, 4, 7, 0, -4 },
  { 256, 4, 4, 5, 0, -4 },
  { 258, 4, 4, 5, 0, -4 },
  { 260, 4, 6, 5, 0, -4 },
  { 263, 5, 6, 5, 0, -4 },
  { 267, 4, 4, 3, 0, -4 },
  { 269, 4, 4, 4, 0, -4 },
  { 271, 3, 5, 3, 0, -5 },
  { 273, 5, 4, 5, 0, -4 },
  { 276, 5, 4, 4, 0, -4 },
  { 279, 7, 4, 6, 0, -4 },
  { 283, 5, 4, 4, 0, -4 },
  { 286, 6, 6, 4, -1, -4 },
  { 291, 4, 4, 4, 0, -4 },
  { 293, 3, 7, 3, 0, -6 },
  { 296, 1, 8, 4, 2, -6 },
  { 297, 3, 7, 3, 0, -6 },
  { 300, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_BOLDITALIC8PT7B_H_
