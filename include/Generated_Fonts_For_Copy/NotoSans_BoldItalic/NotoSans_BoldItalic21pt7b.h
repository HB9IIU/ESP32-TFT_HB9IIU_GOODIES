#ifndef _NOTOSANS_BOLDITALIC21PT7B_H_
#define _NOTOSANS_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x30, 0xE0, 0x00, 0x07,
  0x1E, 0x3C, 0x00, 0x77, 0x66, 0xE6, 0xEE, 0xCC, 0x03, 0x30, 0x0C, 0xC0,
  0x67, 0x01, 0x98, 0x3F, 0xFC, 0xFF, 0xF0, 0xCE, 0x03, 0x30, 0x1C, 0xC1,
  0xFF, 0xEF, 0xFF, 0x06, 0x60, 0x39, 0x80, 0xCE, 0x03, 0x30, 0x00, 0x03,
  0x00, 0x81, 0xFC, 0xFF, 0x7E, 0x5D, 0x87, 0xC0, 0xF8, 0x1F, 0x83, 0xE0,
  0xFC, 0x27, 0xCB, 0xBF, 0xEF, 0xE0, 0x40, 0x10, 0x00, 0x3E, 0x0E, 0x7E,
  0x1C, 0x76, 0x18, 0xE6, 0x30, 0xE6, 0x70, 0xE6, 0xE0, 0xEE, 0xDE, 0xFD,
  0xBF, 0x7B, 0xB3, 0x07, 0x73, 0x06, 0x73, 0x0C, 0x77, 0x1C, 0x77, 0x38,
  0x7E, 0x70, 0x3C, 0x0F, 0xC0, 0x7F, 0x01, 0xCE, 0x06, 0x38, 0x19, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0x8F, 0x7F, 0x3B, 0x9F, 0xCE, 0x3F, 0x38, 0x78,
  0xF7, 0xE3, 0xFF, 0xC7, 0xE7, 0x80, 0x76, 0xEE, 0xC0, 0x0F, 0x0C, 0x1C,
  0x38, 0x30, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x70, 0x1C, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x0E, 0x1C,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xC0, 0x0E, 0x03, 0x8C, 0xC3, 0xF0,
  0xFF, 0xC7, 0xF3, 0xE3, 0xD8, 0x66, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B, 0x9C,
  0xCC, 0x00, 0x7D, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x00, 0xE0, 0x38, 0x00, 0x0F, 0x8F, 0xF3, 0x9D, 0xC7, 0x71, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x3F, 0xC7, 0xE0, 0x07,
  0x1F, 0x3F, 0xFE, 0xEE, 0x4E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x07, 0xE1, 0xFF, 0x1E, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x7F, 0xE7, 0xFE, 0xFF,
  0xC0, 0x0F, 0xC7, 0xFC, 0x67, 0x80, 0x70, 0x0E, 0x03, 0xC3, 0xF0, 0xF8,
  0x07, 0xC0, 0x38, 0x07, 0x00, 0xEC, 0x7D, 0xFF, 0x3F, 0xC0, 0x00, 0xE0,
  0x3C, 0x0F, 0x83, 0xF0, 0xEC, 0x1B, 0x87, 0x71, 0xCE, 0x71, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x01, 0xC0, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1,
  0xC0, 0x18, 0x03, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0xE7, 0xCF, 0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xFC, 0xF8, 0x9C, 0x07,
  0x00, 0xEE, 0x3B, 0xE7, 0xFE, 0xF1, 0xDC, 0x3B, 0x87, 0x71, 0xCF, 0x78,
  0xFE, 0x0F, 0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x00,
  0x1F, 0x87, 0xF8, 0xE7, 0x38, 0x77, 0x9C, 0x77, 0x87, 0xE1, 0xF8, 0x7F,
  0x9C, 0x73, 0x87, 0x71, 0xEE, 0x39, 0xFF, 0x1F, 0x80, 0x1F, 0x8F, 0xE7,
  0xBD, 0xC7, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF, 0x7D, 0xCE, 0xE0, 0x38, 0x1E,
  0x8F, 0x3F, 0x8F, 0xC0, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xCF,
  0x3C, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x87,
  0x1C, 0x30, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x38, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x70, 0x7C, 0xFC,
  0xFC, 0x38, 0x08, 0x00, 0x7E, 0xFF, 0xE7, 0x07, 0x07, 0x0F, 0x3E, 0x38,
  0x70, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x07,
  0x83, 0xC7, 0x00, 0x67, 0x1F, 0xBB, 0x1F, 0x9F, 0x9C, 0xCF, 0x9C, 0x67,
  0xCC, 0x73, 0xE6, 0x31, 0xB3, 0x39, 0xD9, 0xFF, 0xCE, 0x73, 0xC3, 0x80,
  0x01, 0xE0, 0x40, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xFF,
  0x8F, 0xFC, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xE0, 0x1F, 0xC3, 0xFE,
  0x3F, 0xF3, 0x87, 0x38, 0x73, 0x8E, 0x7F, 0xC7, 0xF8, 0x73, 0xC7, 0x0E,
  0xF0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xCF,
  0xDC, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0xDC, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFF,
  0x0F, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x3D, 0xE1, 0xEE, 0x0E, 0x70, 0x73,
  0x83, 0xBC, 0x3D, 0xC3, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x1F, 0xE7,
  0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x9F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03,
  0xC0, 0x70, 0x0F, 0xF1, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC, 0xFF, 0x9C,
  0x03, 0x80, 0x70, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0xF8, 0x7F, 0xC7, 0xDC, 0x78, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x3E, 0x3E, 0xF3, 0xF7, 0x83, 0xBC, 0x1C, 0xE1, 0xC7,
  0xDE, 0x1F, 0xF0, 0x7F, 0x80, 0x1C, 0x1C, 0xF0, 0xE3, 0x83, 0x8E, 0x0E,
  0x38, 0x38, 0xE1, 0xE7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xC1, 0xCF, 0x0F,
  0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x00, 0x1F, 0xC7, 0xF0, 0xF0,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x1F, 0x8F, 0xE0, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x3F, 0x0F, 0x80, 0x1C, 0x3C, 0xF1, 0xE3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0,
  0xEE, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F, 0x38, 0x38, 0xE0,
  0xE3, 0xC3, 0x87, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0xCF,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x36, 0x1F, 0x8D, 0x8E, 0xC7, 0x63,
  0x71, 0xD9, 0xDC, 0x76, 0x67, 0x1D, 0xB9, 0xCE, 0x6C, 0xE3, 0x9F, 0x38,
  0xE7, 0x8E, 0x39, 0xE3, 0x8C, 0x70, 0xE0, 0x1C, 0x0E, 0x7C, 0x1C, 0xF8,
  0x31, 0xF0, 0xE3, 0x71, 0xC6, 0xE3, 0x9D, 0xC7, 0x39, 0xCC, 0x73, 0xB8,
  0xE7, 0x73, 0x87, 0xE7, 0x0F, 0xCE, 0x1F, 0x1C, 0x1E, 0x38, 0x3C, 0x00,
  0x07, 0xE0, 0x7F, 0xC3, 0xE7, 0x8F, 0x0E, 0x78, 0x3D, 0xC0, 0xF7, 0x03,
  0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0x9C, 0x3C, 0x7D, 0xF0, 0xFF,
  0x81, 0xF8, 0x00, 0x1F, 0xC3, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87,
  0x70, 0xF7, 0xFE, 0x7F, 0xC7, 0xE0, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x0E, 0x78, 0x3D, 0xC0,
  0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0x9C, 0x3C, 0x7F,
  0xF0, 0xFF, 0x81, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x87, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xDE, 0x7B, 0xFE, 0x7F,
  0x0E, 0xF3, 0xCE, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x78, 0x0F, 0xE3, 0xFC,
  0x7B, 0x9C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x41, 0xEE, 0x79, 0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x39,
  0xE1, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x0E, 0x3C, 0x38,
  0x7B, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCE, 0x38, 0xE3, 0x86, 0x70, 0x67, 0x06, 0xE0, 0x6E, 0x06, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x87,
  0x71, 0xF1, 0xCE, 0x3E, 0x39, 0xCF, 0xCE, 0x39, 0xF9, 0xC7, 0x37, 0x70,
  0xEE, 0xEE, 0x1D, 0x9D, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81,
  0xE0, 0xF0, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x1C, 0x38, 0x38, 0xF0, 0x7B,
  0xC0, 0x77, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x7B, 0x81, 0xE7, 0x03, 0x8F, 0x0E, 0x0E, 0x3C, 0x1E, 0x00, 0xE0, 0xFE,
  0x1E, 0x71, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x00, 0x0F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0x1F,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0xE0, 0xE0, 0xF8, 0xF8, 0xE3, 0x18, 0xC7, 0x39, 0xCE, 0x31, 0x8E, 0x73,
  0x9C, 0x60, 0x1F, 0x1F, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0xF8, 0xF8, 0x03, 0x00, 0x70, 0x1E,
  0x07, 0xC0, 0xDC, 0x31, 0x8E, 0x31, 0x86, 0x70, 0xFC, 0x0C, 0xFF, 0x80,
  0xE7, 0x30, 0x0C, 0x07, 0xFC, 0xFF, 0xBC, 0xF7, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0xE3, 0x9E, 0xF3, 0xFE, 0x3D, 0xC0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1D, 0x81, 0xFE, 0x3F, 0xE3, 0xCF, 0x38, 0xF3, 0x8F, 0x30, 0xE7,
  0x0E, 0x71, 0xE7, 0xBC, 0x7F, 0xCE, 0xF8, 0x07, 0x0F, 0xCF, 0xEF, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x79, 0x9F, 0xC7, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x0C, 0xE3, 0xFE, 0x3F, 0xE7, 0x1C, 0x71, 0xCE, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE3, 0x8F, 0x78, 0xFF, 0x87, 0xB8, 0x07, 0x07, 0xE3,
  0xFD, 0xC7, 0x71, 0xFF, 0xEF, 0xF3, 0x80, 0xE0, 0x3C, 0x47, 0xF0, 0xFC,
  0x01, 0xF0, 0x3F, 0x03, 0x90, 0x38, 0x07, 0x01, 0xFE, 0x1F, 0xC0, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x06, 0x01, 0xFF, 0x1F,
  0xF3, 0xCF, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0xBC, 0x7F,
  0xC3, 0xDC, 0x01, 0xC0, 0x38, 0xE7, 0x8F, 0xF0, 0x7E, 0x00, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0xC1, 0xFE, 0x3F, 0xE3, 0xCF, 0x38, 0xF3,
  0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0x0E, 0x3C,
  0x70, 0x00, 0x03, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x78,
  0x01, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x0F, 0xC3,
  0xE0, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E,
  0x78, 0xE3, 0x87, 0x38, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0x38,
  0x39, 0xE1, 0xC7, 0x1E, 0x3C, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C,
  0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0x00, 0xC3, 0x06, 0xFB, 0xE3,
  0xFE, 0xFC, 0xF3, 0xC7, 0x38, 0xF1, 0xCE, 0x38, 0x73, 0x8E, 0x39, 0xC3,
  0x8E, 0x70, 0xE3, 0x9C, 0x70, 0xE7, 0x1C, 0x3B, 0xC7, 0x1C, 0x00, 0xC1,
  0xBE, 0x3F, 0xE3, 0xCF, 0x38, 0xF3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE7,
  0x1E, 0x71, 0xCF, 0x1C, 0x0E, 0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE3, 0xFD, 0xE7, 0xF0, 0xF8, 0x00, 0xC0, 0x6F, 0x87, 0xFC,
  0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0x61, 0xC7, 0x0E, 0x38, 0xF1, 0xEF, 0x0F,
  0xF8, 0xEF, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x0C,
  0x07, 0xFC, 0xFF, 0xB8, 0xE7, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0x9E,
  0xF3, 0xFE, 0x3D, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01,
  0xC6, 0xE3, 0xF8, 0xF8, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0x0F, 0x0F, 0xF3, 0xF9, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0xA1, 0xCF, 0xF3, 0xF8, 0x1C, 0x18, 0x38, 0xFF, 0xFF, 0x70, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0xF4, 0xFC, 0x7C, 0x78, 0xEE, 0x1D, 0xC3, 0xB8,
  0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x1E, 0xF7, 0x9F, 0xB1, 0xE6, 0x00, 0xE1,
  0xFC, 0x3B, 0x8E, 0x31, 0xC6, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xE0, 0x00, 0xE3, 0xC7, 0xF1, 0xE3, 0xB9, 0xF3, 0x9C, 0xD9, 0xC6,
  0xED, 0xC3, 0x66, 0xE1, 0xB3, 0x60, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x1C, 0x38, 0x00, 0x1C, 0x78, 0xF7, 0x83, 0xB8, 0x1F, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x03, 0xF0, 0x39, 0xC3, 0xCE, 0x3C, 0x78, 0x38, 0x79, 0xC3,
  0x8E, 0x38, 0x31, 0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x7E, 0x03, 0xE0, 0x1C, 0x00, 0x3F,
  0xCF, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x3F, 0xCF,
  0xF0, 0x07, 0x87, 0x83, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x70, 0xF8, 0x78,
  0x1C, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x1C, 0x0F, 0x87, 0x87, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0xF0, 0x70,
  0x00, 0x7C, 0x7F, 0xF8, 0xFC,
};

const GFXglyph NotoSans_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 15, 6, 0, -15 },
  { 15, 8, 5, 10, 2, -15 },
  { 20, 14, 15, 14, 0, -15 },
  { 47, 10, 17, 12, 1, -16 },
  { 69, 16, 15, 18, 1, -15 },
  { 99, 14, 15, 15, 1, -15 },
  { 126, 4, 5, 5, 2, -15 },
  { 129, 8, 18, 7, 1, -15 },
  { 147, 7, 18, 7, -1, -15 },
  { 163, 10, 10, 11, 2, -16 },
  { 176, 10, 11, 12, 1, -13 },
  { 190, 5, 5, 6, -1, -2 },
  { 194, 6, 3, 7, 0, -7 },
  { 197, 4, 3, 6, 0, -3 },
  { 199, 11, 15, 9, -1, -15 },
  { 220, 10, 15, 12, 1, -15 },
  { 239, 8, 15, 12, 2, -15 },
  { 254, 12, 15, 12, -1, -15 },
  { 277, 11, 15, 12, 0, -15 },
  { 298, 11, 15, 12, 0, -15 },
  { 319, 12, 15, 12, 0, -15 },
  { 342, 11, 15, 12, 1, -15 },
  { 363, 11, 15, 12, 1, -15 },
  { 384, 11, 15, 12, 1, -15 },
  { 405, 10, 15, 12, 1, -15 },
  { 424, 6, 12, 6, 0, -12 },
  { 433, 7, 15, 6, -1, -12 },
  { 447, 10, 11, 12, 1, -13 },
  { 461, 10, 7, 12, 1, -11 },
  { 470, 10, 11, 12, 1, -13 },
  { 484, 8, 15, 10, 2, -15 },
  { 499, 17, 17, 18, 1, -15 },
  { 536, 13, 15, 13, -1, -15 },
  { 561, 12, 15, 13, 1, -15 },
  { 584, 13, 15, 13, 1, -15 },
  { 609, 13, 15, 14, 1, -15 },
  { 634, 11, 15, 11, 1, -15 },
  { 655, 11, 15, 11, 1, -15 },
  { 676, 13, 15, 14, 1, -15 },
  { 701, 14, 15, 15, 1, -15 },
  { 728, 10, 15, 8, -1, -15 },
  { 747, 10, 19, 7, -3, -15 },
  { 771, 14, 15, 13, 1, -15 },
  { 798, 8, 15, 11, 1, -15 },
  { 813, 18, 15, 18, 1, -15 },
  { 847, 15, 15, 16, 1, -15 },
  { 876, 14, 15, 15, 1, -15 },
  { 903, 12, 15, 13, 1, -15 },
  { 926, 14, 19, 15, 1, -15 },
  { 960, 11, 15, 13, 1, -15 },
  { 981, 11, 15, 11, 0, -15 },
  { 1002, 11, 15, 11, 2, -15 },
  { 1023, 14, 15, 15, 1, -15 },
  { 1050, 12, 15, 12, 2, -15 },
  { 1073, 19, 15, 19, 2, -15 },
  { 1109, 15, 15, 13, -1, -15 },
  { 1138, 12, 15, 12, 2, -15 },
  { 1161, 13, 15, 11, -1, -15 },
  { 1186, 8, 18, 7, 0, -15 },
  { 1204, 5, 15, 9, 2, -15 },
  { 1214, 8, 18, 7, -1, -15 },
  { 1232, 11, 10, 12, 0, -15 },
  { 1246, 9, 1, 8, -2, 2 },
  { 1248, 4, 3, 7, 3, -16 },
  { 1250, 11, 12, 12, 1, -12 },
  { 1267, 12, 16, 13, 0, -16 },
  { 1291, 9, 12, 10, 1, -12 },
  { 1305, 12, 16, 12, 1, -16 },
  { 1329, 10, 12, 12, 1, -12 },
  { 1344, 12, 21, 8, -2, -16 },
  { 1376, 12, 17, 13, 0, -12 },
  { 1402, 12, 16, 13, 0, -16 },
  { 1426, 7, 16, 6, 0, -16 },
  { 1440, 10, 21, 6, -3, -16 },
  { 1467, 13, 16, 12, 0, -16 },
  { 1493, 7, 16, 6, 0, -16 },
  { 1507, 18, 12, 19, 0, -12 },
  { 1534, 12, 12, 13, 0, -12 },
  { 1552, 10, 12, 12, 1, -12 },
  { 1567, 13, 17, 13, -1, -12 },
  { 1595, 11, 17, 12, 1, -12 },
  { 1619, 10, 12, 9, 0, -12 },
  { 1634, 10, 12, 10, 0, -12 },
  { 1649, 8, 14, 9, 1, -14 },
  { 1663, 11, 11, 13, 1, -11 },
  { 1679, 11, 11, 11, 1, -11 },
  { 1695, 17, 11, 17, 1, -11 },
  { 1719, 13, 11, 11, -1, -11 },
  { 1737, 13, 16, 11, -1, -11 },
  { 1763, 10, 11, 10, 0, -11 },
  { 1777, 9, 18, 7, 0, -15 },
  { 1798, 2, 21, 12, 5, -16 },
  { 1804, 9, 18, 7, -1, -15 },
  { 1825, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_BOLDITALIC21PT7B_H_
