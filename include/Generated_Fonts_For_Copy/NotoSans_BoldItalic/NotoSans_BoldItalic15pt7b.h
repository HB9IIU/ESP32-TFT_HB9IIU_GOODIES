#ifndef _NOTOSANS_BOLDITALIC15PT7B_H_
#define _NOTOSANS_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x07, 0x38, 0x6D, 0xB4, 0xB6, 0x0D,
  0x82, 0x60, 0x91, 0xFF, 0x7F, 0xC4, 0x8F, 0xFB, 0xFE, 0x26, 0x09, 0x06,
  0xC0, 0x04, 0x1F, 0x3F, 0x38, 0x38, 0x3E, 0x0E, 0x0F, 0xD6, 0xFE, 0x10,
  0x10, 0x30, 0x4F, 0x13, 0x66, 0x6D, 0x8D, 0xA5, 0xEF, 0xDB, 0x58, 0xDB,
  0x13, 0x66, 0x6D, 0x87, 0x00, 0x0E, 0x07, 0xC1, 0xB0, 0x6C, 0x1E, 0x0F,
  0x37, 0xCD, 0x9E, 0xE7, 0x9F, 0xE7, 0xDC, 0x6D, 0x60, 0x19, 0x98, 0xCC,
  0x63, 0x18, 0x84, 0x31, 0x8C, 0x00, 0x18, 0x61, 0x82, 0x0C, 0x31, 0x86,
  0x18, 0x63, 0x18, 0xE0, 0x0C, 0xB3, 0xF9, 0xF6, 0x8D, 0x82, 0x00, 0x10,
  0x20, 0x47, 0xFF, 0xE2, 0x04, 0x00, 0x36, 0x6C, 0x7F, 0x80, 0xFC, 0x03,
  0x03, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x0E, 0x3F,
  0x33, 0x73, 0x63, 0x63, 0x63, 0xE7, 0x66, 0x7E, 0x7C, 0x0C, 0x7F, 0xDF,
  0x18, 0x61, 0x86, 0x38, 0xC3, 0x00, 0x1E, 0x7F, 0x23, 0x03, 0x07, 0x0E,
  0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x3F, 0x23, 0x03, 0x06, 0x38, 0x0E,
  0x06, 0x06, 0xFE, 0xFC, 0x03, 0x07, 0x0F, 0x1E, 0x36, 0x76, 0x66, 0xFF,
  0xFF, 0x0C, 0x0C, 0x1F, 0x3F, 0x30, 0x30, 0x3C, 0x7E, 0x06, 0x06, 0x06,
  0xFE, 0xFC, 0x0E, 0x7D, 0xC3, 0x0D, 0xDF, 0xF3, 0xE7, 0xCD, 0xF9, 0xE0,
  0x7F, 0xFF, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x1E,
  0x3F, 0x33, 0x33, 0x3E, 0x3C, 0x76, 0x67, 0xE7, 0x7E, 0x7C, 0x3C, 0xFF,
  0x9E, 0x3C, 0x7F, 0xDD, 0x86, 0x1D, 0xF3, 0xC0, 0x37, 0x00, 0x00, 0xEE,
  0x19, 0xC0, 0x00, 0x00, 0xCC, 0x66, 0x00, 0x06, 0x3D, 0xE6, 0x0F, 0x07,
  0x81, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x71, 0xFE,
  0x30, 0x40, 0x3B, 0xF4, 0xC3, 0x1C, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x01, 0xFC, 0x70, 0x66, 0x7B, 0xCD, 0xBD, 0x93, 0x93, 0x29, 0x36, 0x9F,
  0xCC, 0x88, 0x60, 0x83, 0xF0, 0x03, 0x01, 0xE0, 0x78, 0x36, 0x1D, 0x86,
  0x63, 0x98, 0xFE, 0x71, 0x98, 0x6E, 0x1C, 0x1E, 0x1F, 0xCC, 0x66, 0x33,
  0x39, 0xF1, 0xCC, 0xC6, 0x63, 0x3F, 0xBF, 0x80, 0x0F, 0x1F, 0xDC, 0x4C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x7F, 0x1F, 0x80, 0x1E, 0x0F, 0xE3,
  0x18, 0xC7, 0x31, 0xCC, 0x77, 0x19, 0x86, 0x63, 0x9F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x8C, 0x06, 0x03, 0xF1, 0xF1, 0xC0, 0xC0, 0x60, 0x3F, 0x3F, 0x00,
  0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x01, 0xF1, 0xF8, 0xC0, 0x60, 0x30, 0x38,
  0x00, 0x0F, 0x1F, 0xDC, 0x2C, 0x0E, 0x06, 0x7F, 0x3D, 0x86, 0xE3, 0x3F,
  0x8F, 0x80, 0x18, 0xE7, 0x18, 0xC3, 0x18, 0x63, 0xFC, 0x7F, 0x1C, 0x63,
  0x0C, 0x61, 0x8C, 0x73, 0x8C, 0x00, 0x3E, 0x78, 0x61, 0xC3, 0x06, 0x0C,
  0x18, 0x71, 0xF3, 0xC0, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x18,
  0x30, 0x61, 0xCF, 0x1C, 0x00, 0x18, 0xE7, 0x38, 0xCE, 0x1B, 0x83, 0xE0,
  0x78, 0x1F, 0x83, 0x30, 0x66, 0x0C, 0xE3, 0x8C, 0x00, 0x18, 0x70, 0xC1,
  0x83, 0x06, 0x1C, 0x30, 0x60, 0xFF, 0xF0, 0x1C, 0x39, 0xE1, 0xCF, 0x1E,
  0x78, 0xB3, 0xCF, 0x1E, 0x59, 0xB6, 0xCD, 0xA6, 0x6F, 0x73, 0x73, 0x39,
  0x98, 0x18, 0x67, 0x8C, 0xF1, 0x9E, 0x33, 0xEE, 0x6D, 0x99, 0xB3, 0x3E,
  0x63, 0xCC, 0x7B, 0x8E, 0x00, 0x0E, 0x0F, 0xE7, 0x19, 0x86, 0xE1, 0xF0,
  0x6C, 0x1B, 0x0E, 0xE3, 0x1F, 0xC7, 0xE0, 0x1E, 0x1F, 0xCC, 0x66, 0x33,
  0x19, 0xFD, 0xFC, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x0E, 0x0F, 0xE7, 0x19,
  0x86, 0xE1, 0xF0, 0x6C, 0x1B, 0x0E, 0xE3, 0x1F, 0xC7, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x1E, 0x1F, 0x8C, 0xE6, 0x33, 0x39, 0xF9, 0xF8, 0xCC, 0x66,
  0x33, 0xB8, 0xC0, 0x1E, 0x3F, 0x31, 0x30, 0x38, 0x3C, 0x0E, 0x06, 0x86,
  0xFE, 0xFC, 0x7F, 0xFF, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x31, 0xDC, 0x66, 0x19, 0x86, 0x63, 0xB8, 0xCE, 0x33, 0x0C, 0xC7,
  0x3F, 0x87, 0xC0, 0xE1, 0xF1, 0xD8, 0xCC, 0xE6, 0x63, 0x71, 0xB0, 0xF8,
  0x78, 0x38, 0x1C, 0x00, 0xC3, 0x1F, 0x0C, 0x6C, 0x71, 0xB1, 0xCC, 0xCF,
  0x31, 0x3D, 0xC7, 0xB6, 0x16, 0xD8, 0x53, 0xC1, 0xC7, 0x06, 0x18, 0x00,
  0x18, 0x63, 0x18, 0x77, 0x07, 0xC0, 0xF0, 0x1C, 0x07, 0xC0, 0xD8, 0x33,
  0x0E, 0x73, 0x86, 0x00, 0xE3, 0xB1, 0x99, 0x8D, 0xC7, 0xC1, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x1C, 0x00, 0x3F, 0x9F, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0,
  0xE0, 0xE0, 0x60, 0x7F, 0x3F, 0x80, 0x3C, 0xF3, 0x0C, 0x31, 0x86, 0x18,
  0x61, 0x0C, 0x34, 0xE0, 0xDB, 0x6D, 0x93, 0x6D, 0x80, 0x1C, 0xF0, 0xC3,
  0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0xF0, 0x04, 0x0C, 0x1E, 0x16, 0x32,
  0x62, 0xC3, 0xFC, 0xE4, 0x7B, 0x7E, 0xE6, 0xC6, 0xC6, 0xCC, 0xFC, 0xFC,
  0x38, 0x30, 0x30, 0x3F, 0x3F, 0x73, 0x63, 0x63, 0x67, 0x7E, 0xDC, 0x3D,
  0xDE, 0x30, 0xC3, 0x0F, 0x9E, 0x03, 0x03, 0x03, 0x7F, 0x6E, 0xE6, 0xC6,
  0xC6, 0xCC, 0xFC, 0xFC, 0x3C, 0xCF, 0x1F, 0xEF, 0x98, 0x3F, 0x3E, 0x07,
  0x83, 0x03, 0x83, 0xE0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x87, 0x81, 0x80, 0x3D, 0x9F, 0x9C, 0xCC, 0x66, 0x33, 0x31, 0xF8,
  0xEC, 0x06, 0x46, 0x3F, 0x06, 0x00, 0x38, 0x30, 0x30, 0x3F, 0x3B, 0x73,
  0x73, 0x63, 0x67, 0x66, 0xE6, 0x38, 0x80, 0x63, 0x39, 0x8C, 0x63, 0x38,
  0x0E, 0x08, 0x00, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x1E,
  0x30, 0x00, 0x38, 0x18, 0x0C, 0x06, 0x73, 0x73, 0xF1, 0xF0, 0xF8, 0x6E,
  0x33, 0x39, 0xC0, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x63, 0x38, 0x3F, 0x71,
  0xDF, 0xDC, 0xE6, 0xC6, 0x76, 0x33, 0x33, 0x99, 0x98, 0xDC, 0xCE, 0x3F,
  0x3B, 0x73, 0x73, 0x63, 0x67, 0x66, 0xE6, 0x7C, 0xFF, 0x1E, 0x3C, 0x79,
  0xFF, 0x3C, 0x1F, 0x8F, 0xCE, 0x66, 0x33, 0x19, 0x9C, 0xFC, 0xDC, 0x60,
  0x30, 0x18, 0x1C, 0x00, 0x7B, 0x6E, 0xE6, 0xC6, 0xC6, 0xCC, 0xFC, 0xEC,
  0x0C, 0x1C, 0x18, 0x18, 0x3E, 0x7D, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0x3E,
  0xC9, 0xC3, 0xC1, 0xC1, 0xBF, 0x7C, 0x31, 0x3E, 0xC6, 0x73, 0x18, 0xF7,
  0x80, 0x67, 0x66, 0xE6, 0xC6, 0xC6, 0xCE, 0xF4, 0xFC, 0xC7, 0xCE, 0xCC,
  0xDC, 0xD8, 0xF0, 0x70, 0x60, 0xCE, 0x7C, 0xE6, 0xDE, 0xCD, 0xEC, 0xF7,
  0x8F, 0x78, 0xE7, 0x0E, 0x70, 0x39, 0xC6, 0xC1, 0xF0, 0x38, 0x1E, 0x0F,
  0x87, 0x63, 0x8C, 0x31, 0xCC, 0xE3, 0x30, 0xDC, 0x36, 0x05, 0x81, 0xC0,
  0x60, 0x18, 0x0C, 0x0F, 0x03, 0x00, 0x3E, 0xFC, 0x70, 0xC3, 0x0C, 0x3F,
  0x7E, 0x0C, 0x71, 0x8C, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70, 0xFF,
  0xFF, 0xFF, 0xF0, 0x10, 0xE1, 0x86, 0x18, 0x60, 0xC7, 0x30, 0xC3, 0x18,
  0xE0, 0x43, 0xFE, 0x78,
};

const GFXglyph NotoSans_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 6, 4, 7, 1, -11 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 8, 12, 8, 0, -11 },
  { 37, 11, 11, 13, 1, -11 },
  { 53, 10, 11, 11, 0, -11 },
  { 67, 3, 4, 4, 1, -11 },
  { 69, 5, 13, 5, 1, -11 },
  { 78, 6, 13, 5, -1, -11 },
  { 88, 7, 7, 8, 1, -11 },
  { 95, 7, 7, 9, 1, -9 },
  { 102, 4, 4, 4, -1, -2 },
  { 104, 5, 2, 5, 0, -5 },
  { 106, 3, 2, 4, 0, -2 },
  { 107, 8, 11, 6, -1, -11 },
  { 118, 8, 11, 8, 0, -11 },
  { 129, 6, 11, 8, 1, -11 },
  { 138, 8, 11, 8, 0, -11 },
  { 149, 8, 11, 8, 0, -11 },
  { 160, 8, 11, 8, 0, -11 },
  { 171, 8, 11, 8, 0, -11 },
  { 182, 7, 11, 8, 1, -11 },
  { 192, 8, 11, 8, 1, -11 },
  { 203, 8, 11, 8, 0, -11 },
  { 214, 7, 11, 8, 1, -11 },
  { 224, 4, 8, 4, 0, -8 },
  { 228, 5, 10, 4, -1, -8 },
  { 235, 7, 8, 9, 1, -9 },
  { 242, 7, 5, 9, 1, -8 },
  { 247, 7, 8, 9, 1, -9 },
  { 254, 6, 11, 7, 1, -11 },
  { 263, 12, 12, 13, 1, -11 },
  { 281, 10, 11, 9, -1, -11 },
  { 295, 9, 11, 9, 0, -11 },
  { 308, 9, 11, 9, 1, -11 },
  { 321, 10, 11, 10, 0, -11 },
  { 335, 9, 11, 8, 0, -11 },
  { 348, 9, 11, 8, 0, -11 },
  { 361, 9, 11, 10, 1, -11 },
  { 374, 11, 11, 11, 0, -11 },
  { 390, 7, 11, 6, 0, -11 },
  { 400, 7, 14, 5, -2, -11 },
  { 413, 11, 11, 9, 0, -11 },
  { 429, 7, 11, 8, 0, -11 },
  { 439, 13, 11, 13, 0, -11 },
  { 457, 11, 11, 11, 0, -11 },
  { 473, 10, 11, 11, 1, -11 },
  { 487, 9, 11, 9, 0, -11 },
  { 500, 10, 14, 11, 1, -11 },
  { 518, 9, 11, 9, 0, -11 },
  { 531, 8, 11, 8, 0, -11 },
  { 542, 8, 11, 8, 1, -11 },
  { 553, 10, 11, 10, 1, -11 },
  { 567, 9, 11, 9, 1, -11 },
  { 580, 14, 11, 13, 1, -11 },
  { 600, 11, 11, 9, -1, -11 },
  { 616, 9, 11, 8, 1, -11 },
  { 629, 9, 11, 8, 0, -11 },
  { 642, 6, 13, 5, 0, -11 },
  { 652, 3, 11, 6, 2, -11 },
  { 657, 6, 13, 5, -1, -11 },
  { 667, 8, 7, 8, 0, -11 },
  { 674, 6, 1, 6, -1, 1 },
  { 675, 3, 2, 5, 2, -11 },
  { 676, 8, 8, 9, 1, -8 },
  { 684, 8, 11, 9, 0, -11 },
  { 695, 6, 8, 7, 1, -8 },
  { 701, 8, 11, 9, 1, -11 },
  { 712, 7, 8, 8, 1, -8 },
  { 719, 9, 15, 6, -2, -11 },
  { 736, 9, 12, 9, 0, -8 },
  { 750, 8, 11, 9, 0, -11 },
  { 761, 5, 11, 4, 0, -11 },
  { 768, 7, 15, 4, -2, -11 },
  { 782, 9, 11, 9, 0, -11 },
  { 795, 5, 11, 4, 0, -11 },
  { 802, 13, 8, 14, 0, -8 },
  { 815, 8, 8, 9, 0, -8 },
  { 823, 7, 8, 9, 1, -8 },
  { 830, 9, 12, 9, -1, -8 },
  { 844, 8, 12, 9, 1, -8 },
  { 856, 7, 8, 6, 0, -8 },
  { 863, 7, 8, 7, 0, -8 },
  { 870, 5, 10, 6, 1, -10 },
  { 877, 8, 8, 9, 1, -8 },
  { 885, 8, 8, 8, 1, -8 },
  { 893, 12, 8, 12, 1, -8 },
  { 905, 10, 8, 8, -1, -8 },
  { 915, 10, 12, 8, -1, -8 },
  { 930, 7, 8, 7, 0, -8 },
  { 937, 6, 13, 5, 0, -11 },
  { 947, 2, 14, 8, 3, -11 },
  { 951, 6, 13, 5, -1, -11 },
  { 961, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_BOLDITALIC15PT7B_H_
