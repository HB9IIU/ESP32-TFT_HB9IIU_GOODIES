#ifndef _NOTOSANS_BOLDITALIC28PT7B_H_
#define _NOTOSANS_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0x7C, 0x3E, 0x0F, 0x00,
  0x7B, 0xFC, 0xFF, 0x3B, 0xCE, 0xE3, 0xB9, 0xCE, 0x70, 0x01, 0xCF, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x38, 0xE1, 0xFF, 0xFE,
  0xFF, 0xFF, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x0F, 0xFF,
  0xF7, 0xFF, 0xF8, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0x38, 0x00, 0x00, 0x60, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F,
  0xFC, 0xFB, 0x63, 0xD8, 0x0F, 0x60, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0D, 0xE0, 0x37, 0xA1, 0x9E, 0xF7, 0xFB, 0xFF, 0xCF,
  0xFE, 0x0F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0xE1,
  0xFC, 0x0E, 0x1F, 0xE0, 0xE1, 0xE7, 0x0F, 0x0F, 0x38, 0x70, 0x71, 0xC7,
  0x03, 0x8E, 0x70, 0x1C, 0xF7, 0x80, 0xE7, 0x3B, 0xF7, 0xFB, 0xBF, 0xBF,
  0xB9, 0xFE, 0xFB, 0xDE, 0x70, 0x1C, 0xE3, 0x81, 0xC7, 0x3C, 0x1E, 0x79,
  0xE1, 0xE3, 0xCE, 0x0E, 0x1E, 0x70, 0xE0, 0xFF, 0x8F, 0x03, 0xF8, 0xF0,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x7C, 0xFF, 0x0F, 0x3F, 0xF3, 0xEF, 0x9F, 0x79, 0xE1, 0xFE, 0x3C,
  0x3F, 0xC7, 0x83, 0xF0, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xE7, 0xC0, 0x7F, 0xBD, 0xEE, 0x73, 0x80, 0x03, 0xC0, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0x01, 0xC0,
  0x0F, 0x04, 0x38, 0x1C, 0xE0, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF,
  0x1F, 0x80, 0xF7, 0x07, 0x9C, 0x04, 0x78, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0xF7,
  0x9E, 0x73, 0xCE, 0x00, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x9F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83,
  0xDE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1,
  0xEF, 0x0F, 0xBC, 0x3C, 0xF9, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x01,
  0xF0, 0x3E, 0x0F, 0xE1, 0xFE, 0xFF, 0xE7, 0xFC, 0x33, 0xC2, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F,
  0x1F, 0x06, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x07, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF8, 0x71, 0xF0, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3E,
  0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0xC0, 0xF9, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xEF,
  0x03, 0x9E, 0x0F, 0x78, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0x1F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x40, 0x3C, 0xE1, 0xF9, 0xFF, 0xE3, 0xFF,
  0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFC, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xFB, 0xE7,
  0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0x78, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0xE1, 0xFF, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xE3, 0xC7, 0x9E, 0x0F,
  0xF0, 0x3F, 0x03, 0xFE, 0x1F, 0x7C, 0xF8, 0xFB, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xE3,
  0xFF, 0x8F, 0x1F, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x7D,
  0xF7, 0xF7, 0xFF, 0x8F, 0xFE, 0x1E, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x87, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x04, 0x1E, 0x1F, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x01,
  0x01, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0,
  0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x7F,
  0xE7, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C,
  0x03, 0xC1, 0xE0, 0x03, 0xC7, 0x81, 0x83, 0x8E, 0x1F, 0xE7, 0x3C, 0x7F,
  0xC7, 0x71, 0xE3, 0x8E, 0xE7, 0x8E, 0x1F, 0xCE, 0x1C, 0x7F, 0x1C, 0x38,
  0xEE, 0x38, 0xF1, 0xDC, 0x71, 0xC7, 0xB8, 0xF7, 0xDE, 0x79, 0xFF, 0xF8,
  0x71, 0xF3, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x18, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x1E,
  0x78, 0x07, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x0E, 0x3C, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1E, 0x7F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1E, 0x3F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFE,
  0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x8E, 0x3E, 0x02, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x38, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0,
  0xF8, 0xF0, 0x7C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xF7, 0xC0, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF1, 0xE3, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x7F, 0xBC, 0x3F,
  0xDE, 0x1F, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF0, 0x7C, 0xFC,
  0x3C, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x03, 0xE1, 0xE0,
  0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81,
  0xE1, 0xF0, 0x3C, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x1E,
  0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x03,
  0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x0F,
  0x81, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0xBE, 0x01, 0xF7, 0x80, 0x3D, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xDF, 0x00, 0xF1, 0xE0,
  0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1D, 0xC1, 0xFE, 0x1D, 0xC1, 0xDC, 0x3D, 0xC3, 0xFC, 0x3D, 0xC3, 0xBC,
  0x3D, 0xC7, 0xBC, 0x39, 0xC7, 0x3C, 0x39, 0xCF, 0x78, 0x79, 0xCE, 0x78,
  0x79, 0xDE, 0x78, 0x79, 0xDC, 0x78, 0x71, 0xFC, 0x78, 0xF1, 0xF8, 0xF0,
  0xF1, 0xF8, 0xF0, 0xF1, 0xF0, 0xF0, 0xF1, 0xF0, 0xF0, 0x0F, 0x80, 0xF0,
  0xF8, 0x0F, 0x1F, 0xC0, 0xF1, 0xFC, 0x0F, 0x1F, 0xC0, 0xE1, 0xDE, 0x1E,
  0x1D, 0xE1, 0xE3, 0xDE, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x3C, 0x3C, 0xF3,
  0xC7, 0x87, 0xBC, 0x78, 0x7B, 0xC7, 0x87, 0xBC, 0x78, 0x3F, 0x87, 0x03,
  0xF8, 0xF0, 0x3F, 0x8F, 0x03, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x03,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0x7E, 0x3E, 0x0F, 0x9F, 0x01,
  0xE7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xE0, 0xFC, 0xFE,
  0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x7F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F,
  0x3C, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0x7E, 0x3E, 0x0F, 0x9F,
  0x01, 0xE7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xE0, 0xFC,
  0xFE, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1E, 0x3E, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E,
  0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x7C, 0xF0, 0x78,
  0xF0, 0x78, 0xF8, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x7C, 0xF0, 0x3C, 0xF0,
  0x3E, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xC6, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x20, 0x7C, 0xE3, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C,
  0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0xC7, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3,
  0xC1, 0xF0, 0xFC, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0x73, 0xC0, 0x73,
  0xC0, 0x77, 0x80, 0x77, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xE0, 0x3C, 0x0F, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x07,
  0xDC, 0x0F, 0x83, 0xCE, 0x0F, 0xC1, 0xE7, 0x07, 0xE1, 0xE3, 0x87, 0xF0,
  0xF1, 0xC3, 0xB8, 0xF0, 0xF3, 0xDC, 0x78, 0x79, 0xCE, 0x78, 0x3D, 0xE7,
  0x3C, 0x1E, 0xF3, 0x9E, 0x0F, 0x71, 0xDE, 0x07, 0x78, 0xEF, 0x03, 0xB8,
  0x77, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x1E, 0x0F, 0x80,
  0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x7C, 0x01, 0xE3, 0xE0,
  0x1F, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x03, 0xE1, 0xF8, 0x0F, 0x00, 0xF0,
  0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xC7, 0xC7, 0x8F, 0x0F, 0x3E, 0x1E, 0x78,
  0x1D, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x90, 0x7E, 0x0F, 0xE0, 0xF1, 0xE3, 0xC3, 0x87,
  0x0E, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38,
  0x70, 0xF0, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x7E,
  0x0F, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0xF7, 0x01, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x38, 0xE0, 0x73, 0xC0,
  0xEF, 0x00, 0xE0, 0xFF, 0xF0, 0xF9, 0xE3, 0x87, 0x01, 0x00, 0x1F, 0x9C,
  0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8,
  0x3D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x9F, 0x8F, 0xFE, 0x1F, 0xDC,
  0x1F, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE6, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x3C, 0x78, 0x78, 0xF0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x7C, 0x3C, 0xFC, 0xF9,
  0xFF, 0xE3, 0xBF, 0x8F, 0x3E, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0xFC, 0x7F,
  0xE3, 0xE1, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x86, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x01, 0x1E, 0x0F, 0xDE, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3E, 0x70, 0x00, 0x80, 0x1F, 0xC1, 0xFF, 0x8F, 0xDF, 0x3C, 0x3D, 0xF0,
  0xF7, 0x87, 0x9F, 0xFE, 0xFF, 0xF3, 0xFE, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x31, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x07, 0xE7, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1F, 0x3E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E,
  0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x80, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE2, 0x03, 0xDF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x3C, 0x78,
  0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x7C, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x87, 0x80, 0x07, 0x87, 0xC3, 0xE0,
  0xE0, 0x00, 0x00, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x3E, 0x3C, 0x3E, 0x1E,
  0x3E, 0x0F, 0x3E, 0x07, 0xBE, 0x03, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x7C, 0xF0, 0x3C, 0x7C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x8F, 0x83, 0xC0, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x80, 0x00, 0x10, 0x08, 0x0E, 0xFC, 0x7E, 0x1F, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFF, 0x1F, 0x1F, 0x8F, 0x1E, 0x1F, 0x0F, 0x1E, 0x1F, 0x0F,
  0x3E, 0x1E, 0x1F, 0x3C, 0x1E, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x3C, 0x1E,
  0x7C, 0x3C, 0x1E, 0x78, 0x3C, 0x3E, 0x78, 0x3C, 0x3C, 0x78, 0x7C, 0x3C,
  0xF8, 0x78, 0x3C, 0x00, 0x10, 0x1D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF1,
  0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xFB,
  0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x3C, 0x01, 0x80, 0x3F,
  0xC1, 0xFF, 0x8F, 0xFF, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x1E, 0xF8, 0xF9, 0xFF, 0xC3, 0xFE, 0x07,
  0xF0, 0x00, 0x18, 0x07, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x8F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E,
  0x1E, 0x3F, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF0, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0x00, 0x1F, 0x9C, 0x7F, 0xF9, 0xFF, 0xF3, 0xC7, 0xCF, 0x87, 0x9E, 0x0F,
  0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F,
  0xFE, 0x1F, 0xFC, 0x1F, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x77, 0xC7, 0xBC,
  0x3F, 0xE1, 0xFD, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0x00, 0x7F,
  0xC7, 0xFC, 0x7F, 0xE3, 0xC1, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0x78, 0x03, 0xCC, 0x1E, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x07,
  0x00, 0xE0, 0x38, 0x0F, 0x07, 0xFE, 0xFF, 0xFF, 0xF1, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC4, 0x7F, 0x0F, 0xE0,
  0xFC, 0x00, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x1F, 0x78, 0x7B, 0xC1,
  0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF, 0x1F, 0x3C, 0xFC, 0xFF,
  0xF3, 0xFB, 0xC7, 0xCE, 0x00, 0xF8, 0x3E, 0xF0, 0x79, 0xE1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0x77, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0xF8,
  0x7F, 0x8F, 0xC7, 0xFC, 0x7E, 0x3D, 0xE3, 0xF1, 0xEF, 0x3B, 0x9E, 0x79,
  0xDC, 0xF3, 0xDC, 0xEF, 0x1E, 0xE7, 0x78, 0xFF, 0x3B, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x80, 0xF7, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xE3, 0xE0, 0xF0, 0x1F, 0x07,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xF1, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0,
  0x3C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x83, 0xC0, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0x7E,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E,
};

const GFXglyph NotoSans_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 20, 8, 0, -20 },
  { 24, 10, 7, 13, 3, -20 },
  { 33, 17, 20, 18, 1, -20 },
  { 76, 14, 23, 15, 1, -21 },
  { 117, 21, 20, 24, 2, -20 },
  { 170, 19, 20, 20, 1, -20 },
  { 218, 5, 7, 7, 3, -20 },
  { 223, 10, 24, 9, 1, -20 },
  { 253, 11, 24, 10, -2, -20 },
  { 286, 14, 13, 15, 2, -21 },
  { 309, 14, 14, 16, 1, -17 },
  { 334, 6, 7, 8, -1, -3 },
  { 340, 8, 3, 9, 0, -9 },
  { 343, 5, 4, 8, 0, -4 },
  { 346, 15, 20, 12, -1, -20 },
  { 384, 14, 20, 15, 1, -20 },
  { 419, 12, 20, 15, 2, -20 },
  { 449, 16, 20, 15, -1, -20 },
  { 489, 15, 20, 15, 0, -20 },
  { 527, 15, 20, 15, 0, -20 },
  { 565, 15, 20, 15, 0, -20 },
  { 603, 15, 20, 15, 1, -20 },
  { 641, 16, 20, 15, 1, -20 },
  { 681, 14, 20, 15, 1, -20 },
  { 716, 14, 20, 15, 1, -20 },
  { 751, 8, 16, 8, 0, -16 },
  { 767, 10, 20, 8, -2, -16 },
  { 792, 14, 15, 16, 1, -18 },
  { 819, 14, 8, 16, 1, -14 },
  { 833, 14, 15, 16, 1, -18 },
  { 860, 12, 20, 13, 2, -20 },
  { 890, 23, 23, 24, 1, -20 },
  { 957, 18, 20, 18, -2, -20 },
  { 1002, 16, 20, 17, 1, -20 },
  { 1042, 16, 20, 17, 2, -20 },
  { 1082, 17, 20, 19, 1, -20 },
  { 1125, 15, 20, 15, 1, -20 },
  { 1163, 15, 20, 15, 1, -20 },
  { 1201, 17, 20, 19, 2, -20 },
  { 1244, 19, 20, 20, 1, -20 },
  { 1292, 13, 20, 11, -1, -20 },
  { 1325, 14, 26, 9, -4, -20 },
  { 1371, 19, 20, 17, 1, -20 },
  { 1419, 12, 20, 15, 1, -20 },
  { 1449, 24, 20, 25, 1, -20 },
  { 1509, 20, 20, 21, 1, -20 },
  { 1559, 18, 20, 20, 2, -20 },
  { 1604, 16, 20, 17, 1, -20 },
  { 1644, 18, 25, 20, 2, -20 },
  { 1701, 16, 20, 17, 1, -20 },
  { 1741, 14, 20, 15, 1, -20 },
  { 1776, 15, 20, 15, 2, -20 },
  { 1814, 18, 20, 19, 2, -20 },
  { 1859, 16, 20, 17, 3, -20 },
  { 1899, 25, 20, 25, 3, -20 },
  { 1962, 21, 20, 17, -2, -20 },
  { 2015, 15, 20, 16, 3, -20 },
  { 2053, 17, 20, 15, -1, -20 },
  { 2096, 12, 24, 9, -1, -20 },
  { 2132, 7, 20, 12, 3, -20 },
  { 2150, 12, 24, 9, -2, -20 },
  { 2186, 15, 13, 15, 0, -20 },
  { 2211, 12, 1, 11, -3, 3 },
  { 2213, 6, 4, 9, 4, -21 },
  { 2216, 15, 16, 17, 1, -16 },
  { 2246, 15, 21, 17, 0, -21 },
  { 2286, 13, 16, 14, 1, -16 },
  { 2312, 16, 21, 17, 1, -21 },
  { 2354, 14, 16, 16, 1, -16 },
  { 2382, 17, 28, 10, -3, -21 },
  { 2442, 16, 23, 17, 0, -16 },
  { 2488, 15, 21, 17, 0, -21 },
  { 2528, 9, 21, 8, 0, -21 },
  { 2552, 13, 28, 8, -4, -21 },
  { 2598, 17, 21, 16, 0, -21 },
  { 2643, 9, 21, 8, 0, -21 },
  { 2667, 24, 16, 25, 0, -16 },
  { 2715, 15, 16, 17, 0, -16 },
  { 2745, 14, 16, 16, 1, -16 },
  { 2773, 16, 23, 17, -1, -16 },
  { 2819, 15, 23, 17, 1, -16 },
  { 2863, 13, 16, 12, 0, -16 },
  { 2889, 13, 16, 13, 0, -16 },
  { 2915, 11, 19, 11, 1, -19 },
  { 2942, 14, 15, 17, 2, -15 },
  { 2969, 15, 15, 14, 1, -15 },
  { 2998, 21, 15, 22, 2, -15 },
  { 3038, 17, 15, 15, -1, -15 },
  { 3070, 18, 22, 15, -2, -15 },
  { 3120, 14, 15, 13, -1, -15 },
  { 3147, 12, 24, 10, 0, -20 },
  { 3183, 3, 27, 15, 6, -21 },
  { 3194, 11, 24, 10, -1, -20 },
  { 3227, 14, 4, 16, 1, -12 },
};

const GFXfont NotoSans_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_BOLDITALIC28PT7B_H_
