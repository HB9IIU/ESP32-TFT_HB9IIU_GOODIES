#ifndef _NOTOSANS_BOLDITALIC25PT7B_H_
#define _NOTOSANS_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x78, 0xF8, 0xF0, 0x7B, 0xDC, 0xE7, 0x39, 0xCE,
  0x63, 0x18, 0xCE, 0x70, 0x01, 0xCE, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x9C,
  0x03, 0x1C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x30, 0x0E, 0x70,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x9C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0,
  0x39, 0xC0, 0x39, 0xC0, 0x00, 0x80, 0x0C, 0x01, 0xFC, 0x3F, 0xF3, 0xFF,
  0x1C, 0x88, 0xEC, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x6F, 0x03, 0x7A, 0x17, 0x9F, 0xFC, 0xFF, 0xC3, 0xF8, 0x03, 0x00, 0x30,
  0x00, 0x1F, 0x01, 0xC3, 0xF8, 0x38, 0x7F, 0x87, 0x07, 0x38, 0x70, 0x73,
  0x8E, 0x07, 0x39, 0xC0, 0xE3, 0xB8, 0x0E, 0x73, 0xBC, 0x7F, 0x77, 0xE7,
  0xEE, 0xFE, 0x3D, 0xCE, 0xF0, 0x1D, 0xCE, 0x03, 0x9C, 0xE0, 0x71, 0xCE,
  0x0E, 0x1C, 0xE0, 0xE1, 0xDC, 0x1C, 0x1F, 0xC3, 0x80, 0xF8, 0x03, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x0F, 0xE0, 0x1F, 0x87, 0x3F, 0x8F, 0x7B, 0xCE, 0xF3, 0xDE, 0xF1, 0xFC,
  0xF0, 0xFC, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x9E, 0x7B, 0x9C,
  0xE6, 0x33, 0x80, 0x03, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x47,
  0x07, 0x70, 0xFF, 0x13, 0xFF, 0x0F, 0xF1, 0xF0, 0x3B, 0x87, 0x38, 0x33,
  0xC0, 0x10, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3C, 0xE7, 0x9C, 0x73,
  0x80, 0x7F, 0x7E, 0xFE, 0x77, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x79, 0xE7, 0x87, 0x3C, 0x3D, 0xC1,
  0xFE, 0x0E, 0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xF3,
  0xCF, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x01, 0xC1, 0xF1, 0xFC, 0xFE,
  0xFF, 0x9D, 0xE2, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xC3,
  0x8F, 0x04, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0xFE, 0x7F, 0xF3,
  0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xC7, 0xFE, 0x10, 0xF0, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x00,
  0x7A, 0x03, 0xDF, 0xFC, 0xFF, 0xE3, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3D, 0xC1, 0xDE, 0x1C, 0xF1, 0xC7,
  0x9C, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC8, 0x1F, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0xC3, 0xFE, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE4, 0x0E, 0xFC, 0x7F,
  0xE7, 0xEF, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x73, 0xC7, 0x8F, 0xFC,
  0x7F, 0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x78, 0xF3, 0x87, 0x9E, 0x3C, 0xF3, 0xC3,
  0xFC, 0x0F, 0x81, 0xFE, 0x1E, 0x79, 0xE1, 0xCE, 0x0F, 0x70, 0x7B, 0xC3,
  0x9F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F,
  0x78, 0x77, 0x07, 0xF0, 0xF7, 0x0F, 0x79, 0xF7, 0xFF, 0x3F, 0xF1, 0xCE,
  0x01, 0xE0, 0x1E, 0x03, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x1C, 0x3C, 0xF8,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x9E, 0x00, 0x0E, 0x0F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78,
  0x70, 0xF0, 0xE0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x07, 0xF1, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x3F, 0xF7,
  0xFD, 0x8F, 0x01, 0xC0, 0xF0, 0x7C, 0x3E, 0x1E, 0x0F, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x06, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x0F, 0xEF, 0xC1, 0xE0, 0x0E, 0x3C, 0x00, 0x73, 0x87, 0xE7, 0x71,
  0xFE, 0x77, 0x3C, 0xE7, 0x63, 0x8E, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x7E,
  0x71, 0xC6, 0xE7, 0x3C, 0xEE, 0x7F, 0xFC, 0xE3, 0xEF, 0x87, 0x08, 0x20,
  0x78, 0x00, 0x03, 0xC0, 0x40, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xEE, 0x01, 0xCE,
  0x03, 0xCE, 0x07, 0x8E, 0x07, 0x8E, 0x0F, 0x0E, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x07, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xC7, 0x1F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0xFE,
  0x3F, 0xE1, 0xFF, 0xC7, 0x8F, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xEF, 0x0F,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0xF8, 0x63, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x04, 0x3F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF3, 0xE3,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xF7, 0x83, 0xCE, 0x0F, 0xBC, 0x7E, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFE, 0x3F, 0xE3, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x06, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFE, 0x70, 0xFE, 0xF0, 0xFE,
  0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x3C, 0x7C, 0x3C, 0x7F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF0, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0,
  0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E,
  0x07, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70,
  0xF0, 0x78, 0x78, 0x3C, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x1E, 0x0F,
  0x8F, 0x0F, 0x07, 0x8F, 0x83, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF7,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x07,
  0x9E, 0x03, 0x8F, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x3C,
  0x00, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8,
  0x3F, 0x1F, 0xC3, 0xB8, 0xEE, 0x1F, 0xC7, 0x71, 0xDE, 0x3B, 0x8E, 0xE3,
  0xDC, 0xE7, 0x1E, 0xE7, 0x78, 0xE7, 0x73, 0xC7, 0x3B, 0x9E, 0x39, 0xF8,
  0xE3, 0xCF, 0xC7, 0x1E, 0x7C, 0x78, 0xE3, 0xE3, 0xC7, 0x0E, 0x1C, 0x00,
  0x1F, 0x01, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7E, 0x0E, 0x3F, 0x83, 0x8E,
  0xE1, 0xE3, 0xBC, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x1E, 0x79, 0xC7, 0x8E,
  0xF1, 0xC3, 0xBC, 0x70, 0xFE, 0x1C, 0x1F, 0x8F, 0x07, 0xE3, 0xC1, 0xF8,
  0xE0, 0x7E, 0x38, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F,
  0x38, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xF1, 0xF1,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC7, 0x1F, 0x3C, 0x3C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x39, 0xFD,
  0xFF, 0xE7, 0xFF, 0x1F, 0xC0, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xE3,
  0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x38,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xF1, 0xF1, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1E, 0x70,
  0x79, 0xE1, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xE0, 0x03,
  0xF0, 0x3F, 0xF1, 0xFF, 0x87, 0x84, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x8C,
  0x1E, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F,
  0x80, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8E, 0x0E,
  0x1C, 0x3C, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x38, 0x1F, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF7, 0x87, 0xC1, 0xCF, 0x0F,
  0x87, 0x9E, 0x3F, 0x0E, 0x3C, 0x7E, 0x3C, 0x79, 0xFC, 0x70, 0x73, 0xB9,
  0xE0, 0xE7, 0x73, 0xC1, 0xDC, 0xE7, 0x03, 0xB9, 0xDE, 0x07, 0xE3, 0xB8,
  0x0F, 0xC7, 0x70, 0x1F, 0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0xF0, 0x1E, 0x3C,
  0x07, 0x9E, 0x00, 0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xC3,
  0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0x3D, 0xC1, 0xF7,
  0x87, 0x9E, 0x3C, 0x79, 0xE0, 0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0x80,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0, 0xF8, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0xF0, 0xFC, 0x3E, 0x00, 0xE3, 0x8E, 0x38, 0xE1,
  0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x38, 0xE3, 0x8E, 0x38, 0xF0, 0x07, 0xE0,
  0xF8, 0x3F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0,
  0x7E, 0x07, 0x30, 0x39, 0xC3, 0x8E, 0x38, 0x31, 0xC1, 0xDC, 0x0F, 0xE0,
  0x70, 0xFF, 0xFF, 0xF0, 0xF3, 0x9C, 0x70, 0x07, 0x38, 0xFD, 0xCF, 0xFE,
  0xF9, 0xF7, 0x87, 0xBC, 0x3B, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x79, 0xFF, 0xC7, 0xEE, 0x1E, 0x70, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x7B, 0xC1, 0xFF, 0x87, 0xFE, 0x1E, 0x7C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x0F, 0x38, 0x3C, 0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0x7F, 0xF1,
  0xFF, 0x8E, 0x7C, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xBE, 0x27, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC1, 0x3F, 0xC7, 0xF8, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xE7, 0x07,
  0xEE, 0x1F, 0xFC, 0x3C, 0xF8, 0xF0, 0xF1, 0xE1, 0xC7, 0x83, 0x8F, 0x0F,
  0x1E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFB, 0x80,
  0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xC7, 0x78, 0x77, 0x0F, 0xFF, 0xEF, 0xFC,
  0xF8, 0x0F, 0x00, 0xF0, 0x27, 0xFC, 0x7F, 0xC3, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xFC,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0x9C, 0x3F, 0x71,
  0xFF, 0xC7, 0x9F, 0x3C, 0x3C, 0xF0, 0xE7, 0x83, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE7, 0x8F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7B, 0xC0, 0x0E, 0x00, 0x78,
  0x81, 0xE3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x79, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0x3C, 0xF8,
  0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78,
  0x71, 0xC1, 0xCF, 0x0F, 0x00, 0x07, 0x0F, 0x0F, 0x06, 0x00, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0x07, 0xE0, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC3, 0xC7, 0x8F,
  0x0F, 0x3C, 0x1C, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x1E, 0x78, 0x3C, 0xF0, 0x78, 0xF0, 0xE1, 0xE3, 0xC3, 0xE0, 0x0F,
  0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x1C, 0xF0, 0xF0, 0xEF, 0xCF, 0xC7,
  0xFE, 0xFE, 0x3E, 0x7C, 0xF3, 0xE3, 0xC3, 0x9E, 0x1E, 0x1C, 0xF0, 0xE1,
  0xE7, 0x8F, 0x0F, 0x38, 0x78, 0x7B, 0xC3, 0xC3, 0x9E, 0x1E, 0x1C, 0xF0,
  0xE1, 0xE7, 0x0F, 0x0F, 0x78, 0x78, 0x78, 0x1C, 0xF0, 0x77, 0xE1, 0xFF,
  0xC7, 0xCF, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x0E, 0x38, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x1C, 0x70, 0x73, 0xC3, 0xC0, 0x07, 0x80, 0xFF, 0x0F,
  0xFC, 0xF9, 0xE7, 0x87, 0x38, 0x3F, 0xC1, 0xDE, 0x0E, 0xF0, 0xF7, 0x87,
  0xBC, 0x78, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x0E, 0x78, 0x1D, 0xF8, 0x3F,
  0xF0, 0x79, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x1C, 0x3C,
  0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0x7C, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x18, 0xFD,
  0xCF, 0xFE, 0x79, 0xF7, 0x87, 0xBC, 0x3B, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7,
  0x87, 0x3C, 0x79, 0xFF, 0xC7, 0xFE, 0x1E, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0xF1, 0xDE, 0x1F, 0xE1, 0xFE,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x9E, 0x23, 0xC0, 0x7C, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x7A, 0x0F, 0x7F, 0xEF, 0xF9, 0xFE, 0x00, 0x0E,
  0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xBF, 0xE3, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x0F, 0xE1, 0xF8, 0x7E, 0x00, 0x3C, 0x3C, 0xF0,
  0xE3, 0x83, 0x8E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x1F, 0x3F, 0xF8, 0x7E, 0xE1, 0xF3, 0x80, 0xF0, 0x7F,
  0x83, 0xDC, 0x3C, 0xE1, 0xE7, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0x70, 0x77,
  0x83, 0xB8, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xE1, 0xE1, 0xFC,
  0x3C, 0x3B, 0x8F, 0x8F, 0x71, 0xF1, 0xCE, 0x7E, 0x79, 0xCF, 0xCF, 0x3B,
  0xBB, 0xC7, 0x77, 0x78, 0xEC, 0xEE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x1E, 0x3E, 0x0F,
  0x3C, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0, 0x78, 0x1E,
  0x0F, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1E, 0x0E, 0x3C, 0x0E, 0x3C, 0x0F,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFC, 0xFF, 0xCF, 0xF8,
  0x01, 0xC0, 0xF0, 0x7C, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x1F,
  0x0F, 0x83, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x03, 0xC1, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0xE0,
  0x7C, 0x1F, 0x0F, 0x87, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x83, 0xE0,
  0xF0, 0x38, 0x00, 0x3C, 0x1F, 0xFB, 0xFF, 0xF8, 0x3F,
};

const GFXglyph NotoSans_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 10, 7, 11, 2, -18 },
  { 28, 16, 18, 16, 0, -18 },
  { 64, 13, 20, 14, 1, -19 },
  { 97, 20, 18, 21, 1, -18 },
  { 142, 16, 18, 18, 1, -18 },
  { 178, 5, 7, 6, 2, -18 },
  { 183, 9, 22, 8, 1, -18 },
  { 208, 10, 22, 9, -2, -18 },
  { 236, 12, 12, 14, 2, -19 },
  { 254, 12, 12, 14, 1, -15 },
  { 272, 6, 6, 7, -1, -3 },
  { 277, 8, 3, 8, 0, -8 },
  { 280, 5, 4, 7, 0, -4 },
  { 283, 13, 18, 11, -1, -18 },
  { 313, 13, 18, 14, 1, -18 },
  { 343, 10, 18, 14, 2, -18 },
  { 366, 14, 18, 14, -1, -18 },
  { 398, 13, 18, 14, 0, -18 },
  { 428, 13, 18, 14, 0, -18 },
  { 458, 14, 18, 14, 0, -18 },
  { 490, 13, 18, 14, 1, -18 },
  { 520, 14, 18, 14, 1, -18 },
  { 552, 13, 18, 14, 1, -18 },
  { 582, 12, 18, 14, 1, -18 },
  { 609, 7, 14, 7, 0, -14 },
  { 622, 8, 17, 7, -1, -14 },
  { 639, 12, 14, 14, 1, -16 },
  { 660, 12, 8, 14, 1, -13 },
  { 672, 12, 14, 14, 1, -16 },
  { 693, 10, 18, 11, 2, -18 },
  { 716, 20, 20, 21, 1, -18 },
  { 766, 16, 18, 16, -2, -18 },
  { 802, 14, 18, 16, 1, -18 },
  { 834, 15, 18, 15, 1, -18 },
  { 868, 15, 18, 17, 1, -18 },
  { 902, 13, 18, 14, 1, -18 },
  { 932, 13, 18, 13, 1, -18 },
  { 962, 16, 18, 17, 1, -18 },
  { 998, 17, 18, 18, 1, -18 },
  { 1037, 12, 18, 10, -1, -18 },
  { 1064, 13, 23, 8, -4, -18 },
  { 1102, 17, 18, 15, 1, -18 },
  { 1141, 10, 18, 13, 1, -18 },
  { 1164, 21, 18, 22, 1, -18 },
  { 1212, 18, 18, 19, 1, -18 },
  { 1253, 17, 18, 18, 1, -18 },
  { 1292, 14, 18, 15, 1, -18 },
  { 1324, 17, 22, 18, 1, -18 },
  { 1371, 14, 18, 16, 1, -18 },
  { 1403, 14, 18, 13, 0, -18 },
  { 1435, 13, 18, 13, 2, -18 },
  { 1465, 16, 18, 17, 2, -18 },
  { 1501, 15, 18, 15, 2, -18 },
  { 1535, 23, 18, 22, 2, -18 },
  { 1587, 18, 18, 15, -1, -18 },
  { 1628, 14, 18, 14, 2, -18 },
  { 1660, 16, 18, 13, -1, -18 },
  { 1696, 10, 22, 8, 0, -18 },
  { 1724, 6, 18, 11, 3, -18 },
  { 1738, 11, 22, 8, -2, -18 },
  { 1769, 13, 12, 14, 0, -18 },
  { 1789, 10, 2, 10, -2, 2 },
  { 1792, 5, 4, 8, 4, -19 },
  { 1795, 13, 14, 15, 1, -14 },
  { 1818, 14, 19, 15, 0, -19 },
  { 1852, 11, 14, 12, 1, -14 },
  { 1872, 15, 19, 15, 1, -19 },
  { 1908, 12, 14, 14, 1, -14 },
  { 1929, 15, 25, 9, -3, -19 },
  { 1976, 14, 20, 15, 0, -14 },
  { 2011, 14, 19, 15, 0, -19 },
  { 2045, 8, 19, 7, 0, -19 },
  { 2064, 11, 25, 7, -3, -19 },
  { 2099, 15, 19, 14, 0, -19 },
  { 2135, 8, 19, 7, 0, -19 },
  { 2154, 21, 14, 23, 0, -14 },
  { 2191, 14, 14, 15, 0, -14 },
  { 2216, 13, 14, 15, 1, -14 },
  { 2239, 15, 20, 15, -1, -14 },
  { 2277, 13, 20, 15, 1, -14 },
  { 2310, 12, 14, 11, 0, -14 },
  { 2331, 11, 14, 12, 0, -14 },
  { 2351, 10, 17, 10, 1, -17 },
  { 2373, 14, 14, 15, 1, -14 },
  { 2398, 13, 14, 13, 1, -14 },
  { 2421, 19, 14, 20, 2, -14 },
  { 2455, 16, 14, 13, -1, -14 },
  { 2483, 16, 20, 13, -2, -14 },
  { 2523, 12, 14, 12, 0, -14 },
  { 2544, 10, 22, 9, 0, -18 },
  { 2572, 2, 25, 14, 6, -19 },
  { 2579, 10, 22, 9, -1, -18 },
  { 2607, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_BOLDITALIC25PT7B_H_
