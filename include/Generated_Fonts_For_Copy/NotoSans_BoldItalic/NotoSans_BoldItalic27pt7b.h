#ifndef _NOTOSANS_BOLDITALIC27PT7B_H_
#define _NOTOSANS_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x1C, 0x00, 0xF3,
  0xFC, 0xEE, 0x3B, 0x9E, 0xE7, 0x39, 0xCC, 0x70, 0x03, 0xCE, 0x01, 0xC6,
  0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0xC3, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFE, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x1C, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF0, 0xE3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x70,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3,
  0xD8, 0x8F, 0x60, 0x3D, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x67, 0xA1, 0x9E, 0xE6, 0xF3, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x23, 0xF0, 0x1C, 0x7F,
  0x03, 0x87, 0x78, 0x70, 0xF3, 0x87, 0x0E, 0x38, 0xE0, 0xE7, 0x9C, 0x0E,
  0x73, 0x80, 0xE7, 0x39, 0xCE, 0xF7, 0x7E, 0xFE, 0xEF, 0xF7, 0xDE, 0xE7,
  0x31, 0xDE, 0x70, 0x39, 0xC7, 0x07, 0x1C, 0x70, 0xF1, 0xCF, 0x0E, 0x1C,
  0xE1, 0xC1, 0xFE, 0x38, 0x1F, 0xC7, 0x80, 0xF8, 0x00, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x3D, 0xFF, 0x1E, 0x79,
  0xE7, 0x3C, 0x7F, 0xCF, 0x0F, 0xE3, 0xC1, 0xF0, 0xF8, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFE, 0x7C, 0xFF, 0xEE, 0xEE, 0xC0, 0x03, 0xC1, 0xE0,
  0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0x02, 0x00, 0x1E, 0x00,
  0xE0, 0xC7, 0x07, 0xB8, 0x7F, 0x9C, 0xFF, 0xE1, 0xFF, 0x1F, 0x89, 0xFC,
  0x1E, 0x70, 0x63, 0x81, 0x1E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0xF7, 0x9E, 0x73, 0x80, 0x7F, 0x7F,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3C, 0x78, 0xF0,
  0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0x7B, 0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xFF, 0x87, 0xFC, 0x0F,
  0xC0, 0x01, 0xE0, 0xFC, 0x7F, 0x9F, 0xEF, 0xFC, 0xF7, 0x88, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x20, 0x07, 0xF8, 0x3F, 0xF8, 0xFF, 0xF0,
  0xE1, 0xE0, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x40, 0x1F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0xC0, 0xF9, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x77, 0x01, 0xFE, 0x07, 0xBC, 0x1E,
  0x78, 0x78, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x60, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x38, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x20, 0x7B, 0xF1,
  0xDF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C,
  0xF9, 0xF1, 0xFF, 0x87, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF2, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF,
  0x87, 0xDF, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x9E, 0x1F, 0xF0, 0x3F,
  0x81, 0xFE, 0x1F, 0xFC, 0x78, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0,
  0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x01, 0x80, 0x7F, 0x07, 0xFC, 0x7F,
  0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFE,
  0x7F, 0xF1, 0xF7, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x83, 0xE7, 0xFE, 0x3F,
  0xE1, 0xFC, 0x00, 0x0E, 0x3C, 0x78, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x9F, 0x3C, 0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xF8,
  0x03, 0x00, 0x00, 0x02, 0x07, 0xFB, 0xFF, 0xBF, 0xF6, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7E, 0x1F, 0x03, 0xC0, 0x1E, 0x1C, 0x00, 0x38, 0xE1, 0xFE, 0xF7,
  0x8F, 0xF1, 0xDC, 0x79, 0xC7, 0x73, 0xC7, 0x1F, 0x8E, 0x1C, 0x7E, 0x38,
  0xE1, 0xF9, 0xC3, 0x8E, 0xE7, 0x0E, 0x3B, 0x8E, 0x79, 0xCE, 0x3F, 0xFE,
  0x1C, 0x79, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x70, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x38, 0x07, 0x9C, 0x07, 0x8E, 0x03, 0xC7,
  0x03, 0xC3, 0x81, 0xE1, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x78,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x1F, 0x1E, 0x1E, 0x3C, 0x1E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF8, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0x60, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x04, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x30, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x3F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x3E, 0x78, 0x7E, 0xFB, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0x02, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0xFE, 0xF0, 0xFE, 0xF0, 0xFE, 0xF1, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF8, 0x3C, 0xFC, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0x03,
  0xC7, 0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3,
  0xC0, 0x78, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xE0,
  0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC7, 0x83, 0xE1, 0xE1, 0xF0,
  0x78, 0xF8, 0x1E, 0x7C, 0x07, 0xBE, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC0,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x7F, 0x8F, 0xF0, 0xEE, 0x1E,
  0xE3, 0xDC, 0x3D, 0xC7, 0x78, 0x73, 0x9E, 0xF1, 0xE7, 0x39, 0xE3, 0xCE,
  0xF3, 0x87, 0x9D, 0xCF, 0x0E, 0x3F, 0x9E, 0x1C, 0x7E, 0x3C, 0x78, 0xFC,
  0x78, 0xF1, 0xF0, 0xE1, 0xE3, 0xE3, 0xC3, 0x87, 0x87, 0x80, 0x0F, 0x80,
  0xF1, 0xF8, 0x0E, 0x1F, 0x81, 0xE1, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1, 0xDC,
  0x1C, 0x3D, 0xE3, 0xC3, 0xDE, 0x3C, 0x3D, 0xE3, 0xC3, 0x8F, 0x3C, 0x78,
  0xF3, 0x87, 0x8F, 0x78, 0x78, 0x7F, 0x87, 0x87, 0xF8, 0x70, 0x7F, 0x0F,
  0x03, 0xF0, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xE0, 0x1F, 0x00, 0x00, 0x60,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x7D, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xF0, 0x7C, 0xFC, 0x7C, 0x3F, 0xFE,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E,
  0x1E, 0x1E, 0x1F, 0x1E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x7E, 0x3F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80,
  0xFB, 0xC0, 0x79, 0xE0, 0x7C, 0xFC, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3,
  0xCF, 0x07, 0x9E, 0x1F, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07,
  0x9F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0,
  0xF0, 0x00, 0x80, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x10, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x20, 0x78, 0xC3, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xF1, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79,
  0xE0, 0x7B, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0x9C,
  0x1F, 0x07, 0x8E, 0x0F, 0x83, 0xC7, 0x07, 0xC1, 0xE3, 0x87, 0xE1, 0xE1,
  0xC3, 0xF0, 0xF0, 0xE3, 0xF8, 0xF0, 0x71, 0xDC, 0x78, 0x39, 0xEF, 0x38,
  0x1C, 0xE7, 0xBC, 0x0E, 0xF3, 0xDC, 0x07, 0x71, 0xFE, 0x03, 0xB8, 0xFF,
  0x01, 0xFC, 0x77, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xF8, 0x1E, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x3E,
  0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x78, 0x3E, 0x78,
  0x7C, 0x78, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0xE3, 0xCF,
  0x1C, 0x71, 0xC7, 0x1E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x1C, 0x71,
  0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x07, 0xE0, 0xFC, 0x3F, 0x80, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xE3, 0x87, 0x8E, 0x1C,
  0x38, 0xE0, 0x63, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0xF3, 0xC7, 0x8E,
  0x1C, 0x07, 0x9E, 0x3F, 0xB8, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x0F,
  0x9E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0xCF, 0x87,
  0xFF, 0x0F, 0xFE, 0x0F, 0xBC, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x9E, 0x0F, 0x7E, 0x1F, 0xFC, 0x3E,
  0x7C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E,
  0x7C, 0x3C, 0xF8, 0xF1, 0xFF, 0xE3, 0xBF, 0x8F, 0x7E, 0x00, 0x07, 0xE0,
  0xFF, 0x3F, 0xF3, 0xE2, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x84, 0x7F, 0xC7, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x9E, 0x1F,
  0xDC, 0x3F, 0xFC, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x38, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF9, 0xF0, 0x7F, 0xF0, 0x7F,
  0x70, 0x3E, 0xF0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0xC7, 0xBC,
  0x3D, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xF0, 0x47, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFA,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xCF,
  0x0F, 0xEE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x7C, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1E, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x81, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x9E, 0x0F, 0x7E, 0x1F, 0xFE, 0x3F, 0x7C, 0x78,
  0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xCF, 0x87, 0x80, 0x02, 0x03, 0xC3, 0xE1,
  0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x80, 0x00, 0x40, 0x0F, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0xBC,
  0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x79,
  0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x0F, 0x0F, 0x0F, 0x87, 0xC0, 0x07, 0x83,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x80, 0x0E, 0x78,
  0x78, 0x3D, 0xF9, 0xF8, 0x77, 0xF7, 0xF8, 0xFD, 0xFC, 0xF1, 0xE1, 0xF1,
  0xE7, 0xC3, 0xC3, 0xCF, 0x07, 0x87, 0x9E, 0x1E, 0x0F, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x79, 0xE0, 0xF0, 0xF3, 0xC1, 0xC1, 0xE7, 0x87, 0x83, 0xCF,
  0x0F, 0x0F, 0x3E, 0x1E, 0x1E, 0x00, 0x0E, 0x78, 0x3D, 0xF8, 0x77, 0xF8,
  0xFD, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x00, 0x07,
  0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x9E, 0x7C, 0x7D, 0xE0, 0xF7, 0x83, 0xFC,
  0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBE, 0x3C, 0x7F, 0xF0, 0xFF, 0x81,
  0xF8, 0x00, 0x07, 0x3C, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x9F, 0x0F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E,
  0x3E, 0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x39, 0xF0, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x9E, 0x3F, 0xB8,
  0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x07, 0x1E, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0xCF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xBC,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x0E, 0x71, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x0F,
  0xE1, 0xFF, 0x3F, 0xF3, 0xC2, 0x3C, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xE8, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x07, 0x01,
  0xC0, 0x38, 0x0F, 0xF7, 0xFD, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF8, 0x7F, 0x07, 0xE0, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xF3, 0xC3, 0xE7, 0xCF, 0x87, 0xFF, 0x0F,
  0xEE, 0x0F, 0x9C, 0x00, 0xF0, 0x3F, 0xC1, 0xF7, 0x07, 0x9C, 0x3E, 0x78,
  0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xEE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xE0, 0xF0, 0xFF, 0x0F, 0x87,
  0xB8, 0x7C, 0x3D, 0xC7, 0xE3, 0xCE, 0x3F, 0x1E, 0x71, 0xF9, 0xE3, 0x9D,
  0xCF, 0x1C, 0xEE, 0xF0, 0xEE, 0x77, 0x87, 0x73, 0xB8, 0x3B, 0x9F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x00, 0x1E,
  0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x81, 0xE7, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xDE,
  0x03, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xF0, 0x1E, 0x07, 0x87, 0x07, 0xC3,
  0x83, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78,
  0x07, 0x78, 0x03, 0xBC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFE, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x07, 0xC3, 0xF0, 0x78, 0x0F, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x01, 0xF0, 0x7E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1F, 0x80, 0xE0, 0xFC, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x1C, 0x05, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFE, 0x80, 0xE0,
};

const GFXglyph NotoSans_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 10, 7, 12, 3, -19 },
  { 32, 17, 19, 17, 1, -19 },
  { 73, 14, 23, 15, 1, -21 },
  { 114, 20, 20, 23, 2, -20 },
  { 164, 18, 20, 19, 1, -20 },
  { 209, 4, 7, 7, 3, -19 },
  { 213, 10, 23, 9, 1, -19 },
  { 242, 10, 24, 9, -2, -20 },
  { 272, 13, 13, 15, 2, -21 },
  { 294, 14, 13, 15, 1, -16 },
  { 317, 6, 6, 8, -1, -3 },
  { 322, 8, 3, 9, 0, -9 },
  { 325, 5, 4, 8, 0, -4 },
  { 328, 14, 19, 11, -1, -19 },
  { 362, 14, 20, 15, 1, -20 },
  { 397, 11, 19, 15, 2, -19 },
  { 424, 15, 20, 15, -1, -20 },
  { 462, 15, 20, 15, 0, -20 },
  { 500, 15, 19, 15, 0, -19 },
  { 536, 15, 19, 15, 0, -19 },
  { 572, 14, 20, 15, 1, -20 },
  { 607, 15, 19, 15, 1, -19 },
  { 643, 14, 20, 15, 1, -20 },
  { 678, 13, 20, 15, 1, -20 },
  { 711, 7, 15, 8, 0, -15 },
  { 725, 8, 18, 8, -1, -15 },
  { 743, 14, 14, 15, 1, -17 },
  { 768, 14, 8, 15, 1, -14 },
  { 782, 14, 14, 15, 1, -17 },
  { 807, 11, 20, 12, 2, -20 },
  { 835, 22, 21, 23, 1, -19 },
  { 893, 17, 19, 17, -2, -19 },
  { 934, 16, 19, 17, 1, -19 },
  { 972, 16, 20, 17, 2, -20 },
  { 1012, 16, 19, 18, 1, -19 },
  { 1050, 15, 19, 15, 1, -19 },
  { 1086, 15, 19, 14, 1, -19 },
  { 1122, 16, 20, 19, 2, -20 },
  { 1162, 18, 19, 19, 1, -19 },
  { 1205, 13, 19, 10, -1, -19 },
  { 1236, 13, 25, 9, -4, -19 },
  { 1277, 18, 19, 17, 1, -19 },
  { 1320, 11, 19, 14, 1, -19 },
  { 1347, 23, 19, 24, 1, -19 },
  { 1402, 20, 19, 20, 1, -19 },
  { 1450, 17, 20, 20, 2, -20 },
  { 1493, 16, 19, 16, 1, -19 },
  { 1531, 17, 25, 20, 2, -20 },
  { 1585, 15, 19, 17, 1, -19 },
  { 1621, 14, 20, 14, 1, -20 },
  { 1656, 14, 19, 14, 2, -19 },
  { 1690, 17, 19, 19, 2, -19 },
  { 1731, 16, 19, 16, 2, -19 },
  { 1769, 25, 19, 24, 2, -19 },
  { 1829, 21, 19, 16, -2, -19 },
  { 1879, 16, 19, 15, 2, -19 },
  { 1917, 17, 19, 14, -1, -19 },
  { 1958, 11, 23, 9, 0, -19 },
  { 1990, 6, 19, 11, 3, -19 },
  { 2005, 11, 23, 9, -2, -19 },
  { 2037, 14, 12, 15, 0, -19 },
  { 2058, 11, 2, 11, -2, 2 },
  { 2061, 6, 5, 9, 4, -21 },
  { 2065, 15, 15, 16, 1, -15 },
  { 2094, 15, 21, 16, 0, -21 },
  { 2134, 12, 15, 13, 1, -15 },
  { 2157, 16, 21, 16, 1, -21 },
  { 2199, 13, 15, 15, 1, -15 },
  { 2224, 16, 27, 10, -3, -21 },
  { 2278, 16, 21, 16, 0, -15 },
  { 2320, 15, 21, 16, 0, -21 },
  { 2360, 9, 21, 8, 0, -21 },
  { 2384, 12, 27, 8, -3, -21 },
  { 2425, 17, 21, 15, 0, -21 },
  { 2470, 9, 21, 8, 0, -21 },
  { 2494, 23, 15, 24, 0, -15 },
  { 2538, 15, 15, 16, 0, -15 },
  { 2567, 14, 15, 16, 1, -15 },
  { 2594, 16, 21, 16, -1, -15 },
  { 2636, 15, 21, 16, 1, -15 },
  { 2676, 12, 15, 11, 0, -15 },
  { 2699, 12, 15, 13, 0, -15 },
  { 2722, 11, 18, 11, 1, -18 },
  { 2747, 15, 15, 16, 1, -15 },
  { 2776, 14, 15, 14, 1, -15 },
  { 2803, 21, 15, 21, 2, -15 },
  { 2843, 17, 15, 14, -1, -15 },
  { 2875, 17, 21, 14, -2, -15 },
  { 2920, 13, 15, 13, 0, -15 },
  { 2945, 11, 23, 10, 0, -19 },
  { 2977, 3, 26, 15, 6, -20 },
  { 2987, 11, 23, 10, -1, -19 },
  { 3019, 14, 5, 15, 1, -12 },
};

const GFXfont NotoSans_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_BOLDITALIC27PT7B_H_
