#ifndef _NOTOSANS_BOLDITALIC46PT7B_H_
#define _NOTOSANS_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0x30, 0x00, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0xFC, 0x7E, 0xFC, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0x1C, 0x0F,
  0xE7, 0x04, 0x0F, 0xC7, 0x00, 0x0F, 0xCF, 0x00, 0x0F, 0xEE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3D, 0xFC, 0x00, 0x39, 0xFC, 0x00, 0x39, 0xFC, 0x80, 0x39, 0xFC, 0xE0,
  0x39, 0xFC, 0xFC, 0x77, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x7F, 0xF8, 0x01, 0xF0,
  0x1F, 0xFF, 0x00, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0xFC, 0x7C, 0x03,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0xFC, 0x3E,
  0x0F, 0xC0, 0x1F, 0x87, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x7C, 0x00, 0x7C,
  0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0xF8, 0xFE,
  0x3E, 0x3F, 0x3E, 0x7F, 0xE7, 0xEF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFB, 0xF7,
  0xFF, 0xCF, 0xFE, 0x7C, 0xFF, 0xF9, 0xFF, 0x9F, 0x3F, 0x1F, 0x9F, 0xE7,
  0xE7, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x0F, 0xC0,
  0x0F, 0x87, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x87,
  0xC0, 0x1F, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF8, 0x0F,
  0x8F, 0xC0, 0x3E, 0x01, 0xFB, 0xF8, 0x0F, 0x80, 0x3F, 0xFE, 0x03, 0xE0,
  0x03, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0x07, 0xFF, 0x01, 0xFC, 0x7F, 0xFC, 0x0F, 0xE3, 0xFF, 0xF8, 0x3F, 0x9F,
  0xEF, 0xF1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF3, 0xF8, 0x3F, 0xBF, 0x8F, 0xE0,
  0x7F, 0xFC, 0x3F, 0x81, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0x83, 0xF8, 0x07,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE7, 0xF8,
  0x0F, 0xFE, 0x0F, 0xF0, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF, 0xBF, 0x7C, 0xF9,
  0xF3, 0xC7, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x20, 0x3E, 0x01, 0xC0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0xDF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF0, 0x70, 0xFF, 0xE0, 0x07, 0xEF,
  0x80, 0x3F, 0x9F, 0x01, 0xFC, 0x7C, 0x01, 0xE1, 0xF8, 0x03, 0x07, 0xE0,
  0x04, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xCF, 0xC3, 0xE3, 0xF0, 0xE1, 0xFC, 0x10, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xFC, 0x07, 0x00, 0xFF,
  0x00, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0x87, 0xFC, 0x07, 0x01, 0xFE, 0x02, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x30, 0x00, 0xFF, 0x1F, 0x01,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC8, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xDE, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x80, 0x0F, 0xF8, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0x06, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0,
  0x7F, 0x7F, 0xE0, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xC3, 0xF8, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF9, 0xFC, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x7F, 0x83, 0xFC, 0x7F,
  0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x00,
  0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xE7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xC0, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x06, 0x07, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0,
  0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xF0, 0x04, 0x00, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFC, 0x3F, 0x8C, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x03, 0xFE, 0x0F,
  0x87, 0xC0, 0x7F, 0xFC, 0x7E, 0x7E, 0x0F, 0xFF, 0xE1, 0xF3, 0xE0, 0xFF,
  0xFE, 0x0F, 0xBF, 0x07, 0xE1, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0x83, 0xEF,
  0x87, 0xE0, 0x7C, 0x1F, 0x7C, 0x3E, 0x07, 0xC0, 0xFF, 0xC3, 0xF0, 0x3E,
  0x07, 0xFE, 0x1F, 0x01, 0xF0, 0x7D, 0xF0, 0xF8, 0x1F, 0x83, 0xEF, 0x87,
  0xC0, 0xF8, 0x1F, 0x7C, 0x3E, 0x07, 0xC1, 0xF3, 0xE1, 0xF0, 0x7E, 0x1F,
  0x9F, 0x0F, 0xC7, 0xF1, 0xF8, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xE1, 0xFF,
  0xBF, 0xFC, 0x1F, 0x0F, 0xFD, 0xFF, 0xC0, 0xF8, 0x1F, 0x83, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7E,
  0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xE0, 0xFF, 0x80,
  0x04, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x60, 0x3F, 0xF9, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0xFF, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x07, 0xFC,
  0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x01, 0xC1, 0xFF,
  0x00, 0x04, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x2F, 0xE0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xCF, 0xE0, 0x7F,
  0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFF, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x08, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x01, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x01,
  0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0x3F,
  0xFC, 0x07, 0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x07,
  0xEF, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x0F, 0xCF, 0x81,
  0xF9, 0xF8, 0x0F, 0xCF, 0x81, 0xFB, 0xF8, 0x0F, 0xCF, 0x83, 0xF3, 0xF0,
  0x0F, 0xCF, 0x83, 0xF3, 0xF0, 0x1F, 0xCF, 0x87, 0xE3, 0xF0, 0x1F, 0x8F,
  0x87, 0xE3, 0xF0, 0x1F, 0x8F, 0x8F, 0xC7, 0xF0, 0x1F, 0x8F, 0x8F, 0x87,
  0xE0, 0x1F, 0x8F, 0x9F, 0x87, 0xE0, 0x3F, 0x8F, 0xDF, 0x07, 0xE0, 0x3F,
  0x0F, 0xFF, 0x0F, 0xE0, 0x3F, 0x0F, 0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0xFE,
  0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xF0,
  0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0xFF,
  0xE0, 0x07, 0xE0, 0x3F, 0xF8, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x7E, 0xFC, 0x03, 0xF0,
  0x1F, 0xBF, 0x81, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x03, 0xF1, 0xF8, 0x1F,
  0x80, 0xFC, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x3F, 0x01, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x07,
  0xE3, 0xF0, 0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE0, 0x7F, 0x7F, 0x03, 0xF8,
  0x0F, 0xDF, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF8, 0x0F,
  0xC0, 0x1F, 0xFE, 0x03, 0xF0, 0x07, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xE0, 0x03, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xF0, 0x7F, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF1,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xF0, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x07,
  0xF0, 0xC0, 0x0F, 0xF0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xEF, 0xE0, 0x0F, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xF8, 0x07, 0xF3,
  0xF8, 0x07, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF7, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFB, 0xE0, 0x7E, 0x07, 0xE0, 0xFD, 0xF0, 0x7F, 0x03,
  0xF0, 0x7C, 0xF8, 0x3F, 0x81, 0xF8, 0x7E, 0x7C, 0x1F, 0x80, 0xFC, 0x3F,
  0x3E, 0x1F, 0xC0, 0x7E, 0x3F, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x8F, 0x8F,
  0xE0, 0x1F, 0x9F, 0x87, 0xC7, 0xE0, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0x07,
  0xE7, 0xC1, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x01, 0xFB, 0xE0,
  0x7D, 0xFC, 0x00, 0xFF, 0xF0, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0x7E,
  0x00, 0x3E, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xDF,
  0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xF9, 0xE0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x1F, 0x00,
  0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x1F,
  0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x0F, 0xC0,
  0xFF, 0xC7, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF1, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xE0, 0x3F, 0xF3, 0xF0, 0x0F,
  0xF1, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xC0, 0x07, 0xF3, 0xF8,
  0x07, 0xEF, 0xFC, 0x07, 0xEF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0xF8, 0x7F, 0x80,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0x87, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x01, 0x07, 0xF8, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x02, 0x07, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFF,
  0x9F, 0x80, 0x7F, 0xFB, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0x7E, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xC7,
  0xF1, 0xFE, 0x0F, 0xCF, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x07, 0xF7,
  0xF0, 0x3F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x08, 0x7F, 0x00, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0xC3, 0xF0, 0x1F, 0xF8, 0xF8, 0x0F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F,
  0xF0, 0x7F, 0x8F, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFB, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x08, 0x01, 0xFE,
  0x03, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x60, 0x07, 0xF3, 0xFC, 0x07, 0xE7, 0xFE, 0x07, 0xEF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x1F, 0xE0, 0x7E, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0x1F, 0xE0, 0x0F, 0xC7, 0xF8, 0x01, 0xF9, 0xFE, 0x00, 0x7F, 0x7F,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x40, 0x01, 0x00, 0x1F, 0x0F, 0xF0, 0x3F, 0xC0, 0x7C, 0x7F, 0xE1, 0xFF,
  0x81, 0xF3, 0xFF, 0x8F, 0xFE, 0x0F, 0xDF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFE, 0x07, 0xF1, 0xFC, 0x07,
  0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0xFE, 0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0x80, 0x7F, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x60, 0x07, 0xC3, 0xFC, 0x07, 0xC7, 0xFE, 0x07,
  0xCF, 0xFF, 0x0F, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0x1F, 0xE0, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xF8, 0x03,
  0xF9, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0xFF,
  0xE7, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xF0, 0x0F, 0xE3,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x60, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7C, 0xFF, 0x0F, 0xDF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF9, 0xF8, 0x7F, 0x01, 0x83,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF9, 0x00, 0x1F, 0xCE, 0x01, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x08, 0x1F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF8,
  0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xE3, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0x81, 0xFF, 0xE7, 0xC0, 0x7F, 0xE3,
  0xE0, 0x1F, 0xE1, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E,
  0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0xFF,
  0x81, 0xFC, 0xFC, 0x0F, 0xF8, 0x1F, 0x8F, 0xC1, 0xFF, 0x83, 0xF8, 0xFC,
  0x1F, 0xF8, 0x3F, 0x0F, 0xC3, 0xEF, 0x87, 0xF0, 0xFC, 0x3E, 0xF8, 0x7F,
  0x0F, 0xC3, 0xEF, 0x8F, 0xE0, 0xFC, 0x7C, 0xF8, 0xFE, 0x0F, 0xC7, 0xCF,
  0x8F, 0xC0, 0xFC, 0xFC, 0xF9, 0xFC, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC,
  0xF8, 0xFB, 0xF8, 0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0xFB, 0xF0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xE7,
  0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x7F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xB0, 0x03,
  0xFE, 0x40, 0x00, 0x60,
};

const GFXglyph NotoSans_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 34, 13, 0, -33 },
  { 65, 16, 12, 21, 5, -33 },
  { 89, 29, 33, 30, 1, -33 },
  { 209, 24, 38, 25, 1, -35 },
  { 323, 35, 33, 39, 3, -33 },
  { 468, 30, 33, 33, 2, -33 },
  { 592, 7, 12, 12, 5, -33 },
  { 603, 17, 40, 16, 2, -33 },
  { 688, 17, 40, 16, -3, -33 },
  { 773, 22, 22, 25, 4, -35 },
  { 834, 23, 22, 26, 2, -27 },
  { 898, 11, 11, 13, -2, -5 },
  { 914, 13, 6, 15, 1, -15 },
  { 924, 8, 8, 13, 0, -7 },
  { 932, 25, 33, 20, -2, -33 },
  { 1036, 24, 33, 25, 1, -33 },
  { 1135, 18, 33, 25, 4, -33 },
  { 1210, 26, 33, 25, -1, -33 },
  { 1318, 25, 33, 25, 0, -33 },
  { 1422, 26, 33, 25, -1, -33 },
  { 1530, 24, 33, 25, 1, -33 },
  { 1629, 24, 33, 25, 2, -33 },
  { 1728, 25, 33, 25, 2, -33 },
  { 1832, 24, 33, 25, 1, -33 },
  { 1931, 23, 33, 25, 2, -33 },
  { 2026, 13, 27, 13, 0, -26 },
  { 2070, 15, 32, 13, -2, -26 },
  { 2130, 23, 24, 26, 2, -29 },
  { 2199, 23, 14, 26, 2, -23 },
  { 2240, 23, 24, 26, 2, -29 },
  { 2309, 19, 34, 21, 4, -33 },
  { 2390, 37, 37, 39, 2, -33 },
  { 2562, 29, 33, 29, -3, -33 },
  { 2682, 27, 33, 29, 1, -33 },
  { 2794, 27, 33, 28, 3, -33 },
  { 2906, 29, 33, 31, 1, -33 },
  { 3026, 26, 33, 25, 1, -33 },
  { 3134, 25, 33, 25, 1, -33 },
  { 3238, 28, 33, 32, 3, -33 },
  { 3354, 31, 33, 32, 1, -33 },
  { 3482, 21, 33, 18, -1, -33 },
  { 3569, 23, 43, 15, -7, -33 },
  { 3693, 31, 33, 28, 1, -33 },
  { 3821, 20, 33, 24, 1, -33 },
  { 3904, 40, 33, 40, 1, -33 },
  { 4069, 34, 33, 35, 1, -33 },
  { 4210, 29, 33, 34, 3, -33 },
  { 4330, 27, 33, 28, 1, -33 },
  { 4442, 29, 41, 34, 3, -33 },
  { 4591, 26, 33, 29, 1, -33 },
  { 4699, 24, 33, 24, 1, -33 },
  { 4798, 24, 33, 24, 4, -33 },
  { 4897, 29, 33, 32, 3, -33 },
  { 5017, 27, 33, 27, 4, -33 },
  { 5129, 41, 33, 41, 4, -33 },
  { 5299, 35, 33, 28, -3, -33 },
  { 5444, 26, 33, 26, 4, -33 },
  { 5552, 28, 33, 25, -1, -33 },
  { 5668, 19, 40, 15, -1, -33 },
  { 5763, 11, 33, 20, 5, -33 },
  { 5809, 19, 40, 15, -3, -33 },
  { 5904, 23, 21, 25, 1, -33 },
  { 5965, 19, 3, 18, -4, 4 },
  { 5973, 9, 7, 15, 7, -35 },
  { 5981, 25, 26, 27, 2, -26 },
  { 6063, 24, 35, 27, 1, -35 },
  { 6168, 21, 26, 22, 2, -26 },
  { 6237, 27, 35, 27, 2, -35 },
  { 6356, 22, 26, 26, 2, -26 },
  { 6428, 27, 46, 17, -5, -35 },
  { 6584, 26, 37, 27, 1, -26 },
  { 6705, 24, 35, 28, 1, -35 },
  { 6810, 14, 35, 14, 1, -35 },
  { 6872, 21, 46, 14, -6, -35 },
  { 6993, 27, 35, 26, 1, -35 },
  { 7112, 14, 35, 14, 1, -35 },
  { 7174, 38, 26, 42, 1, -26 },
  { 7298, 24, 26, 28, 1, -26 },
  { 7376, 23, 26, 27, 2, -26 },
  { 7451, 27, 37, 27, -2, -26 },
  { 7576, 25, 37, 27, 2, -26 },
  { 7692, 20, 26, 19, 1, -26 },
  { 7757, 21, 26, 22, 0, -26 },
  { 7826, 18, 30, 19, 2, -30 },
  { 7894, 25, 25, 28, 2, -25 },
  { 7973, 24, 25, 24, 2, -25 },
  { 8048, 36, 25, 36, 3, -25 },
  { 8161, 29, 25, 25, -2, -25 },
  { 8252, 29, 36, 24, -3, -25 },
  { 8383, 23, 25, 22, -1, -25 },
  { 8455, 19, 40, 16, 0, -33 },
  { 8550, 5, 45, 25, 10, -35 },
  { 8579, 18, 40, 16, -2, -33 },
  { 8669, 23, 8, 26, 2, -20 },
};

const GFXfont NotoSans_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_BOLDITALIC46PT7B_H_
