#ifndef _NOTOSANS_BOLDITALIC34PT7B_H_
#define _NOTOSANS_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7C, 0xFB,
  0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x38, 0xF1, 0xC7, 0x9E, 0x3C, 0xF1,
  0xC0, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC0, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03,
  0x87, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x71, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7D, 0xC4, 0x3E, 0x60,
  0x0F, 0x98, 0x01, 0xF6, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x77, 0xC0, 0x19, 0xF2, 0x06,
  0x7C, 0xF9, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0x07, 0xF0,
  0x07, 0x83, 0xFE, 0x01, 0xE0, 0xFF, 0x80, 0xF0, 0x7D, 0xF0, 0x78, 0x1E,
  0x3C, 0x3C, 0x0F, 0x9F, 0x0F, 0x03, 0xC7, 0xC7, 0x80, 0xF1, 0xE3, 0xC0,
  0x3C, 0x79, 0xE0, 0x0F, 0x1E, 0x79, 0xE3, 0xCF, 0x3D, 0xFE, 0xFF, 0xDE,
  0xFF, 0x9F, 0xEF, 0x3F, 0xF7, 0xF3, 0xDF, 0x3C, 0x31, 0xE7, 0x8F, 0x00,
  0xF1, 0xE3, 0xC0, 0x78, 0xF8, 0xF0, 0x1E, 0x3C, 0x7C, 0x0F, 0x0F, 0x1E,
  0x07, 0x83, 0xC7, 0x83, 0xC0, 0xFB, 0xE0, 0xF0, 0x3F, 0xF0, 0x78, 0x07,
  0xF8, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xE1,
  0xF0, 0x03, 0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xE3, 0xFF, 0x0F, 0x8F, 0xFE, 0x1F,
  0x3F, 0x3E, 0x7C, 0x7C, 0x7F, 0xF1, 0xF0, 0x7F, 0xE3, 0xE0, 0x7F, 0x87,
  0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xF1, 0xF8, 0x7D, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xF0,
  0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xE0, 0x41, 0xE0, 0x71, 0xE0, 0xFD, 0xC0, 0xFF, 0xCF, 0x7F,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xE0, 0x3E, 0xE0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x18, 0xF8, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF1, 0xFF, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0xC7,
  0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3F, 0xFB, 0xFF, 0xC7, 0xDF, 0x1E, 0x7C,
  0x21, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x07, 0xC0, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xC1, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0xC0, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x01, 0xF7, 0xC0,
  0xF9, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x70, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFD, 0x83, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x9E, 0x07, 0xDF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xC7,
  0xE1, 0xF1, 0xF0, 0x3E, 0xFC, 0x1F, 0x3E, 0x07, 0xC7, 0x81, 0xF1, 0xF0,
  0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xE7, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xE1, 0xF0, 0xFC, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xF7, 0xF9, 0xFF,
  0xFC, 0xFF, 0xBC, 0x3F, 0xBE, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x01,
  0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x01,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x7D, 0xFD,
  0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x8F, 0x01, 0xF0, 0xF3, 0xE1,
  0xFF, 0x8F, 0x78, 0x7F, 0xF1, 0xEE, 0x1F, 0x1E, 0x3F, 0xC7, 0xC3, 0x87,
  0xF8, 0xF0, 0xF0, 0xFE, 0x1C, 0x1E, 0x1F, 0xC7, 0x83, 0xC3, 0xB8, 0xF0,
  0xF0, 0xF7, 0x1E, 0x1E, 0x1E, 0xE3, 0xC7, 0xC7, 0x9C, 0x7D, 0xFF, 0xF3,
  0xC7, 0xFF, 0xFC, 0x78, 0xFE, 0x7E, 0x0F, 0x82, 0x02, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x04, 0x01, 0xFC, 0x07, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x7C,
  0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3,
  0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83, 0xF0, 0xF8,
  0x3F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xE1, 0xF8, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC3, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC,
  0x06, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x07, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xF8, 0x7F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x3F,
  0x1F, 0x03, 0xF0, 0xF8, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xE0, 0x10, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x3F, 0xEF, 0xC3, 0xFF, 0x7C, 0x1F, 0xF3, 0xE0,
  0xFF, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01, 0xF1,
  0xF8, 0x0F, 0x87, 0xF0, 0x7C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x23, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0x83,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF8,
  0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x07, 0xBC, 0x1F, 0xF0, 0x3D, 0xE0, 0xF7, 0x83, 0xDF, 0x07, 0x9C,
  0x1E, 0xF8, 0x3C, 0xE1, 0xE7, 0xC3, 0xE7, 0x0F, 0x3C, 0x1F, 0x3C, 0xF3,
  0xE0, 0xF1, 0xE7, 0x9F, 0x07, 0x8F, 0x78, 0xF8, 0x7C, 0x7B, 0xC7, 0xC3,
  0xE3, 0xFC, 0x3C, 0x1F, 0x1F, 0xE3, 0xE0, 0xF0, 0xFE, 0x1F, 0x07, 0x87,
  0xF0, 0xF8, 0x7C, 0x3F, 0x07, 0x83, 0xE1, 0xF8, 0x3C, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xFC, 0x03, 0xC1, 0xFE,
  0x03, 0xE0, 0xFF, 0x01, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x3E,
  0xF0, 0x3C, 0x1F, 0x7C, 0x3E, 0x0F, 0x3E, 0x1F, 0x07, 0x8F, 0x0F, 0x87,
  0xC7, 0xC7, 0x83, 0xE3, 0xE3, 0xC1, 0xF0, 0xF3, 0xE0, 0xF8, 0x7D, 0xF0,
  0x78, 0x3E, 0xF8, 0x7C, 0x0F, 0x78, 0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xFE,
  0x0F, 0x01, 0xFF, 0x07, 0x80, 0x7F, 0x87, 0xC0, 0x3F, 0x83, 0xE0, 0x1F,
  0xC1, 0xF0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3, 0xF0, 0x0F, 0x8F,
  0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x7E,
  0x0F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1,
  0xF0, 0x3F, 0x1F, 0x07, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0xFC, 0x7C, 0x7F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E,
  0x00, 0x70, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFC,
  0x08, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x90, 0x0F, 0xCC, 0x0F, 0xC7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0x80, 0xF8, 0x78, 0x0F, 0x87,
  0x81, 0xF0, 0x78, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0x3D, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x1F,
  0x80, 0xFB, 0xE0, 0x3F, 0x03, 0xE7, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC,
  0x1F, 0x1F, 0x07, 0xF8, 0x3E, 0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x1F, 0xE1,
  0xF0, 0xF8, 0x7B, 0xC3, 0xE1, 0xF0, 0xF7, 0x8F, 0x83, 0xE3, 0xCF, 0x1F,
  0x07, 0xC7, 0x9E, 0x3C, 0x0F, 0x9F, 0x3C, 0xF8, 0x1F, 0x3C, 0x79, 0xF0,
  0x1E, 0xF8, 0xF7, 0xC0, 0x3D, 0xE1, 0xEF, 0x80, 0x7B, 0xC3, 0xDE, 0x00,
  0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xEF, 0x81, 0xF9, 0xF0,
  0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3,
  0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0x87, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1E,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF9, 0xF1, 0xE1, 0xE0, 0x01, 0xE1, 0xE0,
  0xFF, 0x78, 0x3F, 0xEF, 0x0F, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F,
  0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x0F, 0x8F, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFB, 0xC0, 0x7E, 0x78, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0xF8, 0x1F, 0x7F, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0x3F, 0x3F, 0x0F,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x0F, 0xDF, 0x03, 0xE7,
  0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x8F, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF8, 0xF7, 0xFC, 0x3C, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0x84, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x08,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x1E, 0x3E, 0x07, 0xF3, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1,
  0xF9, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xDE, 0x01, 0xF9,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x10, 0xFE, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0xFE, 0x78,
  0x3F, 0xEF, 0x0F, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F,
  0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x20,
  0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x78, 0x1F, 0x7F, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0x3F, 0x3F, 0x87, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E,
  0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x1F,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0x03,
  0x81, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x1F, 0x07, 0xE1, 0xF0,
  0xFC, 0x1F, 0x1F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E, 0x03, 0xEF, 0xC0, 0x3E,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0xFC, 0x07, 0xC7, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x00, 0x0E, 0x1E, 0x07, 0xC1, 0xE7, 0xF0, 0xFE, 0x1E, 0xFF, 0xBF,
  0xE1, 0xFF, 0xFB, 0xFF, 0x1F, 0xCF, 0xF3, 0xF3, 0xF8, 0x7E, 0x1F, 0x3F,
  0x07, 0xC1, 0xF3, 0xE0, 0xFC, 0x1F, 0x3E, 0x0F, 0x81, 0xF3, 0xE0, 0xF8,
  0x3E, 0x7C, 0x0F, 0x83, 0xE7, 0xC0, 0xF8, 0x3E, 0x7C, 0x1F, 0x03, 0xE7,
  0xC1, 0xF0, 0x3E, 0x7C, 0x1F, 0x07, 0xCF, 0x81, 0xF0, 0x7C, 0xF8, 0x1F,
  0x07, 0xCF, 0x83, 0xE0, 0x7C, 0xF8, 0x3E, 0x0F, 0xC0, 0x0E, 0x1E, 0x07,
  0x9F, 0xE1, 0xEF, 0xF8, 0x7F, 0xFF, 0x1F, 0xCF, 0xCF, 0xE1, 0xF3, 0xF0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xF3, 0xF9, 0xF9, 0xF8, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xF0, 0xFC,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0x8F, 0x80,
  0x79, 0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x3F, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F, 0x8F, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3E, 0xFC, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0xFF, 0x78, 0x3F, 0xEF,
  0x0F, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7C, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1E,
  0x3E, 0xF8, 0x7B, 0xF0, 0xF7, 0xE1, 0xFF, 0xC7, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xF0, 0x47, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xA0, 0x3F, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x00, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x8F, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xEF, 0x03, 0xF3, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF0, 0xF1, 0xF8,
  0x78, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFB, 0xE1, 0xFC, 0x3F, 0x7C, 0x3F,
  0x87, 0xCF, 0x87, 0xF0, 0xF9, 0xF1, 0xFE, 0x3E, 0x3E, 0x3F, 0xC7, 0xC7,
  0xCF, 0x79, 0xF0, 0xF9, 0xEF, 0x3E, 0x1F, 0x79, 0xEF, 0x81, 0xEF, 0x3D,
  0xF0, 0x3D, 0xE7, 0xBC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7E,
  0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7,
  0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3E, 0x7C,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 13, 9, 15, 3, -24 },
  { 49, 21, 24, 22, 1, -24 },
  { 112, 18, 28, 19, 1, -26 },
  { 175, 26, 25, 29, 2, -25 },
  { 257, 23, 25, 24, 1, -25 },
  { 329, 6, 9, 9, 3, -24 },
  { 336, 13, 29, 12, 1, -24 },
  { 384, 12, 30, 12, -2, -25 },
  { 429, 16, 16, 19, 3, -26 },
  { 461, 16, 16, 19, 2, -20 },
  { 493, 9, 8, 10, -2, -4 },
  { 502, 9, 4, 11, 1, -11 },
  { 507, 6, 5, 10, 0, -5 },
  { 511, 19, 24, 14, -2, -24 },
  { 568, 17, 25, 19, 1, -25 },
  { 622, 14, 24, 19, 3, -24 },
  { 664, 19, 25, 19, -1, -25 },
  { 724, 18, 25, 19, 0, -25 },
  { 781, 18, 24, 19, 0, -24 },
  { 835, 19, 24, 19, 0, -24 },
  { 892, 18, 25, 19, 1, -25 },
  { 949, 19, 24, 19, 1, -24 },
  { 1006, 18, 25, 19, 1, -25 },
  { 1063, 17, 25, 19, 1, -25 },
  { 1117, 9, 19, 10, 0, -19 },
  { 1139, 11, 23, 10, -2, -19 },
  { 1171, 16, 18, 19, 2, -21 },
  { 1207, 16, 10, 19, 2, -17 },
  { 1227, 16, 18, 19, 2, -21 },
  { 1263, 14, 25, 16, 3, -25 },
  { 1307, 27, 27, 29, 2, -24 },
  { 1399, 21, 24, 21, -2, -24 },
  { 1462, 20, 24, 21, 1, -24 },
  { 1522, 20, 25, 21, 2, -25 },
  { 1585, 21, 24, 23, 1, -24 },
  { 1648, 19, 24, 18, 1, -24 },
  { 1705, 19, 24, 18, 1, -24 },
  { 1762, 21, 25, 23, 2, -25 },
  { 1828, 23, 24, 24, 1, -24 },
  { 1897, 16, 24, 13, -1, -24 },
  { 1945, 17, 31, 11, -5, -24 },
  { 2011, 23, 24, 21, 1, -24 },
  { 2080, 14, 24, 18, 1, -24 },
  { 2122, 29, 24, 30, 1, -24 },
  { 2209, 25, 24, 26, 1, -24 },
  { 2284, 22, 25, 25, 2, -25 },
  { 2353, 20, 24, 21, 1, -24 },
  { 2413, 22, 31, 25, 2, -25 },
  { 2499, 19, 24, 21, 1, -24 },
  { 2556, 17, 25, 18, 1, -25 },
  { 2610, 18, 24, 18, 3, -24 },
  { 2664, 22, 24, 24, 2, -24 },
  { 2730, 20, 24, 20, 3, -24 },
  { 2790, 31, 24, 30, 3, -24 },
  { 2883, 25, 24, 21, -2, -24 },
  { 2958, 19, 24, 19, 3, -24 },
  { 3015, 21, 24, 18, -1, -24 },
  { 3078, 15, 29, 11, -1, -24 },
  { 3133, 8, 24, 14, 4, -24 },
  { 3157, 14, 29, 11, -2, -24 },
  { 3208, 17, 15, 19, 1, -24 },
  { 3240, 14, 2, 14, -3, 3 },
  { 3244, 7, 5, 11, 5, -26 },
  { 3249, 19, 19, 20, 1, -19 },
  { 3295, 18, 26, 20, 1, -26 },
  { 3354, 16, 19, 16, 1, -19 },
  { 3392, 20, 26, 20, 1, -26 },
  { 3457, 17, 19, 19, 1, -19 },
  { 3498, 20, 34, 13, -4, -26 },
  { 3583, 19, 27, 20, 1, -19 },
  { 3648, 18, 26, 21, 1, -26 },
  { 3707, 10, 26, 10, 1, -26 },
  { 3740, 15, 34, 10, -4, -26 },
  { 3804, 20, 26, 19, 1, -26 },
  { 3869, 10, 26, 10, 1, -26 },
  { 3902, 28, 19, 31, 1, -19 },
  { 3969, 18, 19, 21, 1, -19 },
  { 4012, 17, 19, 20, 1, -19 },
  { 4053, 20, 27, 20, -1, -19 },
  { 4121, 19, 27, 20, 1, -19 },
  { 4186, 15, 19, 14, 1, -19 },
  { 4222, 15, 19, 16, 0, -19 },
  { 4258, 13, 23, 14, 2, -23 },
  { 4296, 18, 19, 21, 2, -19 },
  { 4339, 17, 19, 17, 2, -19 },
  { 4380, 27, 19, 27, 2, -19 },
  { 4445, 22, 19, 18, -2, -19 },
  { 4498, 21, 27, 18, -2, -19 },
  { 4569, 17, 19, 16, -1, -19 },
  { 4610, 14, 29, 12, 0, -24 },
  { 4661, 3, 34, 19, 8, -26 },
  { 4674, 14, 29, 12, -2, -24 },
  { 4725, 16, 6, 19, 2, -15 },
};

const GFXfont NotoSans_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_BOLDITALIC34PT7B_H_
