#ifndef _NOTOSANS_BOLDITALIC10PT7B_H_
#define _NOTOSANS_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0xB0, 0xFA, 0x14, 0x55, 0xF1, 0x4F, 0xCA, 0x14, 0x00,
  0x11, 0xDE, 0xE3, 0x97, 0xEC, 0x20, 0xE7, 0x52, 0xE6, 0xF2, 0xA9, 0x73,
  0x00, 0x38, 0x58, 0xE3, 0xBD, 0xD9, 0x9F, 0x00, 0xE0, 0x32, 0x44, 0xCC,
  0xC4, 0x40, 0x31, 0x11, 0x13, 0x26, 0xC0, 0x25, 0x3E, 0xCB, 0x00, 0x44,
  0xF4, 0x40, 0xE0, 0xE0, 0x70, 0x18, 0x88, 0x44, 0x62, 0x00, 0x3B, 0x53,
  0x9C, 0xED, 0xC0, 0x3F, 0xA2, 0x66, 0x40, 0x7A, 0x42, 0x22, 0x63, 0xE0,
  0x78, 0x46, 0x61, 0xCF, 0xC0, 0x18, 0xCE, 0xBF, 0xFC, 0xC0, 0x3D, 0x85,
  0x1E, 0x1A, 0x6F, 0x00, 0x3D, 0x85, 0x1E, 0xC9, 0x67, 0x00, 0x7C, 0x21,
  0x84, 0x31, 0x8C, 0x00, 0x39, 0xB7, 0x9C, 0xDB, 0x27, 0x00, 0x7A, 0x52,
  0xF1, 0x8B, 0xC0, 0x4C, 0x05, 0x80, 0x23, 0x00, 0x06, 0xC0, 0x16, 0x87,
  0x10, 0xF0, 0xF0, 0x86, 0x1E, 0x80, 0xF3, 0x34, 0xC8, 0xC0, 0x1E, 0x61,
  0x5F, 0x55, 0xE5, 0x5E, 0x40, 0x3C, 0x0C, 0x38, 0x51, 0xA3, 0xCC, 0xF1,
  0x80, 0x3D, 0x96, 0xDE, 0x4D, 0x3F, 0x80, 0x7F, 0x28, 0x20, 0x83, 0x2F,
  0x00, 0x3D, 0x96, 0x59, 0x45, 0x3F, 0x00, 0x3D, 0x86, 0x1E, 0x41, 0x2F,
  0x00, 0x3D, 0x86, 0x1E, 0x41, 0x0C, 0x00, 0x7F, 0x0C, 0x26, 0xAB, 0x6F,
  0x80, 0x26, 0xCD, 0x93, 0xE4, 0x49, 0xB3, 0x00, 0x72, 0x66, 0x64, 0xE0,
  0x08, 0x46, 0x31, 0x08, 0xC6, 0xE0, 0x26, 0xD9, 0xE3, 0x85, 0x8B, 0x33,
  0x00, 0x23, 0x18, 0x84, 0x27, 0xC0, 0x33, 0xB9, 0x9D, 0xCA, 0xA5, 0xD2,
  0xDB, 0x68, 0x33, 0x72, 0x72, 0x5E, 0x4E, 0x4C, 0xCC, 0x7B, 0x38, 0xE3,
  0x8F, 0x6F, 0x00, 0x3D, 0x96, 0x5F, 0x41, 0x0C, 0x00, 0x7B, 0x38, 0xE3,
  0x8F, 0x6F, 0x04, 0x18, 0x3D, 0xB6, 0xDE, 0x59, 0x6C, 0xC0, 0x3B, 0x18,
  0x61, 0xCF, 0xC0, 0xFB, 0x18, 0xC4, 0x23, 0x00, 0x4F, 0x3C, 0xA2, 0x8A,
  0x6F, 0x00, 0x8E, 0x69, 0x3C, 0xE3, 0x8C, 0x00, 0x99, 0xCC, 0xA6, 0xD5,
  0x4A, 0xE6, 0x63, 0x30, 0x33, 0x16, 0x1C, 0x18, 0x3C, 0x2C, 0xC6, 0xDF,
  0x47, 0x18, 0x41, 0x0C, 0x00, 0x7C, 0x61, 0x0C, 0x63, 0x0F, 0x80, 0x36,
  0x44, 0x4C, 0xC8, 0xC0, 0xBD, 0x54, 0x31, 0x13, 0x22, 0x22, 0xE0, 0x11,
  0x9B, 0x90, 0xF0, 0xCC, 0x21, 0xF4, 0xB2, 0xD9, 0xE0, 0x20, 0x87, 0x1E,
  0x4D, 0x25, 0xBC, 0x13, 0xD1, 0x8C, 0xB8, 0x04, 0x12, 0xDF, 0x4B, 0x2D,
  0x9E, 0x13, 0xD3, 0xEC, 0x3C, 0x0C, 0x71, 0x1E, 0x30, 0x82, 0x08, 0x63,
  0x00, 0x21, 0xF4, 0xB2, 0xD9, 0xE1, 0xBC, 0x20, 0x86, 0x9E, 0x6D, 0x24,
  0xB6, 0x24, 0x34, 0x96, 0x11, 0x03, 0x22, 0x26, 0x6C, 0x20, 0x86, 0x5A,
  0x51, 0xC5, 0x36, 0x25, 0xB4, 0xB6, 0x09, 0x3F, 0x9B, 0x69, 0x24, 0x96,
  0xD8, 0x09, 0xE6, 0xD2, 0x4B, 0x60, 0x13, 0xD3, 0x9D, 0xB8, 0x11, 0xE4,
  0xD2, 0x5B, 0xCC, 0x20, 0x21, 0xF4, 0xB2, 0xD9, 0xE1, 0x04, 0x0B, 0x98,
  0x84, 0x60, 0x2B, 0x98, 0x61, 0x78, 0x22, 0xF4, 0x44, 0x60, 0xDC, 0xA5,
  0x6D, 0x00, 0xCD, 0x65, 0x1C, 0x60, 0xB7, 0x6B, 0xD6, 0xED, 0x80, 0x3E,
  0x30, 0x61, 0x4E, 0xC0, 0x66, 0x58, 0xA1, 0xC3, 0x06, 0x38, 0x00, 0x79,
  0x99, 0x8F, 0x00, 0x32, 0x26, 0xC4, 0x46, 0x60, 0xFF, 0xC0, 0x30, 0x8C,
  0x73, 0x10, 0x9C, 0x80, 0xF0,
};

const GFXglyph NotoSans_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 7, 7, 6, 0, -7 },
  { 12, 5, 9, 6, 0, -8 },
  { 18, 7, 7, 9, 1, -7 },
  { 25, 7, 7, 7, 0, -7 },
  { 32, 2, 2, 3, 1, -7 },
  { 33, 4, 9, 3, 0, -7 },
  { 38, 4, 9, 3, -1, -7 },
  { 43, 5, 5, 5, 1, -8 },
  { 47, 4, 5, 6, 1, -6 },
  { 50, 2, 2, 3, 0, -1 },
  { 51, 3, 1, 3, 0, -3 },
  { 52, 2, 2, 3, 0, -2 },
  { 53, 5, 7, 4, 0, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 6, 7, 6, 0, -7 },
  { 88, 6, 7, 6, 0, -7 },
  { 94, 6, 7, 6, 0, -7 },
  { 100, 6, 7, 6, 0, -7 },
  { 106, 5, 7, 6, 0, -7 },
  { 111, 3, 6, 3, 0, -6 },
  { 114, 4, 7, 3, -1, -6 },
  { 118, 4, 5, 6, 1, -6 },
  { 121, 4, 3, 6, 1, -5 },
  { 123, 4, 5, 6, 1, -6 },
  { 126, 4, 7, 5, 1, -7 },
  { 130, 8, 8, 9, 0, -7 },
  { 138, 7, 7, 6, -1, -7 },
  { 145, 6, 7, 6, 0, -7 },
  { 151, 6, 7, 6, 1, -7 },
  { 157, 6, 7, 7, 0, -7 },
  { 163, 6, 7, 5, 0, -7 },
  { 169, 6, 7, 5, 0, -7 },
  { 175, 6, 7, 7, 1, -7 },
  { 181, 7, 7, 7, 0, -7 },
  { 188, 4, 7, 4, 0, -7 },
  { 192, 5, 9, 3, -2, -7 },
  { 198, 7, 7, 6, 0, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 9, 7, 9, 0, -7 },
  { 218, 8, 7, 8, 0, -7 },
  { 225, 6, 7, 7, 1, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 6, 9, 7, 1, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 5, 7, 5, 0, -7 },
  { 255, 5, 7, 5, 1, -7 },
  { 260, 6, 7, 7, 1, -7 },
  { 266, 6, 7, 6, 1, -7 },
  { 272, 9, 7, 9, 1, -7 },
  { 280, 8, 7, 6, -1, -7 },
  { 287, 6, 7, 6, 1, -7 },
  { 293, 6, 7, 5, 0, -7 },
  { 299, 4, 9, 3, 0, -7 },
  { 304, 2, 7, 4, 1, -7 },
  { 306, 4, 9, 3, -1, -7 },
  { 311, 5, 4, 6, 0, -7 },
  { 314, 4, 1, 4, -1, 1 },
  { 315, 3, 2, 3, 1, -8 },
  { 316, 6, 6, 6, 0, -6 },
  { 321, 6, 8, 6, 0, -8 },
  { 327, 5, 6, 5, 0, -6 },
  { 331, 6, 8, 6, 0, -8 },
  { 337, 5, 6, 6, 0, -6 },
  { 341, 6, 10, 4, -1, -8 },
  { 349, 6, 8, 6, 0, -6 },
  { 355, 6, 8, 6, 0, -8 },
  { 361, 3, 8, 3, 0, -8 },
  { 364, 4, 10, 3, -1, -8 },
  { 369, 6, 8, 6, 0, -8 },
  { 375, 3, 8, 3, 0, -8 },
  { 378, 9, 6, 9, 0, -6 },
  { 385, 6, 6, 6, 0, -6 },
  { 390, 5, 6, 6, 0, -6 },
  { 394, 6, 8, 6, 0, -6 },
  { 400, 6, 8, 6, 0, -6 },
  { 406, 5, 6, 4, 0, -6 },
  { 410, 5, 6, 5, 0, -6 },
  { 414, 4, 7, 4, 0, -7 },
  { 418, 5, 5, 6, 1, -5 },
  { 422, 6, 5, 5, 0, -5 },
  { 426, 7, 5, 8, 1, -5 },
  { 431, 7, 5, 5, -1, -5 },
  { 436, 7, 7, 5, -1, -5 },
  { 443, 5, 5, 5, 0, -5 },
  { 447, 4, 9, 4, 0, -7 },
  { 452, 1, 10, 6, 2, -8 },
  { 454, 5, 9, 4, -1, -7 },
  { 460, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_BOLDITALIC10PT7B_H_
