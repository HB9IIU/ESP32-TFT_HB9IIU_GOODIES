#ifndef _NOTOSANS_BOLDITALIC71PT7B_H_
#define _NOTOSANS_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFF,
  0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x3E, 0x3F, 0x00, 0x7F,
  0xE1, 0xE0, 0x38, 0x07, 0xFF, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0xF8, 0x00,
  0x01, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x00, 0x7F, 0xF1,
  0xE0, 0x00, 0x03, 0xFF, 0xDF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0x03, 0xE3, 0xFF, 0x80,
  0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0xFF, 0xE0, 0x00, 0x07, 0xC7,
  0xFF, 0x10, 0x00, 0x3C, 0x3F, 0xF8, 0xE0, 0x03, 0xE1, 0xFF, 0x87, 0xE0,
  0x1F, 0x1F, 0xFC, 0x3F, 0xE0, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0x1F, 0xF1, 0xFF, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xFC,
  0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x00,
  0x1F, 0xE0, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xFE, 0x1F, 0xC0, 0x01, 0xFF, 0xE7, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFB, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xC0, 0x03,
  0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0xC0,
  0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0x02, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x83, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0xC3, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xC1, 0xFF,
  0x80, 0xFC, 0x0F, 0xFC, 0x03, 0x80, 0xFF, 0xE0, 0x08, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x04, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xC0,
  0x02, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xC0, 0x00,
  0x1F, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x00, 0x0F,
  0xFF, 0x83, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x60,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xF1,
  0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x20, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xC0,
  0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0x9F,
  0xFC, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF0, 0x7F, 0xFC, 0x7E, 0x00, 0x7F, 0xF0, 0xE0, 0x01, 0xFF,
  0xC2, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x87,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE3, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFF,
  0x83, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xEF, 0xE0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF7, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFB, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x1F,
  0xFD, 0xFF, 0xFB, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFE, 0x7F,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x10, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0x10, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0x8F, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF1, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x80, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xF0,
  0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F,
  0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x9F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xC7,
  0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFF,
  0x00, 0x3F, 0xF1, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xF9, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF3, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF3, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1E, 0x00, 0x7F,
  0xF8, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x10, 0x00, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xE0, 0x00,
  0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x0F,
  0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC7, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE3,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC7,
  0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF,
  0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xF8,
  0x7F, 0xC0, 0x3F, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0xEF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x87,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFC,
  0xFF, 0x80, 0x1F, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE3, 0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x08, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x20, 0x7F, 0xF8, 0x00, 0xC0, 0x7F, 0xFC, 0x07, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFF, 0xF7, 0xFE,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x87,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x1F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F,
  0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF,
  0x80, 0x7F, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x30, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0xFF, 0xF0, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x81, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0x00, 0x3F, 0xFF, 0xF3, 0xFE, 0x00, 0x7F, 0xFF,
  0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFB, 0xFF,
  0x80, 0x07, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0xFF, 0x00,
  0x3F, 0xEF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xF8,
  0x07, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF3, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFB,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x7F,
  0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF,
  0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0xE0, 0x07, 0xFF,
  0xF9, 0xFF, 0x00, 0x1F, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x1E, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xBF, 0xFE, 0x01, 0xFF,
  0x3F, 0xFC, 0x01, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFC, 0x0F, 0xFE, 0x00,
  0x78, 0x1F, 0xFC, 0x00, 0x20, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x10, 0x00, 0x0F, 0xFE, 0x3C, 0x00,
  0x3F, 0xF8, 0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x04,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF,
  0xC3, 0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0x3F, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x3F,
  0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x3F, 0x81, 0xFF, 0x80, 0x7F, 0xC1,
  0xFE, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x3F, 0x83, 0xFF, 0x00,
  0x7F, 0xC3, 0xFC, 0x3F, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0x87,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xF8,
  0x3F, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF8, 0x00, 0x7F,
  0xCF, 0xF0, 0x3F, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x3F, 0x9F, 0xF8,
  0x00, 0x7F, 0xCF, 0xF0, 0x3F, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x3F,
  0xBF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF,
  0xC0, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x47,
  0xFF, 0xC0, 0x00, 0x17, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE8, 0x00, 0x03, 0xFF, 0xE2, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 22, 52, 20, 1, -51 },
  { 144, 26, 19, 32, 7, -51 },
  { 206, 45, 51, 46, 1, -51 },
  { 493, 37, 58, 39, 2, -54 },
  { 762, 54, 52, 61, 4, -51 },
  { 1113, 48, 52, 50, 2, -51 },
  { 1425, 12, 19, 18, 7, -51 },
  { 1454, 26, 62, 24, 3, -51 },
  { 1656, 27, 63, 24, -5, -52 },
  { 1869, 34, 34, 39, 6, -54 },
  { 2014, 34, 34, 41, 4, -42 },
  { 2159, 17, 17, 20, -3, -8 },
  { 2196, 20, 8, 23, 1, -23 },
  { 2216, 12, 12, 20, 1, -11 },
  { 2234, 38, 51, 30, -3, -51 },
  { 2477, 36, 52, 39, 2, -51 },
  { 2711, 29, 51, 39, 6, -51 },
  { 2896, 40, 51, 39, -2, -51 },
  { 3151, 38, 52, 39, 0, -51 },
  { 3398, 39, 51, 39, -1, -51 },
  { 3647, 38, 52, 39, 1, -51 },
  { 3894, 37, 52, 39, 3, -51 },
  { 4135, 39, 51, 39, 3, -51 },
  { 4384, 37, 52, 39, 2, -51 },
  { 4625, 35, 52, 39, 3, -51 },
  { 4853, 18, 40, 20, 1, -39 },
  { 4943, 23, 48, 20, -4, -39 },
  { 5081, 34, 37, 41, 4, -44 },
  { 5239, 34, 22, 41, 4, -36 },
  { 5333, 34, 37, 41, 4, -44 },
  { 5491, 30, 52, 33, 5, -51 },
  { 5686, 57, 57, 61, 3, -51 },
  { 6093, 44, 51, 45, -4, -51 },
  { 6374, 41, 51, 44, 2, -51 },
  { 6636, 42, 52, 44, 4, -51 },
  { 6909, 44, 51, 48, 2, -51 },
  { 7190, 39, 51, 39, 2, -51 },
  { 7439, 39, 51, 38, 2, -51 },
  { 7688, 44, 52, 49, 4, -51 },
  { 7974, 48, 51, 50, 2, -51 },
  { 8280, 33, 51, 27, -2, -51 },
  { 8491, 35, 66, 24, -11, -51 },
  { 8780, 48, 51, 44, 2, -51 },
  { 9086, 30, 51, 37, 2, -51 },
  { 9278, 61, 51, 62, 2, -51 },
  { 9667, 52, 51, 54, 2, -51 },
  { 9999, 46, 52, 52, 4, -51 },
  { 10298, 42, 51, 43, 2, -51 },
  { 10566, 46, 63, 52, 4, -51 },
  { 10929, 40, 51, 44, 2, -51 },
  { 11184, 37, 52, 38, 1, -51 },
  { 11425, 37, 51, 38, 6, -51 },
  { 11661, 45, 52, 49, 5, -51 },
  { 11954, 42, 51, 42, 6, -51 },
  { 12222, 64, 51, 63, 6, -51 },
  { 12630, 53, 51, 43, -4, -51 },
  { 12968, 41, 51, 40, 6, -51 },
  { 13230, 44, 51, 38, -2, -51 },
  { 13511, 29, 62, 24, -1, -51 },
  { 13736, 17, 51, 30, 8, -51 },
  { 13845, 30, 62, 24, -5, -51 },
  { 14078, 36, 33, 39, 1, -51 },
  { 14227, 29, 5, 28, -6, 6 },
  { 14246, 15, 11, 23, 10, -54 },
  { 14267, 38, 40, 42, 3, -39 },
  { 14457, 38, 55, 42, 1, -54 },
  { 14719, 32, 40, 34, 3, -39 },
  { 14879, 41, 55, 42, 3, -54 },
  { 15161, 35, 40, 40, 3, -39 },
  { 15336, 42, 71, 27, -8, -54 },
  { 15709, 40, 56, 42, 1, -39 },
  { 15989, 38, 54, 43, 1, -54 },
  { 16246, 22, 54, 21, 1, -54 },
  { 16395, 32, 71, 21, -9, -54 },
  { 16679, 43, 54, 40, 1, -54 },
  { 16970, 22, 54, 21, 1, -54 },
  { 17119, 60, 39, 64, 1, -39 },
  { 17412, 38, 39, 43, 1, -39 },
  { 17598, 35, 40, 42, 3, -39 },
  { 17773, 41, 56, 42, -2, -39 },
  { 18060, 38, 56, 42, 3, -39 },
  { 18326, 32, 39, 30, 1, -39 },
  { 18482, 31, 40, 34, 1, -39 },
  { 18637, 27, 48, 29, 3, -47 },
  { 18799, 38, 40, 43, 4, -39 },
  { 18989, 36, 39, 36, 4, -39 },
  { 19165, 56, 39, 56, 4, -39 },
  { 19438, 45, 39, 38, -4, -39 },
  { 19658, 46, 56, 37, -5, -39 },
  { 19980, 35, 39, 33, -1, -39 },
  { 20151, 30, 62, 25, 0, -51 },
  { 20384, 7, 70, 39, 16, -54 },
  { 20446, 29, 62, 25, -4, -51 },
  { 20671, 34, 12, 41, 4, -31 },
};

const GFXfont NotoSans_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_BOLDITALIC71PT7B_H_
