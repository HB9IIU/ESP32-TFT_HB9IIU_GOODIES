#ifndef _NOTOSANS_BOLDITALIC37PT7B_H_
#define _NOTOSANS_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x7C, 0xFB, 0xC7, 0xDE, 0x3D, 0xF1, 0xEF, 0x8F,
  0x78, 0xFB, 0xC7, 0x9E, 0x3C, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0x78, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFD, 0xCE, 0x1F, 0x38, 0x03, 0xE6, 0x00, 0x7C, 0xC0,
  0x0F, 0xD8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xBF, 0x00, 0x67, 0xE8, 0x0C, 0xFD,
  0xC3, 0xBF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x40, 0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x0F, 0x83, 0xFF, 0x80, 0xF0,
  0x7C, 0xF8, 0x1E, 0x07, 0xCF, 0x83, 0xC0, 0x78, 0xF8, 0x7C, 0x0F, 0x8F,
  0x87, 0x80, 0xF8, 0xF8, 0xF0, 0x0F, 0x8F, 0x1E, 0x00, 0xF8, 0xF3, 0xE0,
  0x0F, 0x9F, 0x3C, 0xFC, 0xF9, 0xE7, 0x9F, 0xEF, 0xFE, 0xFB, 0xFF, 0x7F,
  0xDF, 0x7F, 0xF3, 0xF9, 0xE7, 0xCF, 0x0E, 0x3C, 0xF8, 0xF0, 0x07, 0xCF,
  0x8F, 0x00, 0xF8, 0xF0, 0xF0, 0x0F, 0x0F, 0x0F, 0x01, 0xE0, 0xF1, 0xF0,
  0x3E, 0x0F, 0x1F, 0x03, 0xC0, 0xF3, 0xE0, 0x78, 0x0F, 0xFE, 0x0F, 0x00,
  0xFF, 0xC1, 0xF0, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFC, 0x7F, 0xF0, 0x7C, 0x7F, 0xFC, 0x7E, 0x7F,
  0x7E, 0x3E, 0x3F, 0x1F, 0xBF, 0x3F, 0x07, 0xFF, 0x1F, 0x83, 0xFF, 0x0F,
  0xC0, 0xFF, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x7E, 0x03, 0xFE, 0x3F, 0x80, 0x7D, 0xE7,
  0xBE, 0xFB, 0xCF, 0x3C, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x01, 0x03, 0xC0, 0x70, 0xF0, 0x1F, 0x38,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x3C,
  0x7F, 0xC0, 0x3F, 0x78, 0x1F, 0x9E, 0x03, 0xC7, 0xC0, 0x61, 0xF0, 0x08,
  0x3C, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x18, 0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x1F, 0x3F, 0x03,
  0xE7, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF, 0x3E, 0x7C, 0x38,
  0xF8, 0x41, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xE1,
  0xFC, 0x0C, 0x07, 0xE0, 0x40, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x30, 0x3F, 0x02,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC8, 0x00, 0xFC, 0xF0, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x80,
  0x1F, 0xCF, 0x07, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF3, 0xF0, 0x3E, 0xFF, 0x0F, 0xBF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xC7, 0xE7, 0xE0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C,
  0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0xFE, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F,
  0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0x81, 0xFD, 0xF8, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0,
  0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x3F, 0x07, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x83, 0xE7, 0xE0,
  0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xBE, 0x1F, 0xDF, 0x83,
  0xC7, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x88, 0x3F,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0x01,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x7C, 0x1F, 0x8F, 0xE3, 0xF0, 0x7C,
  0x00, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF3, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEE, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE7,
  0xC1, 0xFF, 0x8F, 0x3C, 0x1F, 0xFC, 0x7B, 0xC1, 0xFF, 0xE3, 0xDE, 0x1F,
  0x1E, 0x1F, 0xE1, 0xF0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0xF0, 0x3C,
  0x3F, 0xC7, 0x83, 0xC1, 0xFE, 0x3C, 0x1E, 0x1F, 0xF1, 0xE0, 0xF0, 0xF7,
  0x8F, 0x0F, 0x8F, 0xBC, 0x78, 0xFC, 0xF9, 0xE3, 0xFF, 0xFF, 0x8F, 0x0F,
  0xF7, 0xF8, 0x7C, 0x3F, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x08, 0x00, 0xFE, 0x03, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF8,
  0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC1,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xC1, 0xE1, 0xFC, 0x01, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x02, 0x07,
  0xFC, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xC0,
  0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87,
  0xE0, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0x07, 0xF0, 0x02, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0xFF, 0xDF, 0x83, 0xFF, 0xBF, 0x07, 0xFE, 0x7E, 0x0F,
  0xFC, 0xFC, 0x1F, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F,
  0x87, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x3F,
  0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x0F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xEF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x78, 0x1E, 0xF8, 0x1F, 0x7C,
  0x3E, 0xF8, 0x1F, 0x7C, 0x3C, 0xF8, 0x1F, 0x7C, 0x7C, 0xF8, 0x3E, 0x3C,
  0x79, 0xF8, 0x3E, 0x3C, 0xF9, 0xF0, 0x3E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3D,
  0xF1, 0xF0, 0x3E, 0x3D, 0xE1, 0xF0, 0x7C, 0x3F, 0xE3, 0xF0, 0x7C, 0x3F,
  0xC3, 0xE0, 0x7C, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xF8, 0x3F,
  0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x03, 0xE0,
  0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x0F, 0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xF0,
  0x7E, 0x0F, 0x3E, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F,
  0x8F, 0x87, 0xC1, 0xF1, 0xF1, 0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x83, 0xE7,
  0xC1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0xFB, 0xC1, 0xF8,
  0x1F, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0x7F, 0xE0, 0xF8, 0x07, 0xFC,
  0x1F, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0x9F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC3,
  0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x3F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0x83, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF1, 0x00, 0x7E, 0x3C, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7C, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F,
  0x87, 0xC0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x00, 0xF0, 0xF8, 0x03,
  0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x01, 0xF3, 0xF0, 0x1F,
  0x80, 0xFC, 0xFC, 0x0F, 0xE0, 0x3E, 0x1F, 0x03, 0xF8, 0x1F, 0x87, 0xC1,
  0xFE, 0x07, 0xE1, 0xF0, 0x7F, 0xC1, 0xF0, 0x7C, 0x3F, 0xF0, 0xFC, 0x1F,
  0x0F, 0xFC, 0x3E, 0x07, 0xC7, 0xDF, 0x1F, 0x81, 0xF1, 0xF7, 0xC7, 0xC0,
  0x7C, 0x79, 0xF1, 0xF0, 0x1F, 0x3E, 0x7C, 0xF8, 0x07, 0xCF, 0x1F, 0x3E,
  0x01, 0xF7, 0xC7, 0xDF, 0x80, 0x7D, 0xF1, 0xF7, 0xC0, 0x1F, 0x78, 0x7D,
  0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xEF, 0x07, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7,
  0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F,
  0x07, 0xC3, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0,
  0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7E, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0x80, 0x00, 0xFE,
  0x3C, 0x3F, 0xEF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xEF, 0x03, 0xF1, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x20, 0x0F, 0x9F, 0x81, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFC, 0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7C,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xCF, 0xF8, 0x78, 0xFC, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x3F, 0x02, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x04, 0xFE, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x10, 0x7C, 0x07, 0xF3, 0xE0, 0x7F,
  0xDF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF7, 0x80, 0x7F, 0x3C,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xDF,
  0xCF, 0xC3, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x06, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x8F,
  0x07, 0xFD, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF8, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE1, 0xF8, 0x7E,
  0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFD, 0xF0, 0x1F, 0x9F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x80, 0x7E, 0x0F, 0x9F, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x10, 0x0F, 0x9F, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F,
  0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0xBF, 0x03, 0xE7, 0xE0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7E, 0xFC, 0x0F, 0x9F, 0x81, 0xF3,
  0xE0, 0x3E, 0x7C, 0x0F, 0xC0, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0x02, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x01, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0x80, 0x7C, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x1E, 0x3F, 0x07, 0xF0, 0x3D, 0xFF, 0x1F, 0xF0, 0xFB,
  0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0xFF, 0x8F, 0xC7, 0xE0,
  0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x3F, 0x03, 0xE0, 0x7C, 0x7E, 0x0F,
  0xC0, 0xF8, 0xF8, 0x1F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0xE7, 0xE0, 0x7C,
  0x0F, 0xCF, 0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x3E, 0x3E, 0x07, 0xE0,
  0xFC, 0x7C, 0x0F, 0x81, 0xF9, 0xF8, 0x1F, 0x03, 0xF3, 0xF0, 0x3E, 0x07,
  0xC7, 0xC0, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x3F, 0x00, 0x00, 0x06, 0x01,
  0xE3, 0xF8, 0x3D, 0xFF, 0x8F, 0xBF, 0xF1, 0xFF, 0xFE, 0x3F, 0x87, 0xC7,
  0xE0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x1F, 0x9F,
  0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C,
  0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF8, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC3,
  0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7E, 0xFC,
  0x7F, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0x00, 0x1E, 0x7F, 0x00, 0xF7, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xF8, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC7, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7D, 0xFF, 0x03, 0xE7, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x3C, 0x3F,
  0xEF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x7F, 0x1F, 0xFF,
  0xE1, 0xFF, 0x7C, 0x3F, 0xDF, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x0F, 0x1F, 0x0F, 0x3F,
  0x1F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x60, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xFD, 0xF0, 0xF8,
  0x10, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xC0, 0x7E,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x43, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0,
  0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC,
  0x1F, 0x8F, 0x81, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0, 0xFF, 0xEF, 0x0F,
  0xFE, 0xF0, 0x7F, 0xDF, 0x03, 0xF1, 0xF0, 0xF8, 0x07, 0xFF, 0x01, 0xFB,
  0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x81, 0xFF, 0xC0,
  0xFC, 0x0F, 0xBE, 0x0F, 0xE0, 0xFD, 0xF0, 0x7F, 0x07, 0xCF, 0x87, 0xB8,
  0x7E, 0x3C, 0x3D, 0xC3, 0xE1, 0xE1, 0xFE, 0x1F, 0x0F, 0x1E, 0xF1, 0xF0,
  0x78, 0xF7, 0x8F, 0x83, 0xCF, 0xBC, 0xF8, 0x1E, 0x79, 0xE7, 0xC0, 0xF7,
  0xCF, 0x7E, 0x07, 0xBC, 0x7B, 0xE0, 0x3D, 0xE3, 0xDF, 0x01, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF3, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x07, 0xC0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03,
  0xE1, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xEF, 0x80, 0x01,
  0xEF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 26, 11, 0, -26 },
  { 40, 13, 9, 17, 4, -26 },
  { 55, 23, 26, 24, 1, -26 },
  { 130, 19, 30, 20, 1, -28 },
  { 202, 28, 27, 32, 2, -27 },
  { 297, 25, 27, 26, 1, -27 },
  { 382, 6, 9, 9, 4, -26 },
  { 389, 14, 32, 13, 1, -26 },
  { 445, 14, 33, 13, -3, -27 },
  { 503, 18, 18, 20, 3, -28 },
  { 544, 18, 18, 21, 2, -22 },
  { 585, 9, 9, 11, -2, -4 },
  { 596, 10, 4, 12, 1, -12 },
  { 601, 7, 6, 11, 0, -6 },
  { 607, 20, 27, 16, -2, -27 },
  { 675, 19, 27, 20, 1, -27 },
  { 740, 15, 26, 20, 3, -26 },
  { 789, 21, 27, 20, -1, -27 },
  { 860, 20, 27, 20, 0, -27 },
  { 928, 20, 26, 20, 0, -26 },
  { 993, 20, 26, 20, 0, -26 },
  { 1058, 19, 27, 20, 2, -27 },
  { 1123, 21, 26, 20, 1, -26 },
  { 1192, 19, 27, 20, 1, -27 },
  { 1257, 18, 27, 20, 2, -27 },
  { 1318, 10, 21, 11, 0, -21 },
  { 1345, 12, 26, 11, -2, -21 },
  { 1384, 18, 19, 21, 2, -23 },
  { 1427, 18, 11, 21, 2, -19 },
  { 1452, 18, 19, 21, 2, -23 },
  { 1495, 15, 27, 17, 3, -27 },
  { 1546, 29, 29, 32, 2, -26 },
  { 1652, 23, 26, 23, -2, -26 },
  { 1727, 22, 26, 23, 1, -26 },
  { 1799, 22, 27, 23, 2, -27 },
  { 1874, 23, 26, 25, 1, -26 },
  { 1949, 20, 26, 20, 1, -26 },
  { 2014, 20, 26, 20, 1, -26 },
  { 2079, 23, 27, 26, 2, -27 },
  { 2157, 25, 26, 26, 1, -26 },
  { 2239, 17, 26, 14, -1, -26 },
  { 2295, 19, 34, 12, -6, -26 },
  { 2376, 25, 26, 23, 1, -26 },
  { 2458, 16, 26, 19, 1, -26 },
  { 2510, 32, 26, 33, 1, -26 },
  { 2614, 27, 26, 28, 1, -26 },
  { 2702, 24, 27, 27, 2, -27 },
  { 2783, 22, 26, 23, 1, -26 },
  { 2855, 24, 33, 27, 2, -27 },
  { 2954, 21, 26, 23, 1, -26 },
  { 3023, 19, 27, 20, 1, -27 },
  { 3088, 19, 26, 20, 3, -26 },
  { 3150, 23, 26, 26, 3, -26 },
  { 3225, 22, 26, 22, 3, -26 },
  { 3297, 34, 26, 33, 3, -26 },
  { 3408, 27, 26, 23, -2, -26 },
  { 3496, 21, 26, 21, 3, -26 },
  { 3565, 23, 26, 20, -1, -26 },
  { 3640, 16, 32, 12, -1, -26 },
  { 3704, 9, 27, 16, 4, -27 },
  { 3735, 15, 32, 12, -2, -26 },
  { 3795, 18, 18, 20, 1, -27 },
  { 3836, 15, 3, 15, -3, 3 },
  { 3842, 8, 6, 12, 5, -28 },
  { 3848, 19, 21, 22, 2, -21 },
  { 3898, 19, 28, 22, 1, -28 },
  { 3965, 16, 21, 18, 2, -21 },
  { 4007, 21, 28, 22, 2, -28 },
  { 4081, 18, 21, 21, 2, -21 },
  { 4129, 22, 37, 14, -4, -28 },
  { 4231, 20, 30, 22, 1, -21 },
  { 4306, 19, 28, 22, 1, -28 },
  { 4373, 11, 28, 11, 1, -28 },
  { 4412, 17, 37, 11, -5, -28 },
  { 4491, 22, 28, 21, 1, -28 },
  { 4568, 11, 28, 11, 1, -28 },
  { 4607, 31, 21, 33, 1, -21 },
  { 4689, 19, 21, 22, 1, -21 },
  { 4739, 18, 21, 22, 2, -21 },
  { 4787, 21, 30, 22, -1, -21 },
  { 4866, 19, 30, 22, 2, -21 },
  { 4938, 16, 21, 16, 1, -21 },
  { 4980, 17, 21, 18, 0, -21 },
  { 5025, 14, 25, 15, 2, -25 },
  { 5069, 20, 20, 22, 2, -20 },
  { 5119, 19, 20, 19, 2, -20 },
  { 5167, 29, 20, 29, 2, -20 },
  { 5240, 24, 20, 20, -2, -20 },
  { 5300, 24, 29, 19, -3, -20 },
  { 5387, 19, 20, 17, -1, -20 },
  { 5435, 16, 32, 13, 0, -26 },
  { 5499, 4, 36, 20, 8, -28 },
  { 5517, 15, 32, 13, -2, -26 },
  { 5577, 18, 6, 21, 2, -16 },
};

const GFXfont NotoSans_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_BOLDITALIC37PT7B_H_
