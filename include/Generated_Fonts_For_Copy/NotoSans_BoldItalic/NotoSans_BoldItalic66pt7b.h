#ifndef _NOTOSANS_BOLDITALIC66PT7B_H_
#define _NOTOSANS_BOLDITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC,
  0x3F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xCF,
  0x87, 0x80, 0x7F, 0xE3, 0xE0, 0x60, 0x1F, 0xF0, 0xF0, 0x00, 0x07, 0xFC,
  0x3C, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x7F, 0xC7, 0xC0, 0x00, 0x1F,
  0xF9, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0xF8, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x00,
  0xF9, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x0F, 0x0F, 0xF8, 0x80,
  0x07, 0xC7, 0xFE, 0x38, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x78, 0xFF, 0xE3,
  0xFF, 0x1E, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF8,
  0xFF, 0x1F, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xFF, 0xCF, 0xF1, 0xFF,
  0x3F, 0xC7, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFE, 0x3F, 0xE3, 0xFC, 0xFF, 0xFC, 0x7F, 0x1F, 0xF0, 0xFF, 0x0F,
  0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xC0, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0xFF,
  0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x1E,
  0x01, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x01, 0xFF,
  0xDF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF,
  0x80, 0x10, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x38, 0x0F, 0xF8,
  0x00, 0x20, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x1F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFB, 0xFE, 0x1F, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xE0,
  0x7C, 0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFE, 0x00,
  0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xFE, 0x00,
  0x18, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x08, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0x80, 0x01,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xCF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x38,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x08, 0x00,
  0x00, 0xFF, 0xE1, 0x80, 0x00, 0x3F, 0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x05,
  0xE8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x03, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFD, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0,
  0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xDF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x07, 0xFF,
  0xC0, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x1F, 0xE0, 0xFF, 0xE3, 0xE0, 0x0F, 0xFC, 0x70, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFC, 0x1F, 0xC3,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x07,
  0xF8, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xCF, 0xF0, 0x1F, 0xFC, 0x7F,
  0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF7, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xBF, 0x81, 0xFC, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xEF, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC7, 0xF0,
  0x3F, 0xC1, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xBF, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xCF,
  0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFF, 0x00,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF,
  0x80, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0xF1, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0xF0, 0x07,
  0xFF, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xF7, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF7, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0x7F, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x01, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x9F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x7F, 0x80,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0x0F, 0xFE,
  0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x81, 0x00, 0x00, 0x3F, 0xF0,
  0x38, 0x00, 0x0F, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF3,
  0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x0F, 0xF1,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x3F, 0x81, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x7F, 0x0F, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x81, 0xFC,
  0x7F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF8, 0x00, 0x1F, 0xE7,
  0xFC, 0x07, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x3F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x02, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xF3, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF,
  0x87, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x03,
  0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF,
  0xBF, 0xFF, 0x00, 0x3F, 0xEF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF,
  0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0x7F, 0xF8, 0x01, 0x81, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x40, 0xFF, 0xF0, 0x07, 0x01, 0xFF, 0xF0, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80,
  0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFE,
  0xFF, 0x00, 0x07, 0xFF, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0x8F, 0xF0, 0x00,
  0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x7F, 0xF8, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x0C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFF, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0x9F, 0xF0, 0x07,
  0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x07, 0xFF,
  0x9F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x00, 0x0F, 0xFC, 0x01, 0xC0,
  0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x0F,
  0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xF8, 0x01, 0xFF,
  0xBF, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x04, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0xFE,
  0x1F, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xFF,
  0xF0, 0x00, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF,
  0xFF, 0x00, 0x3F, 0xEF, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xFF, 0xC0, 0x03,
  0xFE, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x38,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFC, 0x00, 0xFF,
  0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFB, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFB, 0xFE, 0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xE0, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x7F, 0xF0, 0x1F, 0xE7, 0xFF, 0x80,
  0xFF, 0x3F, 0xF8, 0x07, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFC, 0x0F, 0xFC, 0x01, 0xE0, 0x7F, 0xE0, 0x02, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0x00, 0x01,
  0xFF, 0x8C, 0x00, 0x1F, 0xFC, 0x7C, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x0E, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFB, 0xFC, 0x07, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xCF, 0xF0, 0x07,
  0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xFE, 0x07, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0xC7, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0x7F, 0x87, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xF0,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80,
  0xFE, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0xC1, 0xFE,
  0x07, 0xFB, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x07, 0xFE, 0x07,
  0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0xF0,
  0x1F, 0xE0, 0xFE, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF,
  0x80, 0x7F, 0x87, 0xF1, 0xFE, 0x3F, 0xF0, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xFC, 0x01, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0x80, 0x3F, 0xC7, 0xF0, 0xFF,
  0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0x83,
  0xFD, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFE,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0xFD, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x1F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x87, 0xFF, 0x80,
  0x00, 0xCF, 0xFF, 0xF0, 0x00, 0xEF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x70, 0x00, 0x7F, 0xFE, 0x20, 0x00,
  0x07, 0xFC, 0x00,
};

const GFXglyph NotoSans_BoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 20, 48, 19, 1, -47 },
  { 121, 25, 17, 30, 6, -47 },
  { 175, 42, 47, 43, 1, -47 },
  { 422, 34, 54, 36, 2, -50 },
  { 652, 50, 49, 57, 4, -48 },
  { 959, 44, 49, 47, 2, -48 },
  { 1229, 12, 17, 17, 6, -47 },
  { 1255, 25, 57, 22, 2, -47 },
  { 1434, 25, 58, 23, -5, -48 },
  { 1616, 31, 31, 36, 6, -50 },
  { 1737, 33, 32, 38, 3, -39 },
  { 1869, 16, 17, 19, -3, -8 },
  { 1903, 19, 8, 21, 1, -22 },
  { 1922, 11, 11, 19, 1, -10 },
  { 1938, 36, 48, 28, -3, -48 },
  { 2154, 34, 49, 36, 2, -48 },
  { 2363, 26, 47, 36, 6, -47 },
  { 2516, 37, 48, 36, -2, -48 },
  { 2738, 36, 49, 36, 0, -48 },
  { 2959, 37, 47, 36, -1, -47 },
  { 3177, 35, 48, 36, 1, -47 },
  { 3387, 34, 49, 36, 3, -48 },
  { 3596, 36, 47, 36, 3, -47 },
  { 3808, 34, 49, 36, 2, -48 },
  { 4017, 32, 49, 36, 3, -48 },
  { 4213, 17, 38, 19, 1, -37 },
  { 4294, 22, 46, 19, -4, -37 },
  { 4421, 33, 34, 38, 3, -41 },
  { 4562, 33, 20, 38, 3, -33 },
  { 4645, 33, 34, 38, 3, -41 },
  { 4786, 27, 49, 30, 5, -48 },
  { 4952, 53, 53, 57, 3, -47 },
  { 5304, 41, 47, 41, -4, -47 },
  { 5545, 38, 47, 41, 2, -47 },
  { 5769, 39, 49, 40, 4, -48 },
  { 6008, 41, 47, 45, 2, -47 },
  { 6249, 36, 47, 36, 2, -47 },
  { 6461, 36, 47, 35, 2, -47 },
  { 6673, 41, 49, 46, 4, -48 },
  { 6925, 45, 47, 46, 2, -47 },
  { 7190, 31, 47, 25, -2, -47 },
  { 7373, 32, 61, 22, -10, -47 },
  { 7617, 45, 47, 40, 2, -47 },
  { 7882, 28, 47, 34, 2, -47 },
  { 8047, 56, 47, 58, 2, -47 },
  { 8376, 48, 47, 50, 2, -47 },
  { 8658, 42, 49, 48, 4, -48 },
  { 8916, 39, 47, 40, 2, -47 },
  { 9146, 42, 59, 48, 4, -48 },
  { 9456, 37, 47, 41, 2, -47 },
  { 9674, 35, 49, 35, 1, -48 },
  { 9889, 35, 47, 35, 5, -47 },
  { 10095, 42, 48, 46, 4, -47 },
  { 10347, 39, 47, 39, 6, -47 },
  { 10577, 59, 47, 59, 6, -47 },
  { 10924, 49, 47, 40, -4, -47 },
  { 11212, 37, 47, 37, 6, -47 },
  { 11430, 41, 47, 35, -2, -47 },
  { 11671, 27, 57, 22, -1, -47 },
  { 11864, 16, 48, 28, 7, -48 },
  { 11960, 27, 57, 22, -4, -47 },
  { 12153, 34, 30, 36, 1, -47 },
  { 12281, 27, 4, 26, -6, 6 },
  { 12295, 13, 11, 21, 10, -51 },
  { 12313, 35, 38, 39, 3, -37 },
  { 12480, 35, 51, 39, 1, -50 },
  { 12704, 30, 38, 32, 3, -37 },
  { 12847, 38, 51, 39, 3, -50 },
  { 13090, 32, 38, 37, 3, -37 },
  { 13242, 39, 66, 25, -7, -50 },
  { 13564, 37, 53, 39, 1, -37 },
  { 13810, 36, 50, 40, 1, -50 },
  { 14035, 20, 50, 20, 1, -50 },
  { 14160, 29, 66, 20, -8, -50 },
  { 14400, 40, 50, 37, 1, -50 },
  { 14650, 21, 50, 20, 1, -50 },
  { 14782, 55, 37, 60, 1, -37 },
  { 15037, 36, 37, 40, 1, -37 },
  { 15204, 33, 38, 39, 3, -37 },
  { 15361, 38, 53, 39, -2, -37 },
  { 15613, 35, 53, 39, 3, -37 },
  { 15845, 29, 37, 28, 1, -37 },
  { 15980, 29, 38, 31, 1, -37 },
  { 16118, 25, 45, 27, 3, -44 },
  { 16259, 35, 37, 40, 4, -36 },
  { 16421, 35, 36, 34, 3, -36 },
  { 16579, 51, 36, 52, 4, -36 },
  { 16809, 41, 36, 35, -3, -36 },
  { 16994, 43, 52, 34, -5, -36 },
  { 17274, 33, 36, 31, -1, -36 },
  { 17423, 28, 57, 23, 0, -47 },
  { 17623, 7, 65, 36, 15, -50 },
  { 17680, 27, 57, 23, -3, -47 },
  { 17873, 33, 11, 38, 3, -29 },
};

const GFXfont NotoSans_BoldItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_BOLDITALIC66PT7B_H_
