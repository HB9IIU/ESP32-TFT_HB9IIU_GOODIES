#ifndef _NOTOSANS_BOLDITALIC7PT7B_H_
#define _NOTOSANS_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x33, 0xD5, 0xE6, 0x00, 0x76, 0x65, 0xE0, 0x6A,
  0xCD, 0xCD, 0x58, 0x72, 0x9B, 0x6F, 0x80, 0xC0, 0x6A, 0x49, 0x80, 0x55,
  0x60, 0xCF, 0x00, 0x2F, 0x20, 0xC0, 0xC0, 0x80, 0x25, 0x28, 0x75, 0x9A,
  0xE0, 0x75, 0x80, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x36, 0x6F, 0x20,
  0x74, 0x62, 0xE0, 0x74, 0xF9, 0x60, 0x73, 0x24, 0xC0, 0x75, 0x69, 0xE0,
  0x69, 0x72, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xE0,
  0xD8, 0x80, 0x39, 0x7B, 0x6F, 0x40, 0xC0, 0x35, 0x5F, 0x90, 0x75, 0x65,
  0xF0, 0x7A, 0x31, 0x87, 0x00, 0x72, 0xD4, 0xAE, 0x00, 0x75, 0x64, 0xE0,
  0x74, 0x64, 0x80, 0x3A, 0x3F, 0xA7, 0x00, 0x4A, 0x5C, 0xA9, 0x00, 0x69,
  0x2C, 0x24, 0x95, 0x80, 0x5B, 0x98, 0xC9, 0x00, 0x49, 0x2E, 0x6D, 0xB7,
  0x6E, 0xA8, 0x6B, 0x5B, 0x39, 0x00, 0x72, 0x73, 0xB7, 0x00, 0x75, 0x74,
  0x80, 0x72, 0x73, 0xB7, 0x08, 0x75, 0x76, 0x90, 0x74, 0x62, 0xE0, 0xEA,
  0x48, 0x4A, 0x55, 0xA7, 0x00, 0xBA, 0xCC, 0x80, 0xA6, 0xAE, 0xBC, 0x90,
  0x5A, 0x98, 0xC9, 0x00, 0xBE, 0xC8, 0x80, 0x72, 0x64, 0xE0, 0x69, 0x49,
  0x80, 0xF8, 0x55, 0x60, 0x26, 0x90, 0xE0, 0x80, 0x75, 0x9E, 0x47, 0x59,
  0xE0, 0x7A, 0x30, 0x17, 0x59, 0xE0, 0x6F, 0x86, 0x37, 0x22, 0x44, 0xC0,
  0x75, 0x9E, 0x2C, 0x47, 0x59, 0xA0, 0x56, 0x80, 0x24, 0xB4, 0xA0, 0x45,
  0x6E, 0xB0, 0x56, 0x80, 0x7D, 0x59, 0x6B, 0x75, 0x9A, 0x6D, 0x96, 0x75,
  0x9E, 0x88, 0x75, 0x9E, 0x22, 0x6A, 0x40, 0x79, 0xF0, 0x5D, 0x2C, 0x55,
  0x9E, 0x9A, 0x64, 0xB6, 0xED, 0x94, 0x56, 0x6A, 0x96, 0x64, 0x48, 0x65,
  0x70, 0x69, 0x69, 0x80, 0xFE, 0x49, 0xA9, 0x00, 0xF0,
};

const GFXglyph NotoSans_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 6, 5, 6, 0, -5 },
  { 15, 5, 5, 5, 0, -5 },
  { 19, 1, 2, 2, 1, -5 },
  { 20, 3, 6, 2, 0, -5 },
  { 23, 2, 6, 2, 0, -5 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 2, 5, 4, 1, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 4, 3, 4, 0, -4 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 6, 6, 6, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 5, 5, 4, 0, -5 },
  { 89, 5, 5, 5, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 5, 5, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -5 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 3, 6, 2, -1, -5 },
  { 112, 5, 5, 4, 0, -5 },
  { 116, 3, 5, 4, 0, -5 },
  { 118, 6, 5, 6, 0, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 5, 5, 5, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 5, 6, 5, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 3, 5, 4, 1, -5 },
  { 145, 5, 5, 5, 0, -5 },
  { 149, 4, 5, 4, 1, -5 },
  { 152, 6, 5, 6, 1, -5 },
  { 156, 5, 5, 4, 0, -5 },
  { 160, 4, 5, 4, 1, -5 },
  { 163, 4, 5, 4, 0, -5 },
  { 166, 3, 6, 2, 0, -5 },
  { 169, 1, 5, 3, 1, -5 },
  { 170, 2, 6, 2, 0, -5 },
  { 172, 4, 3, 4, 0, -5 },
  { 174, 3, 1, 3, -1, 0 },
  { 175, 1, 1, 2, 1, -5 },
  { 176, 4, 4, 4, 0, -4 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 4, 5, 4, 0, -5 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 7, 3, -1, -5 },
  { 192, 4, 6, 4, 0, -4 },
  { 195, 4, 5, 4, 0, -5 },
  { 198, 2, 5, 2, 0, -5 },
  { 200, 3, 7, 2, -1, -5 },
  { 203, 4, 5, 4, 0, -5 },
  { 206, 2, 5, 2, 0, -5 },
  { 208, 6, 4, 6, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 4, 6, 4, 0, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 3, 4, 3, 0, -4 },
  { 225, 3, 5, 3, 0, -5 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 6, 4, 6, 0, -4 },
  { 234, 4, 4, 4, 0, -4 },
  { 236, 4, 6, 4, 0, -4 },
  { 239, 3, 4, 3, 0, -4 },
  { 241, 3, 6, 2, 0, -5 },
  { 244, 1, 7, 4, 1, -5 },
  { 245, 3, 6, 2, 0, -5 },
  { 248, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_BOLDITALIC7PT7B_H_
