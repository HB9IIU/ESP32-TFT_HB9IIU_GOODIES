#ifndef _NOTOSANS_BOLDITALIC16PT7B_H_
#define _NOTOSANS_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0x80, 0x07, 0x38, 0xDE, 0xE7, 0x20, 0x0C,
  0x83, 0x60, 0x99, 0xFF, 0x1B, 0x06, 0xCF, 0xFF, 0xFE, 0x36, 0x09, 0x86,
  0xC0, 0x06, 0x0F, 0xCF, 0xC6, 0xA3, 0x41, 0xE0, 0x7C, 0x1E, 0x0B, 0x77,
  0xBF, 0x82, 0x01, 0x00, 0x30, 0x07, 0x86, 0xD8, 0xCD, 0x98, 0xDB, 0x0D,
  0xAE, 0xF7, 0xF6, 0xDB, 0x19, 0xB1, 0x9B, 0x31, 0xE6, 0x1E, 0x0C, 0x0F,
  0xC3, 0x30, 0xCC, 0x36, 0x0F, 0x07, 0x8F, 0xF6, 0xCF, 0xB1, 0xCF, 0xF1,
  0xFE, 0xFA, 0x1C, 0xC6, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1,
  0x80, 0x18, 0x61, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x71, 0x8C,
  0x00, 0x0C, 0x48, 0xE8, 0x3F, 0x39, 0x6C, 0x2E, 0x08, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x36, 0x6C, 0x7F, 0x80, 0xFC, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00,
  0x08, 0x3E, 0x76, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0xCE, 0xCE, 0xFC, 0x78,
  0x1E, 0x7B, 0xF2, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC0, 0x0C, 0x1F,
  0x9D, 0xC4, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xDF, 0xC0,
  0x0C, 0x1F, 0x8C, 0xE0, 0x70, 0x30, 0xF0, 0x78, 0x4E, 0x03, 0x43, 0xBF,
  0x9F, 0x80, 0x07, 0x83, 0x83, 0xC3, 0x63, 0x73, 0x33, 0x99, 0xFE, 0xFF,
  0x07, 0x03, 0x00, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0xE3, 0xF8, 0x1C, 0x0E,
  0x87, 0x7F, 0x3F, 0x00, 0x06, 0x1F, 0x39, 0x60, 0xE0, 0xDE, 0xEE, 0xC6,
  0xC6, 0xCE, 0xFC, 0x78, 0x7F, 0xFF, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x30, 0x38, 0x00, 0x06, 0x0F, 0x8E, 0xE6, 0x33, 0x30, 0xF0,
  0xF8, 0xEE, 0x63, 0x71, 0x9F, 0xC7, 0xC0, 0x18, 0x7E, 0x66, 0xE7, 0xC7,
  0xC6, 0xFE, 0x76, 0x0E, 0x0C, 0xFC, 0xF0, 0x33, 0x30, 0x00, 0x0E, 0xE0,
  0x18, 0xC6, 0x00, 0x00, 0x06, 0x63, 0x30, 0x01, 0x07, 0x1C, 0x70, 0xE0,
  0x78, 0x1E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x3C, 0xF0, 0xC0, 0x19, 0xF9, 0xB8, 0x30, 0xC7, 0x8C, 0x30, 0x00,
  0x03, 0x87, 0x00, 0x1F, 0xE1, 0xC3, 0x98, 0x0D, 0x9F, 0x2C, 0xD9, 0xEC,
  0xCA, 0x66, 0xD3, 0x66, 0xDF, 0xE6, 0x00, 0x18, 0x20, 0x7F, 0x00, 0x03,
  0x81, 0xE0, 0x78, 0x36, 0x1D, 0x86, 0x73, 0xFC, 0xFF, 0x70, 0xD8, 0x3E,
  0x0C, 0x1F, 0x8F, 0xF3, 0x9C, 0xC6, 0x3F, 0x8F, 0xC7, 0x39, 0xC6, 0x63,
  0x9F, 0xCF, 0xE0, 0x06, 0x0F, 0xCF, 0x6E, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xE0, 0x70, 0x1F, 0x87, 0xC0, 0x1F, 0x8F, 0xF3, 0x8C, 0xC3, 0x30, 0xCC,
  0x37, 0x1D, 0xC7, 0x63, 0x9F, 0xCF, 0xE0, 0x1F, 0x9F, 0xCE, 0x06, 0x03,
  0xF1, 0xF9, 0xC0, 0xE0, 0x60, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xCE, 0x06,
  0x03, 0xF1, 0xF9, 0xF8, 0xE0, 0x60, 0x30, 0x38, 0x00, 0x07, 0x07, 0xF3,
  0xD9, 0xC0, 0x60, 0x38, 0x0E, 0x7B, 0x1E, 0xE3, 0xB8, 0xC7, 0xF0, 0xFC,
  0x18, 0x67, 0x1C, 0xE3, 0x98, 0x63, 0xFC, 0x7F, 0x9C, 0x73, 0x8E, 0x61,
  0x8C, 0x33, 0x8E, 0x00, 0x3E, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x71,
  0xF3, 0xE0, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0xF8, 0xF8, 0x18, 0xE7, 0x38, 0xEE, 0x1B, 0x83, 0xE0, 0x7C,
  0x1D, 0x83, 0xB8, 0x67, 0x0C, 0x63, 0x8E, 0x00, 0x18, 0x70, 0xE1, 0x83,
  0x06, 0x1C, 0x38, 0x60, 0xFF, 0xF8, 0x1C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF,
  0x1E, 0x3C, 0xD8, 0xD3, 0x67, 0x5B, 0x99, 0x6C, 0x67, 0x31, 0x9C, 0xCE,
  0x63, 0x00, 0x1C, 0x33, 0xC3, 0x3E, 0x73, 0x66, 0x36, 0x63, 0x76, 0x73,
  0x66, 0x3E, 0x63, 0xC6, 0x1C, 0xE1, 0xC0, 0x06, 0x07, 0xE3, 0xBD, 0xC7,
  0x60, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xB8, 0xE7, 0xF0, 0xF8, 0x1F, 0x8F,
  0xF3, 0x9C, 0xC7, 0x31, 0xCF, 0xE7, 0xE1, 0xC0, 0x60, 0x18, 0x0E, 0x00,
  0x06, 0x07, 0xE3, 0xBD, 0xC7, 0x60, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xB8,
  0xE7, 0xF0, 0xF8, 0x06, 0x01, 0xC0, 0x38, 0x1F, 0x8E, 0xE3, 0x9C, 0xC6,
  0x33, 0x8F, 0xC7, 0xE1, 0xDC, 0x63, 0x18, 0xCE, 0x38, 0x06, 0x0F, 0xCE,
  0xC6, 0x03, 0x01, 0xE0, 0x78, 0x1C, 0x06, 0x43, 0x3F, 0x9F, 0x80, 0x7F,
  0xFF, 0x86, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x00,
  0x30, 0xDC, 0x77, 0x1D, 0x86, 0x61, 0xB8, 0x6E, 0x3B, 0x8C, 0xE7, 0x3F,
  0xC7, 0xE0, 0xE1, 0xD8, 0xE6, 0x31, 0x8C, 0x66, 0x19, 0x86, 0xC1, 0xB0,
  0x78, 0x1E, 0x07, 0x00, 0xE3, 0x8F, 0xC7, 0x19, 0x9E, 0x73, 0x3C, 0xC6,
  0xDB, 0x8D, 0xB6, 0x1E, 0x6C, 0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0x81, 0xC7,
  0x00, 0x1C, 0x71, 0xCE, 0x0D, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xB8, 0x3B, 0x87, 0x18, 0xE1, 0xC0, 0xE3, 0xD8, 0xC7, 0x61, 0xF8, 0x3C,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0x3F, 0x9F, 0xC1, 0xC1,
  0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x7F, 0xBF, 0x80, 0x3C, 0xC3, 0x0C,
  0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xF3, 0x80, 0xCC, 0xCC, 0xC4, 0x66,
  0x66, 0x67, 0x1E, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x8F, 0x1E, 0x00, 0x0E, 0x0E, 0x1E, 0x12, 0x33, 0x63, 0xC1, 0xFF, 0xF0,
  0xE7, 0x3B, 0x7F, 0x67, 0xE7, 0xC6, 0xC6, 0xCE, 0xFE, 0xFC, 0x18, 0x0C,
  0x0E, 0x06, 0xE3, 0xF1, 0x9D, 0xCE, 0xC7, 0x63, 0xB1, 0x9F, 0xDB, 0xC0,
  0x3E, 0xFF, 0x87, 0x0C, 0x18, 0x30, 0x7E, 0x7C, 0x03, 0x81, 0xC0, 0xC7,
  0x67, 0xF3, 0x3B, 0x9D, 0x8C, 0xC6, 0x67, 0x3F, 0x8E, 0x80, 0x1C, 0x7E,
  0x67, 0xC6, 0xFE, 0xE0, 0xC0, 0xFC, 0x7C, 0x03, 0xC1, 0xE0, 0x60, 0x3E,
  0x1F, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x0F, 0x03, 0x80, 0x1D, 0x9F, 0xCC, 0xEE, 0x76, 0x33, 0x19, 0x9C, 0xFE,
  0x7F, 0x03, 0x23, 0x9F, 0x87, 0x80, 0x18, 0x0C, 0x0E, 0x06, 0xE3, 0xF9,
  0xDD, 0xCE, 0xE7, 0x63, 0x31, 0x98, 0xDC, 0xE0, 0x19, 0xC0, 0x73, 0x19,
  0xCE, 0x63, 0x19, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC1, 0x87, 0x0E, 0x18,
  0x30, 0x61, 0xC3, 0x86, 0x3C, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC7, 0x33,
  0x8D, 0xC7, 0xE1, 0xF0, 0x7E, 0x1B, 0x86, 0x73, 0x9C, 0x18, 0xCE, 0x63,
  0x19, 0xCE, 0x63, 0x19, 0xC0, 0x37, 0x38, 0xFF, 0xE3, 0xBD, 0xDC, 0xE7,
  0x73, 0x99, 0x8C, 0x66, 0x31, 0x98, 0xCE, 0xE7, 0x38, 0x37, 0x1F, 0xCE,
  0xEE, 0x77, 0x3B, 0x19, 0x8C, 0xC6, 0xE7, 0x00, 0x3C, 0x7E, 0xE7, 0xE7,
  0xC7, 0xC6, 0xC6, 0xFE, 0x78, 0x1B, 0x87, 0xE1, 0x9C, 0xE7, 0x31, 0xCC,
  0x73, 0x18, 0xFE, 0x7F, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x3B, 0x7F,
  0x67, 0xE7, 0xC6, 0xC6, 0xCE, 0xFE, 0x7C, 0x0C, 0x0C, 0x1C, 0x1C, 0x36,
  0x7C, 0xEB, 0x87, 0x0C, 0x18, 0x30, 0xE0, 0x3E, 0xFD, 0xC3, 0x83, 0xC3,
  0x83, 0xFE, 0xF8, 0x30, 0xC7, 0xFF, 0x61, 0x8E, 0x38, 0xC3, 0xCF, 0x00,
  0x63, 0x63, 0x63, 0xE7, 0xE6, 0xC6, 0xCE, 0xFE, 0xF6, 0xC7, 0xC6, 0xCE,
  0xCC, 0xDC, 0xD8, 0x58, 0x70, 0x70, 0xC6, 0x3C, 0xE7, 0xCE, 0x6D, 0xA6,
  0xDA, 0xCD, 0x2C, 0xF3, 0x8F, 0x38, 0xE3, 0x80, 0x39, 0xC6, 0x61, 0xB0,
  0x7C, 0x0E, 0x07, 0x83, 0xF1, 0xDC, 0xE3, 0x80, 0x31, 0xCC, 0x63, 0x38,
  0xCC, 0x3B, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xC0, 0xE0,
  0x00, 0x3F, 0x7E, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xFC, 0xFC, 0x0E, 0x38,
  0x60, 0xC3, 0x0E, 0x30, 0x30, 0x70, 0xC1, 0x83, 0x07, 0x02, 0x00, 0xFF,
  0xFF, 0x18, 0x78, 0x30, 0xC1, 0x83, 0x83, 0x8E, 0x30, 0x60, 0xC3, 0x8E,
  0x10, 0x00, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 5, 0, -11 },
  { 8, 5, 4, 7, 2, -11 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 9, 13, 9, 0, -12 },
  { 40, 12, 12, 14, 1, -12 },
  { 58, 10, 12, 11, 1, -12 },
  { 73, 2, 4, 4, 2, -11 },
  { 74, 6, 14, 5, 1, -11 },
  { 85, 6, 15, 5, -1, -12 },
  { 97, 8, 8, 9, 1, -12 },
  { 105, 8, 8, 9, 1, -10 },
  { 113, 4, 4, 5, -1, -2 },
  { 115, 5, 2, 5, 0, -5 },
  { 117, 3, 2, 5, 0, -2 },
  { 118, 9, 12, 7, -1, -12 },
  { 132, 8, 12, 9, 1, -12 },
  { 144, 7, 11, 9, 1, -11 },
  { 154, 9, 12, 9, 0, -12 },
  { 168, 9, 12, 9, 0, -12 },
  { 182, 9, 11, 9, 0, -11 },
  { 195, 9, 11, 9, 0, -11 },
  { 208, 8, 12, 9, 1, -12 },
  { 220, 9, 11, 9, 1, -11 },
  { 233, 9, 12, 9, 0, -12 },
  { 247, 8, 12, 9, 1, -12 },
  { 259, 4, 9, 5, 0, -9 },
  { 264, 5, 11, 5, -1, -9 },
  { 271, 8, 8, 9, 1, -10 },
  { 279, 8, 5, 9, 1, -8 },
  { 284, 8, 8, 9, 1, -10 },
  { 292, 7, 12, 7, 1, -12 },
  { 303, 13, 12, 14, 1, -11 },
  { 323, 10, 11, 10, -1, -11 },
  { 337, 10, 11, 10, 0, -11 },
  { 351, 9, 12, 10, 1, -12 },
  { 365, 10, 11, 11, 0, -11 },
  { 379, 9, 11, 9, 0, -11 },
  { 392, 9, 11, 9, 0, -11 },
  { 405, 10, 12, 11, 1, -12 },
  { 420, 11, 11, 11, 0, -11 },
  { 436, 7, 11, 6, 0, -11 },
  { 446, 8, 14, 5, -3, -11 },
  { 460, 11, 11, 10, 0, -11 },
  { 476, 7, 11, 8, 0, -11 },
  { 486, 14, 11, 14, 0, -11 },
  { 506, 12, 11, 12, 0, -11 },
  { 523, 10, 12, 12, 1, -12 },
  { 538, 10, 11, 10, 0, -11 },
  { 552, 10, 15, 12, 1, -12 },
  { 571, 10, 11, 10, 0, -11 },
  { 585, 9, 12, 8, 0, -12 },
  { 599, 9, 11, 9, 1, -11 },
  { 612, 10, 11, 11, 1, -11 },
  { 626, 10, 11, 9, 1, -11 },
  { 640, 15, 11, 14, 1, -11 },
  { 661, 12, 11, 10, -1, -11 },
  { 678, 10, 11, 9, 1, -11 },
  { 692, 9, 11, 9, 0, -11 },
  { 705, 6, 14, 5, 0, -11 },
  { 716, 4, 12, 7, 2, -12 },
  { 722, 7, 14, 5, -1, -11 },
  { 735, 8, 7, 9, 0, -11 },
  { 742, 6, 2, 6, -1, 1 },
  { 744, 4, 2, 5, 2, -12 },
  { 745, 8, 9, 9, 1, -9 },
  { 754, 9, 12, 10, 0, -12 },
  { 768, 7, 9, 8, 1, -9 },
  { 776, 9, 12, 10, 1, -12 },
  { 790, 8, 9, 9, 1, -9 },
  { 799, 10, 16, 6, -2, -12 },
  { 819, 9, 13, 10, 0, -9 },
  { 834, 9, 12, 10, 0, -12 },
  { 848, 5, 12, 5, 0, -12 },
  { 856, 7, 16, 5, -2, -12 },
  { 870, 10, 12, 9, 0, -12 },
  { 885, 5, 12, 5, 0, -12 },
  { 893, 14, 9, 14, 0, -9 },
  { 909, 9, 9, 10, 0, -9 },
  { 920, 8, 9, 9, 1, -9 },
  { 929, 10, 13, 10, -1, -9 },
  { 946, 8, 13, 10, 1, -9 },
  { 959, 7, 9, 7, 0, -9 },
  { 967, 7, 9, 8, 0, -9 },
  { 975, 6, 11, 7, 1, -11 },
  { 984, 8, 9, 10, 1, -9 },
  { 993, 8, 9, 8, 1, -9 },
  { 1002, 12, 9, 13, 1, -9 },
  { 1016, 10, 9, 9, -1, -9 },
  { 1028, 10, 13, 8, -1, -9 },
  { 1045, 8, 9, 8, 0, -9 },
  { 1054, 7, 14, 6, 0, -11 },
  { 1067, 1, 16, 9, 4, -12 },
  { 1069, 7, 14, 6, -1, -11 },
  { 1082, 8, 3, 9, 1, -7 },
};

const GFXfont NotoSans_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_BOLDITALIC16PT7B_H_
