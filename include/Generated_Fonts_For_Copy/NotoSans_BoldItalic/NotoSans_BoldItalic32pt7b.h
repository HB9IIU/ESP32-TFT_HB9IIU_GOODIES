#ifndef _NOTOSANS_BOLDITALIC32PT7B_H_
#define _NOTOSANS_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x7C, 0xF7, 0x9F, 0x79, 0xE7, 0x9E,
  0x71, 0xE7, 0x1C, 0xF1, 0xCE, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x03,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x8E, 0x00, 0x71, 0xE0,
  0x07, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC1, 0xE3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF9, 0x98, 0x7C, 0xC0, 0x3E, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0x7C, 0x01, 0xBE, 0x41, 0xDF, 0x38, 0xCF, 0x9F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0x80, 0x3F, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x80, 0x3C, 0x3F, 0xC0, 0x38, 0x3F, 0xC0, 0x78, 0x79, 0xE0, 0xF0,
  0x79, 0xE1, 0xE0, 0xF1, 0xE1, 0xC0, 0xF1, 0xE3, 0xC0, 0xF1, 0xE7, 0x80,
  0xF3, 0xCF, 0x00, 0xF3, 0xCE, 0x7C, 0xF7, 0xDE, 0xFE, 0xFF, 0xBD, 0xFF,
  0x7F, 0x7B, 0xEF, 0x3E, 0x73, 0xCF, 0x00, 0xF3, 0xCF, 0x01, 0xE7, 0x8F,
  0x03, 0xC7, 0x8F, 0x03, 0x87, 0x8F, 0x07, 0x87, 0x9E, 0x0F, 0x07, 0x9E,
  0x1E, 0x07, 0xFE, 0x1C, 0x03, 0xFC, 0x3C, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x78, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC1, 0xF3, 0xFF, 0x0F, 0xBF, 0x7C, 0xF9, 0xF3, 0xF7,
  0x9F, 0x0F, 0xFC, 0xF8, 0x3F, 0xC7, 0xC1, 0xFC, 0x3F, 0x07, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x8F, 0xC0, 0x7D, 0xE7,
  0x9E, 0x71, 0xCF, 0x38, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x03, 0x1E, 0x0F,
  0xB8, 0x1F, 0xF0, 0xDF, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0x80, 0xF7,
  0x03, 0xEF, 0x03, 0x8E, 0x02, 0x1E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF0, 0xFF, 0xFF,
  0xBF, 0xDF, 0xE0, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x0F, 0x7C, 0x0F,
  0x7C, 0x0F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x3F,
  0xE3, 0xFF, 0x7F, 0xF3, 0xF7, 0x8E, 0x7C, 0x23, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0x87, 0xC0, 0x81, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x01, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x60, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xA0, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xBC, 0x07, 0xFE, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xC7,
  0x83, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1, 0xE3, 0xE0, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0C, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xCC, 0x07, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0xF0, 0x3E, 0xFE, 0x1E, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xE7, 0xE0, 0xF3,
  0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C,
  0x78, 0x3C, 0x3E, 0x3E, 0x1F, 0x3E, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFF, 0xC3, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x1E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x9F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80,
  0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFE, 0x3F, 0xDE, 0x0F, 0xBE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x07,
  0xC7, 0xE3, 0xF1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0xF1, 0xF8, 0xFC, 0x3C, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F,
  0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x30, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0x83, 0xC0, 0x01, 0xE1,
  0xE0, 0x7C, 0x3C, 0xF0, 0xFF, 0xCF, 0x38, 0x7F, 0xF3, 0xDE, 0x3E, 0x38,
  0x77, 0x8F, 0x1E, 0x1D, 0xC7, 0x87, 0x8F, 0x71, 0xE1, 0xE3, 0xFC, 0x70,
  0x70, 0xFF, 0x1C, 0x3C, 0x3B, 0xC7, 0x0F, 0x1E, 0xF1, 0xE7, 0xCF, 0x1C,
  0x7F, 0xFF, 0x87, 0x8F, 0xDF, 0xC1, 0xE1, 0xC1, 0xC0, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x0F,
  0x9E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03,
  0xC1, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF8, 0x7E, 0x1E, 0x0F, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7C, 0x3F,
  0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x18, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x18, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0x8F, 0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7,
  0xC1, 0xF8, 0x7C, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC0, 0xC3, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0xEF, 0x83, 0xFC, 0xF8,
  0x7F, 0xCF, 0x87, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0xC0, 0xF8, 0x7E, 0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x9F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03,
  0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xB8, 0x0E, 0xF0, 0xF7, 0x03, 0xFE,
  0x1E, 0xE0, 0x77, 0xC3, 0xDE, 0x1E, 0xF0, 0xFB, 0xC7, 0x9E, 0x1F, 0x78,
  0xF3, 0xC3, 0xCF, 0x3C, 0xF8, 0x79, 0xE7, 0x9F, 0x0F, 0x3D, 0xE3, 0xC3,
  0xE7, 0xBC, 0x78, 0x7C, 0xFF, 0x1F, 0x0F, 0x1F, 0xE3, 0xE1, 0xE3, 0xF8,
  0x78, 0x3C, 0x7F, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x1F, 0xC0, 0x3C, 0x3F, 0x80, 0x78,
  0x7F, 0x01, 0xF0, 0xFF, 0x03, 0xE3, 0xFE, 0x07, 0x87, 0xBC, 0x0F, 0x0F,
  0x7C, 0x3E, 0x1E, 0xF8, 0x7C, 0x3C, 0xF0, 0xF0, 0xF9, 0xF1, 0xE1, 0xF3,
  0xE3, 0xC3, 0xC3, 0xCF, 0x87, 0x87, 0xDF, 0x0F, 0x0F, 0xBC, 0x3E, 0x0F,
  0x78, 0x7C, 0x1F, 0xF0, 0xF0, 0x3F, 0xE1, 0xE0, 0x3F, 0xC3, 0xC0, 0x7F,
  0x0F, 0x80, 0xFE, 0x1F, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xF0,
  0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xC0, 0x7C, 0x7C, 0x1F, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x7F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xC0, 0xFC,
  0x7C, 0x1F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F,
  0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x80, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x1F, 0x06, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x80, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E,
  0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7,
  0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C,
  0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x3F,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x3E, 0x3E, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0x81, 0xE1,
  0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0xF8,
  0x0F, 0xBC, 0x07, 0xC0, 0x7D, 0xE0, 0x3E, 0x07, 0xCF, 0x03, 0xF0, 0x3E,
  0x78, 0x1F, 0x81, 0xE3, 0xC1, 0xFC, 0x1F, 0x1E, 0x0F, 0xE0, 0xF0, 0xF0,
  0xF7, 0x8F, 0x87, 0x87, 0xBC, 0x78, 0x3C, 0x79, 0xE7, 0xC1, 0xE3, 0xCF,
  0x3E, 0x0F, 0x1E, 0x79, 0xE0, 0x79, 0xE3, 0xDF, 0x03, 0xCF, 0x1E, 0xF0,
  0x1E, 0xF0, 0xFF, 0x80, 0xF7, 0x87, 0xF8, 0x07, 0xB8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0,
  0x00, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xC7, 0xC0,
  0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0xFC, 0x03, 0xF0, 0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0x81, 0xF1, 0xF0, 0x7C,
  0x7C, 0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0xC0, 0xF3, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x0F, 0x3C, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFB, 0xE7, 0x9F, 0x3C, 0x70, 0x01, 0xC0, 0x41, 0xFD, 0xE0, 0xFF,
  0x78, 0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F,
  0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xBC, 0x07, 0xCF, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0xE0, 0x3E, 0xFC, 0x1E, 0xFF, 0x0F, 0xFF, 0x8F, 0xC7, 0xC7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xDF, 0xE1,
  0xC7, 0xE0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xF0, 0xC7,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x82, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x71, 0xE0, 0x3F, 0xBC, 0x0F, 0xF7, 0x83, 0xFF, 0xF0,
  0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7E, 0x3F, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xF9, 0xE0, 0x00, 0xF0, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x7E, 0x7F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x04, 0x7E, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x20, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x4F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x41, 0xFD, 0xE0, 0xFF, 0x78, 0x7F, 0xFE, 0x3F, 0x1F,
  0x8F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF,
  0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7F, 0xBC, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x30, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x70, 0x3E, 0xFC, 0x1E, 0xFF, 0x0F, 0xFF, 0xCF, 0xE3, 0xE7,
  0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xE0, 0x78, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x27, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x08, 0xF8, 0x7E, 0x1F, 0x1F, 0x83,
  0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF3, 0xE0, 0x3C,
  0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0x81, 0xF0, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x1C, 0x0F, 0x07, 0x9F, 0x8F, 0xE1,
  0xEF, 0xF7, 0xFC, 0x7F, 0xFD, 0xFF, 0x3F, 0x9F, 0xE7, 0xCF, 0xC3, 0xF0,
  0xF3, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x1F, 0x3C, 0x1F, 0x07, 0xDF, 0x07,
  0xC1, 0xF7, 0xC1, 0xF0, 0x79, 0xF0, 0x78, 0x1E, 0x78, 0x1E, 0x0F, 0x9E,
  0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3C, 0xF8, 0x3C, 0x1F,
  0x3C, 0x1F, 0x07, 0xC0, 0x00, 0x1C, 0x0F, 0x3F, 0x07, 0xBF, 0xC3, 0xFF,
  0xF3, 0xF8, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x0F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0xF7, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3D, 0xFE, 0x07,
  0x9F, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0xFB, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0xBE, 0x07, 0x9F, 0x03, 0xCF, 0x83,
  0xE7, 0xE3, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xBC, 0x0F, 0xBE, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x79, 0xE1, 0xEF, 0x87, 0xFE,
  0x3F, 0xF8, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xE0, 0x87, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0x90, 0x1F, 0x3C, 0x7E, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xFF, 0xBF, 0xF9, 0xFF, 0xD3, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x3E, 0x0F,
  0x9E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0,
  0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1E, 0x0F, 0x8F,
  0x8F, 0xC7, 0xFF, 0xE3, 0xFE, 0xF1, 0xFE, 0x70, 0x7E, 0x78, 0x00, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF0, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF0, 0x7E, 0x0F,
  0xF8, 0x3F, 0x0F, 0xBC, 0x3F, 0x87, 0x9E, 0x1F, 0xC7, 0xCF, 0x1F, 0xE3,
  0xE7, 0x8F, 0xF3, 0xE3, 0xC7, 0x79, 0xF1, 0xE7, 0xBC, 0xF0, 0xF3, 0x9E,
  0xF8, 0x7B, 0xCF, 0x78, 0x3D, 0xE7, 0xFC, 0x0E, 0xE3, 0xFC, 0x07, 0xF1,
  0xFE, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xF8, 0x3F, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x3E, 0x1F, 0x00, 0xF1, 0xF0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFB,
  0xE0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xF0, 0xFC, 0x0F, 0x80,
  0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0xF8, 0x07, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0x7B,
  0xE0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x7F, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0,
  0x00, 0x3C, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
};

const GFXglyph NotoSans_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 23, 9, 0, -23 },
  { 30, 12, 8, 15, 3, -23 },
  { 42, 20, 23, 21, 1, -23 },
  { 100, 17, 26, 18, 1, -24 },
  { 156, 24, 23, 27, 2, -23 },
  { 225, 21, 23, 23, 1, -23 },
  { 286, 6, 8, 8, 3, -23 },
  { 292, 12, 28, 11, 1, -23 },
  { 334, 12, 28, 11, -2, -23 },
  { 376, 15, 15, 17, 3, -24 },
  { 405, 15, 15, 18, 2, -19 },
  { 434, 8, 8, 9, -2, -4 },
  { 442, 9, 4, 10, 1, -11 },
  { 447, 6, 5, 9, 0, -5 },
  { 451, 17, 23, 14, -1, -23 },
  { 500, 16, 23, 18, 1, -23 },
  { 546, 13, 23, 18, 3, -23 },
  { 584, 18, 23, 18, -1, -23 },
  { 636, 17, 23, 18, 0, -23 },
  { 685, 17, 23, 18, 0, -23 },
  { 734, 18, 23, 18, 0, -23 },
  { 786, 17, 23, 18, 1, -23 },
  { 835, 18, 23, 18, 1, -23 },
  { 887, 17, 23, 18, 1, -23 },
  { 936, 16, 23, 18, 1, -23 },
  { 982, 9, 18, 9, 0, -18 },
  { 1003, 11, 22, 9, -2, -18 },
  { 1034, 15, 17, 18, 2, -20 },
  { 1066, 15, 9, 18, 2, -16 },
  { 1083, 15, 17, 18, 2, -20 },
  { 1115, 14, 23, 15, 2, -23 },
  { 1156, 26, 26, 27, 1, -23 },
  { 1241, 20, 23, 20, -2, -23 },
  { 1299, 19, 23, 20, 1, -23 },
  { 1354, 19, 23, 20, 2, -23 },
  { 1409, 20, 23, 22, 1, -23 },
  { 1467, 17, 23, 17, 1, -23 },
  { 1516, 17, 23, 17, 1, -23 },
  { 1565, 20, 23, 22, 2, -23 },
  { 1623, 22, 23, 22, 1, -23 },
  { 1687, 15, 23, 12, -1, -23 },
  { 1731, 16, 30, 11, -5, -23 },
  { 1791, 22, 23, 20, 1, -23 },
  { 1855, 13, 23, 17, 1, -23 },
  { 1893, 27, 23, 28, 1, -23 },
  { 1971, 23, 23, 24, 1, -23 },
  { 2038, 20, 23, 23, 2, -23 },
  { 2096, 19, 23, 20, 1, -23 },
  { 2151, 20, 28, 23, 2, -23 },
  { 2221, 18, 23, 20, 1, -23 },
  { 2273, 16, 23, 17, 1, -23 },
  { 2319, 16, 23, 17, 3, -23 },
  { 2365, 20, 23, 22, 2, -23 },
  { 2423, 19, 23, 19, 3, -23 },
  { 2478, 29, 23, 29, 3, -23 },
  { 2562, 24, 23, 20, -2, -23 },
  { 2631, 18, 23, 18, 3, -23 },
  { 2683, 20, 23, 17, -1, -23 },
  { 2741, 14, 28, 11, -1, -23 },
  { 2790, 8, 23, 14, 3, -23 },
  { 2813, 13, 28, 11, -2, -23 },
  { 2859, 16, 15, 18, 1, -23 },
  { 2889, 13, 2, 13, -3, 3 },
  { 2893, 6, 6, 10, 5, -25 },
  { 2898, 18, 18, 19, 1, -18 },
  { 2939, 17, 24, 19, 1, -24 },
  { 2990, 15, 18, 15, 1, -18 },
  { 3024, 19, 24, 19, 1, -24 },
  { 3081, 16, 18, 18, 1, -18 },
  { 3117, 19, 32, 12, -3, -24 },
  { 3193, 18, 26, 19, 1, -18 },
  { 3252, 17, 24, 19, 1, -24 },
  { 3303, 9, 24, 10, 1, -24 },
  { 3330, 14, 32, 10, -4, -24 },
  { 3386, 19, 24, 18, 1, -24 },
  { 3443, 10, 24, 10, 1, -24 },
  { 3473, 26, 18, 29, 1, -18 },
  { 3532, 17, 18, 19, 1, -18 },
  { 3571, 16, 18, 19, 1, -18 },
  { 3607, 19, 26, 19, -1, -18 },
  { 3669, 17, 26, 19, 1, -18 },
  { 3725, 14, 18, 14, 1, -18 },
  { 3757, 15, 18, 15, 0, -18 },
  { 3791, 13, 21, 13, 1, -21 },
  { 3826, 17, 17, 19, 2, -17 },
  { 3863, 16, 17, 16, 2, -17 },
  { 3897, 25, 17, 25, 2, -17 },
  { 3951, 21, 17, 17, -2, -17 },
  { 3996, 20, 25, 17, -2, -17 },
  { 4059, 16, 17, 15, -1, -17 },
  { 4093, 13, 28, 11, 0, -23 },
  { 4139, 4, 31, 18, 7, -24 },
  { 4155, 13, 28, 11, -2, -23 },
  { 4201, 15, 5, 18, 2, -14 },
};

const GFXfont NotoSans_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_BOLDITALIC32PT7B_H_
