#ifndef _NOTOSANS_BOLDITALIC42PT7B_H_
#define _NOTOSANS_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x3E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xE0,
  0x3F, 0x00, 0x40, 0x00, 0x3E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x78,
  0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE1, 0xF0, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x3C, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xEE, 0xF0, 0x7F, 0x38, 0x41, 0xF9, 0xC0, 0x07, 0xE7,
  0x00, 0x1F, 0xDC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x77, 0xF0, 0x01, 0xCF, 0xC0, 0x07, 0x3F, 0x20, 0x1C, 0xFC, 0xE0, 0x67,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x0F, 0xFC, 0x00, 0xF8, 0x1F, 0xFC,
  0x01, 0xF0, 0x3F, 0xFE, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x7E, 0x3E,
  0x07, 0xC0, 0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x1F, 0x00, 0xFC, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0xF8, 0x00, 0xF8, 0xFC, 0xF9, 0xFC, 0xFC, 0xF9, 0xF3, 0xFE, 0x7F, 0xFB,
  0xE7, 0xFF, 0x7F, 0xF3, 0xCF, 0xFF, 0x3F, 0xE7, 0xDF, 0x9F, 0x1F, 0xCF,
  0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x3F, 0x1F, 0x00, 0x3E,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0xF0,
  0x3E, 0x3F, 0x01, 0xF0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x7E, 0x07, 0xC0,
  0x3F, 0xFC, 0x07, 0xC0, 0x1F, 0xFC, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xF0, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF,
  0x07, 0xE3, 0xFF, 0xF8, 0x7E, 0x7F, 0x1F, 0xCF, 0xC7, 0xF0, 0xFF, 0xFC,
  0x7E, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0x80, 0xFF, 0xE1, 0xFC, 0x3E,
  0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xF3, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x60, 0xF8, 0x07, 0x8F, 0x80,
  0xFC, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x21, 0xFF, 0x80, 0x3F, 0x7C, 0x07, 0xE7,
  0xC0, 0x3E, 0x3E, 0x01, 0xC3, 0xE0, 0x08, 0x3F, 0x00, 0x01, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3,
  0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x08, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x80,
  0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0x7E, 0x7E, 0x7C, 0xFC, 0x30, 0xFC, 0x20, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xE0, 0xFE, 0x01, 0xC0, 0x7F, 0x01, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x70, 0x3F, 0xC0, 0x40,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x40,
  0x01, 0xF8, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x03,
  0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x08, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x20, 0x03, 0xF8, 0xC0, 0x1F, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F, 0xE0, 0x7E, 0xFF,
  0xC1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xF7, 0xF8, 0xFF, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0x81, 0xFD, 0xFC,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xF1,
  0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xF8, 0x7F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0,
  0xFF, 0x7F, 0xBF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF3, 0xFF, 0xFE, 0x0F,
  0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x80, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F,
  0x80, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8E, 0x07, 0xF2, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0xFE, 0x0F, 0x8F, 0x81, 0xFF, 0xE3, 0xE3, 0xE0, 0xFF, 0xF8,
  0x79, 0xF0, 0x7F, 0xFE, 0x1E, 0x7C, 0x3F, 0x0F, 0x87, 0xDE, 0x1F, 0x83,
  0xC1, 0xFF, 0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xE0, 0x7C, 0x1E, 0xF8, 0xF8,
  0x1F, 0x0F, 0xBE, 0x3E, 0x07, 0x83, 0xEF, 0x0F, 0x83, 0xE0, 0xFB, 0xC3,
  0xE0, 0xF8, 0x7C, 0xF8, 0xF8, 0x7E, 0x1F, 0x3E, 0x3E, 0x3F, 0x8F, 0x8F,
  0x8F, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0x7F, 0xE0, 0x78, 0x3F, 0x8F, 0xF0,
  0x1F, 0x03, 0xC1, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F,
  0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x7E,
  0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0x87, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3,
  0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xE0, 0x78, 0x3F, 0xC0, 0x08, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x3F, 0xC0,
  0x70, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x7F,
  0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xF8, 0x7F,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0x03, 0xFC, 0x00,
  0x40, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xFF,
  0x1F, 0x81, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0x7E, 0x07, 0xFF, 0x1F, 0xC0,
  0xFF, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0x7F,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00,
  0x7F, 0x3F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xFD, 0xE0, 0x1F, 0x7C, 0x0F, 0xDE, 0x03,
  0xEF, 0xC0, 0xFD, 0xE0, 0x3E, 0xFC, 0x0F, 0x9E, 0x07, 0xCF, 0xC0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x1F, 0x9F, 0x0F, 0x9F, 0x81, 0xF9, 0xF0, 0xF9, 0xF8,
  0x1F, 0x9F, 0x1F, 0x1F, 0x81, 0xF1, 0xF1, 0xF1, 0xF0, 0x1F, 0x1F, 0x3E,
  0x3F, 0x03, 0xF1, 0xF3, 0xE3, 0xF0, 0x3F, 0x1F, 0x7C, 0x3F, 0x03, 0xF1,
  0xF7, 0xC3, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x07, 0xE1, 0xFF, 0x87, 0xE0,
  0x7E, 0x1F, 0xF0, 0x7E, 0x07, 0xE1, 0xFF, 0x07, 0xE0, 0x7C, 0x1F, 0xE0,
  0x7E, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0xFC, 0x0F,
  0xF0, 0x01, 0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF,
  0xC0, 0x1F, 0x81, 0xFF, 0xC0, 0x3F, 0x03, 0xFF, 0x80, 0x7C, 0x07, 0xDF,
  0x01, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x3F, 0x7E, 0x07, 0xE0, 0x7E, 0x7C,
  0x0F, 0xC0, 0xF8, 0xFC, 0x1F, 0x01, 0xF1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x0F, 0xC7,
  0xC0, 0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x3F, 0x7E,
  0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0xFF, 0xE0,
  0x7E, 0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0x81, 0xF8, 0x03, 0xFE, 0x03,
  0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x87,
  0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E,
  0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE7, 0xF0,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xE7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0xCF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0x81, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x20, 0x03, 0xF0, 0xE0, 0x3F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFA, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x01,
  0xF8, 0x0F, 0x81, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xEF, 0xC0,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0x07,
  0xF3, 0xF0, 0x1F, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x80, 0xFE, 0x3F, 0x03,
  0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0, 0x7D, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x3F, 0x07, 0xDF, 0x0F, 0xC0, 0xFC, 0x3E,
  0x7C, 0x3F, 0x03, 0xF0, 0xF9, 0xF0, 0xFC, 0x0F, 0xC7, 0xE7, 0xC7, 0xE0,
  0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x7C, 0xFC, 0x03, 0xF3, 0xE1,
  0xF3, 0xF0, 0x0F, 0xCF, 0x87, 0xCF, 0x80, 0x3F, 0x7C, 0x1F, 0x7E, 0x00,
  0xFD, 0xF0, 0x7D, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E,
  0x01, 0xFC, 0x7C, 0x1F, 0xF9, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8,
  0x7F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0x9F,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0xFD, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0x03,
  0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0x9F, 0xF8, 0x3E, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x81, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x43, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xFE, 0xFC,
  0x0F, 0xFE, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x87, 0xF8,
  0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0,
  0x1F, 0xC7, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0xE3, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E,
  0x07, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x08,
  0xFF, 0x8F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x3E, 0x07, 0xFE,
  0x7C, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF1,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFC, 0x03, 0xF3,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x82, 0x00, 0x7E,
  0x06, 0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0xFD, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x0F, 0xC7,
  0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x7F, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE,
  0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x01, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0x87,
  0xE0, 0x3F, 0x01, 0xF3, 0xFE, 0x1F, 0xF0, 0x3E, 0xFF, 0xE7, 0xFF, 0x07,
  0xDF, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F,
  0xC7, 0xF8, 0x3F, 0xC1, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x3F, 0x8F,
  0xC0, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0x07, 0x87, 0xF0, 0x3E, 0x7F, 0xE0, 0xFB, 0xFF, 0x83,
  0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xC3, 0xF1, 0xFE, 0x0F, 0xC7, 0xF0,
  0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0xFE, 0x7E,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x07,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xF9, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x80,
  0xFE, 0xFC, 0x0F, 0xE7, 0xF0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xE3, 0xF8, 0x03,
  0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x7F, 0xF0, 0x3F,
  0x7F, 0xE0, 0x3F, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x7C, 0x1F, 0xF9, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xBF, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xC3, 0xF7, 0xF0, 0xF9,
  0xFC, 0x3E, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x3C, 0x3F, 0x01,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x98, 0x07, 0xF3, 0xF3, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x07, 0xF0, 0xFC,
  0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0x7C, 0x07, 0xFC, 0xF8, 0x07, 0xF1, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xEF, 0xC0, 0x3F, 0x9F, 0x00, 0xFC, 0x7C, 0x07, 0xF1, 0xF8, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0x7E,
  0xF8, 0x1F, 0xE0, 0xFE, 0xF8, 0x3F, 0xE0, 0xFC, 0xF8, 0x3D, 0xE0, 0xFC,
  0xF8, 0x3D, 0xE1, 0xF8, 0xF8, 0x7D, 0xE1, 0xF8, 0xF8, 0x79, 0xE3, 0xF0,
  0xF8, 0xFB, 0xE3, 0xF0, 0xF8, 0xFB, 0xE7, 0xE0, 0xF9, 0xF3, 0xE7, 0xE0,
  0xF9, 0xF3, 0xE7, 0xC0, 0xF9, 0xE3, 0xEF, 0xC0, 0xFB, 0xE1, 0xEF, 0x80,
  0xFB, 0xE1, 0xEF, 0x80, 0xFB, 0xC1, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC7, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0E,
  0x00, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xF2, 0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 31, 12, 0, -30 },
  { 52, 16, 11, 19, 4, -30 },
  { 74, 26, 30, 27, 1, -30 },
  { 172, 22, 34, 23, 1, -32 },
  { 266, 32, 30, 36, 2, -30 },
  { 386, 28, 30, 30, 1, -30 },
  { 491, 7, 11, 11, 4, -30 },
  { 501, 15, 37, 14, 2, -30 },
  { 571, 16, 37, 14, -3, -30 },
  { 645, 20, 20, 23, 4, -32 },
  { 695, 21, 20, 24, 2, -25 },
  { 748, 10, 10, 12, -2, -5 },
  { 761, 12, 5, 14, 1, -14 },
  { 769, 8, 8, 12, 0, -7 },
  { 777, 23, 30, 18, -2, -30 },
  { 864, 22, 30, 23, 1, -30 },
  { 947, 16, 30, 23, 4, -30 },
  { 1007, 24, 30, 23, -1, -30 },
  { 1097, 23, 30, 23, 0, -30 },
  { 1184, 24, 30, 23, -1, -30 },
  { 1274, 22, 30, 23, 1, -30 },
  { 1357, 22, 30, 23, 2, -30 },
  { 1440, 23, 30, 23, 2, -30 },
  { 1527, 22, 30, 23, 1, -30 },
  { 1610, 20, 30, 23, 2, -30 },
  { 1685, 11, 24, 12, 0, -23 },
  { 1718, 13, 28, 12, -2, -23 },
  { 1764, 21, 22, 24, 2, -26 },
  { 1822, 21, 12, 24, 2, -21 },
  { 1854, 21, 22, 24, 2, -26 },
  { 1912, 18, 31, 19, 3, -30 },
  { 1982, 34, 34, 36, 2, -30 },
  { 2127, 27, 30, 26, -3, -30 },
  { 2229, 25, 30, 26, 1, -30 },
  { 2323, 25, 30, 26, 2, -30 },
  { 2417, 26, 30, 28, 1, -30 },
  { 2515, 23, 30, 23, 1, -30 },
  { 2602, 23, 30, 22, 1, -30 },
  { 2689, 27, 30, 29, 2, -30 },
  { 2791, 29, 30, 29, 1, -30 },
  { 2900, 19, 30, 16, -1, -30 },
  { 2972, 21, 39, 14, -7, -30 },
  { 3075, 29, 30, 26, 1, -30 },
  { 3184, 18, 30, 22, 1, -30 },
  { 3252, 36, 30, 37, 1, -30 },
  { 3387, 31, 30, 32, 1, -30 },
  { 3504, 27, 30, 31, 2, -30 },
  { 3606, 25, 30, 26, 1, -30 },
  { 3700, 27, 37, 31, 2, -30 },
  { 3825, 24, 30, 26, 1, -30 },
  { 3915, 22, 30, 22, 1, -30 },
  { 3998, 22, 30, 22, 3, -30 },
  { 4081, 26, 30, 29, 3, -30 },
  { 4179, 25, 30, 25, 4, -30 },
  { 4273, 38, 30, 38, 4, -30 },
  { 4416, 31, 30, 26, -2, -30 },
  { 4533, 24, 30, 24, 4, -30 },
  { 4623, 26, 30, 23, -1, -30 },
  { 4721, 18, 37, 14, -1, -30 },
  { 4805, 10, 30, 18, 5, -30 },
  { 4843, 18, 37, 14, -3, -30 },
  { 4927, 21, 19, 23, 1, -30 },
  { 4977, 18, 3, 17, -4, 4 },
  { 4984, 9, 7, 14, 6, -32 },
  { 4992, 22, 23, 25, 2, -23 },
  { 5056, 22, 32, 25, 1, -32 },
  { 5144, 19, 23, 20, 2, -23 },
  { 5199, 24, 32, 25, 2, -32 },
  { 5295, 20, 23, 23, 2, -23 },
  { 5353, 24, 42, 16, -4, -32 },
  { 5479, 23, 33, 25, 1, -23 },
  { 5574, 22, 32, 25, 1, -32 },
  { 5662, 12, 32, 13, 1, -32 },
  { 5710, 19, 42, 13, -5, -32 },
  { 5810, 25, 32, 24, 1, -32 },
  { 5910, 13, 32, 13, 1, -32 },
  { 5962, 35, 23, 38, 1, -23 },
  { 6063, 22, 23, 25, 1, -23 },
  { 6127, 21, 23, 25, 2, -23 },
  { 6188, 24, 33, 25, -1, -23 },
  { 6287, 22, 33, 25, 2, -23 },
  { 6378, 18, 23, 18, 1, -23 },
  { 6430, 19, 23, 20, 0, -23 },
  { 6485, 16, 28, 17, 2, -28 },
  { 6541, 23, 23, 25, 2, -23 },
  { 6608, 22, 23, 22, 2, -23 },
  { 6672, 32, 23, 33, 3, -23 },
  { 6764, 26, 23, 22, -2, -23 },
  { 6839, 27, 33, 22, -3, -23 },
  { 6951, 21, 23, 20, -1, -23 },
  { 7012, 18, 37, 15, 0, -30 },
  { 7096, 5, 42, 23, 9, -32 },
  { 7123, 17, 37, 15, -2, -30 },
  { 7202, 21, 7, 24, 2, -18 },
};

const GFXfont NotoSans_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_BOLDITALIC42PT7B_H_
