#ifndef _NOTOSANS_BOLDITALIC19PT7B_H_
#define _NOTOSANS_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x18, 0xF3, 0x80,
  0x6F, 0xDF, 0xB6, 0x6C, 0xC0, 0x06, 0x60, 0x66, 0x06, 0x60, 0xEC, 0x3F,
  0xF7, 0xFF, 0x0D, 0xC1, 0x98, 0x7F, 0xEF, 0xFE, 0x1B, 0x03, 0x30, 0x33,
  0x03, 0x70, 0x03, 0x03, 0xF1, 0xFC, 0xEB, 0x3A, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0x7C, 0xDB, 0xFE, 0x7F, 0x02, 0x01, 0x80, 0x18, 0x18, 0xF8,
  0x71, 0xB8, 0xC7, 0x73, 0x0C, 0xEC, 0x19, 0xB8, 0x37, 0x6F, 0x7D, 0xBE,
  0x76, 0xEE, 0x1D, 0xDC, 0x33, 0x30, 0xC6, 0x63, 0x0F, 0xCE, 0x0F, 0x00,
  0x07, 0x01, 0xF8, 0x3D, 0xC3, 0x9C, 0x39, 0x83, 0xF8, 0x1E, 0x07, 0xE7,
  0xFE, 0x6E, 0x7E, 0xE3, 0xCE, 0x3C, 0xFF, 0xC7, 0xEE, 0x7F, 0xEC, 0x0E,
  0x38, 0x61, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x70, 0x60, 0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0xE1, 0x87, 0x0C, 0x30, 0xE0, 0x10, 0x06, 0x23, 0x1D, 0x0F, 0xF9, 0xFD,
  0xF1, 0xD8, 0x4E, 0x04, 0x00, 0x0C, 0x06, 0x03, 0x1F, 0xFF, 0xF8, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x3B, 0x99, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x00,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x00, 0x0E, 0x1F, 0xCF, 0xEE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xDD, 0xEF, 0xE3, 0xE0, 0x06, 0x3C, 0xFF,
  0xFE, 0xD3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x00, 0x07, 0x07,
  0xE3, 0xFC, 0x47, 0x01, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xBF, 0xE0, 0x0F, 0x0F, 0xF1, 0xFC, 0x47, 0x01, 0xC0, 0xF1,
  0xF0, 0x7C, 0x03, 0x80, 0x60, 0x3A, 0x0E, 0xFF, 0x3F, 0x80, 0x01, 0xC0,
  0xF0, 0x3C, 0x1F, 0x0D, 0x87, 0x63, 0xB9, 0xCE, 0x63, 0xBF, 0xFF, 0xFC,
  0x1C, 0x07, 0x01, 0x80, 0x1F, 0xC7, 0xF1, 0xFC, 0x60, 0x38, 0x0F, 0x03,
  0xF8, 0xFE, 0x03, 0x80, 0x60, 0x3A, 0x1E, 0xFF, 0x3F, 0x80, 0x07, 0xC7,
  0xE3, 0xF8, 0xE0, 0x70, 0x1B, 0x8F, 0xF3, 0xDE, 0xE3, 0xB8, 0xEE, 0x3B,
  0x9C, 0xFF, 0x1F, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x0E, 0x1F,
  0xCE, 0xEE, 0x37, 0x19, 0xDC, 0xF8, 0xFC, 0xE7, 0x61, 0xF0, 0xFC, 0xEF,
  0xF3, 0xF0, 0x1E, 0x1F, 0x9F, 0xEC, 0x7E, 0x3F, 0x1F, 0x8E, 0xFF, 0x7B,
  0x81, 0x81, 0xC1, 0xCF, 0xC7, 0xC0, 0x11, 0xCE, 0x20, 0x00, 0x00, 0x67,
  0x38, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x18, 0xE0, 0x00,
  0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x01, 0xF0, 0x3E, 0x03, 0x80, 0x40, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0x78,
  0x1C, 0x7C, 0xF8, 0xF0, 0x40, 0x00, 0x1C, 0x7F, 0x7F, 0x03, 0x07, 0x0F,
  0x1E, 0x38, 0x30, 0x70, 0x00, 0x60, 0xF0, 0x60, 0x00, 0xC0, 0x1F, 0xF0,
  0x70, 0x71, 0x80, 0x76, 0x3E, 0x6C, 0xFC, 0xF3, 0x99, 0xE6, 0x33, 0xCC,
  0xC7, 0xB9, 0x9B, 0x3F, 0xF6, 0x7B, 0xC6, 0x00, 0x0E, 0x04, 0x0F, 0xF8,
  0x07, 0xC0, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0C,
  0x61, 0xC6, 0x1F, 0xE3, 0xFE, 0x3F, 0xE7, 0x07, 0x70, 0x7E, 0x07, 0x1F,
  0x01, 0xFE, 0x1F, 0xE1, 0xC7, 0x18, 0x63, 0x8E, 0x3F, 0xC3, 0xFC, 0x31,
  0xC7, 0x0E, 0x70, 0xE7, 0x3C, 0x7F, 0xCF, 0xF0, 0x07, 0xC3, 0xFC, 0xFF,
  0x9C, 0x17, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0x47, 0xF8, 0x7F, 0x00, 0x1F, 0x01, 0xFE, 0x1F, 0xE1, 0xC7, 0x18, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x0F, 0x70, 0xE7, 0x3C, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0x80, 0x70, 0x8F, 0xE1, 0xFC,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x47, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0E, 0x01, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x3F, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xFF, 0x3F, 0xE3, 0x80, 0x70,
  0x07, 0x00, 0xE3, 0xEE, 0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xC7, 0x1C, 0x7F,
  0xC3, 0xFC, 0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0x83, 0x9C, 0x38,
  0xFF, 0xC7, 0xFE, 0x38, 0x73, 0x83, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x70,
  0x70, 0x1F, 0x8F, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x07, 0xE7, 0xF0, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x71, 0x78, 0xF8,
  0x78, 0x00, 0x1C, 0x38, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0x9C, 0x1D, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0x9C, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x70,
  0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0E, 0x17, 0xF7, 0xF8, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3,
  0xC3, 0xE1, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xDC, 0x6E, 0xEC, 0x37, 0x6E,
  0x3B, 0xF7, 0x1C, 0xF3, 0x8E, 0x79, 0x86, 0x38, 0xC7, 0x1C, 0xE0, 0x1E,
  0x0E, 0x3C, 0x18, 0x78, 0x70, 0xF8, 0xE3, 0xF1, 0xC7, 0x63, 0x0E, 0xE6,
  0x19, 0xDC, 0x31, 0xB8, 0xE3, 0xF1, 0xC7, 0xC3, 0x87, 0x86, 0x0F, 0x1C,
  0x1E, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xF3, 0x87, 0x70, 0x77, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xE7, 0x1E, 0x7F, 0xC3, 0xF0, 0x1F,
  0x01, 0xFE, 0x1F, 0xE1, 0xC7, 0x18, 0x73, 0x87, 0x38, 0xE3, 0xFE, 0x3F,
  0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x81, 0xFE, 0x3F,
  0xF3, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xE7, 0x1C, 0x7F, 0xC3, 0xF0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1F, 0x03,
  0xF8, 0x7F, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0xF9, 0xFE, 0x3F, 0x0E, 0x71,
  0xCE, 0x38, 0xE7, 0x1D, 0xC3, 0xC0, 0x07, 0x87, 0xF3, 0xFC, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x3B, 0x1E, 0xFF, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xE3, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x67,
  0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x1C, 0xE1, 0xCF, 0x3C, 0x7F, 0x83,
  0xF0, 0xC0, 0xFC, 0x3B, 0x87, 0x70, 0xCE, 0x39, 0xC6, 0x39, 0xC7, 0x30,
  0xEE, 0x1D, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xC1, 0x83, 0xE1,
  0xC3, 0xB0, 0xF1, 0xD8, 0x78, 0xCC, 0x7C, 0xE6, 0x3E, 0x73, 0x3F, 0x71,
  0x9B, 0xB8, 0xDD, 0xD8, 0x6C, 0xFC, 0x36, 0x7C, 0x1E, 0x3E, 0x0F, 0x0E,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x70, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0xE0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x38,
  0x70, 0xE3, 0x83, 0xC0, 0xE1, 0xF8, 0x7E, 0x39, 0x9C, 0x77, 0x1F, 0x87,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x7F, 0xCF, 0xFC, 0x1F, 0x1E, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xF0, 0xF0,
  0xC7, 0x38, 0xC6, 0x31, 0x8E, 0x73, 0x8C, 0x63, 0x1C, 0x1F, 0x1E, 0x06,
  0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38,
  0xF0, 0xF0, 0x02, 0x01, 0xC0, 0x70, 0x3C, 0x1D, 0x86, 0x63, 0x19, 0xC7,
  0xE0, 0xC0, 0xFF, 0xEE, 0x70, 0x08, 0x0F, 0xF7, 0xFD, 0xCE, 0xE3, 0xB8,
  0xEE, 0x3B, 0x8E, 0xE7, 0x3F, 0xC7, 0xB0, 0x1C, 0x07, 0x01, 0xC0, 0x64,
  0x3F, 0xCF, 0xF3, 0x8C, 0xC3, 0x30, 0xDC, 0x77, 0x1D, 0xCE, 0x7F, 0xBB,
  0xC0, 0x04, 0x3F, 0x7F, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE2, 0xFE, 0x7E,
  0x00, 0xE0, 0x18, 0x07, 0x04, 0xE3, 0xFC, 0xFF, 0x9C, 0xE7, 0x1C, 0xE3,
  0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xF0, 0xF6, 0x00, 0x06, 0x1F, 0x9E, 0xEE,
  0x7E, 0x3F, 0xFB, 0xF1, 0xC0, 0xE1, 0x7F, 0x9F, 0x80, 0x00, 0xC0, 0x7C,
  0x0F, 0x83, 0x80, 0x70, 0x3F, 0x87, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x1F, 0x03, 0xC0, 0x20,
  0x00, 0x04, 0x03, 0xFC, 0xFF, 0x9C, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E,
  0x73, 0x8F, 0xF0, 0xEE, 0x01, 0xC0, 0x71, 0xFE, 0x3F, 0x81, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0xC3, 0xFC, 0x7F, 0x8E, 0x39, 0xC6, 0x31, 0xCE,
  0x39, 0xC7, 0x38, 0xE6, 0x19, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE3,
  0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x80, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xF8, 0xF0,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x81, 0x38, 0xE3, 0x9C, 0x3B, 0x83,
  0x70, 0x3E, 0x07, 0xF0, 0x77, 0x07, 0x38, 0x63, 0x8E, 0x3C, 0x1C, 0x71,
  0xC6, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x80, 0x01, 0x04, 0x3F,
  0xDF, 0x37, 0xFF, 0x38, 0xE7, 0x38, 0xE7, 0x31, 0xC7, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0x86, 0x63, 0x8E, 0xE3, 0x8E, 0x01, 0x87, 0xF8, 0xDF, 0x1C,
  0x73, 0x8C, 0x63, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x33, 0x8E, 0x00, 0x0C,
  0x1F, 0x9F, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0x7F, 0x9F, 0x80,
  0x00, 0x83, 0xFC, 0x7F, 0x8E, 0x31, 0x86, 0x30, 0xCE, 0x39, 0xC7, 0x39,
  0xC7, 0xF9, 0xDE, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x08, 0x0F,
  0xF7, 0xFD, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0x3F, 0xC7, 0xF0,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x01, 0x9F, 0xCF, 0xC7, 0x83, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x00, 0x0C, 0x1F, 0xDE, 0xCE, 0x07,
  0x81, 0xF0, 0x7C, 0x0E, 0x87, 0x7F, 0x3F, 0x00, 0x18, 0x30, 0xE7, 0xFF,
  0xEE, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0xC7, 0x80, 0x71, 0xDC, 0x77, 0x1D,
  0x86, 0xE3, 0xB8, 0xEE, 0x3B, 0x9C, 0xFF, 0x1E, 0xC0, 0xE3, 0xF8, 0xEE,
  0x73, 0x9C, 0x6E, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x1C, 0x00, 0xE3, 0x8F,
  0xCF, 0x3B, 0x9E, 0x77, 0x6D, 0xCE, 0xDB, 0x9F, 0xB6, 0x3E, 0x7C, 0x3C,
  0xF0, 0x71, 0xE0, 0xE3, 0x80, 0x3C, 0xF1, 0xDE, 0x0D, 0xC0, 0xF8, 0x0F,
  0x00, 0xF0, 0x1F, 0x83, 0xB8, 0x73, 0x8F, 0x1C, 0x38, 0xF3, 0x8E, 0x39,
  0xC1, 0x9C, 0x1B, 0x81, 0xB8, 0x1B, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0xF8, 0x0F, 0x00, 0xC0, 0x00, 0x3F, 0x9F, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xE0, 0xE2, 0xFE, 0x7F, 0x00, 0x03, 0x0F, 0x0F, 0x1C, 0x1C,
  0x18, 0x18, 0x78, 0xE0, 0xF0, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x1C, 0x1E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0E, 0x07, 0x1E, 0x18, 0x38, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0xF8, 0xFF,
  0xE1, 0xC0,
};

const GFXglyph NotoSans_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 9, 2, -14 },
  { 17, 12, 14, 12, 0, -14 },
  { 38, 10, 15, 10, 0, -14 },
  { 57, 15, 14, 16, 1, -14 },
  { 84, 12, 14, 13, 1, -14 },
  { 105, 3, 5, 5, 2, -14 },
  { 107, 7, 17, 6, 1, -14 },
  { 122, 7, 17, 6, -1, -14 },
  { 137, 9, 10, 10, 2, -15 },
  { 149, 9, 9, 11, 1, -11 },
  { 160, 5, 4, 5, -1, -2 },
  { 163, 6, 2, 6, 0, -6 },
  { 165, 3, 3, 5, 0, -3 },
  { 167, 10, 14, 8, -1, -14 },
  { 185, 9, 14, 10, 1, -14 },
  { 201, 7, 14, 10, 2, -14 },
  { 214, 10, 14, 10, 0, -14 },
  { 232, 10, 14, 10, 0, -14 },
  { 250, 10, 14, 10, 0, -14 },
  { 268, 10, 14, 10, 0, -14 },
  { 286, 10, 14, 10, 1, -14 },
  { 304, 10, 14, 10, 1, -14 },
  { 322, 9, 14, 10, 1, -14 },
  { 338, 9, 14, 10, 1, -14 },
  { 354, 5, 11, 5, 0, -11 },
  { 361, 6, 13, 5, -1, -11 },
  { 371, 9, 10, 11, 1, -12 },
  { 383, 9, 6, 11, 1, -10 },
  { 390, 9, 10, 11, 1, -12 },
  { 402, 8, 14, 9, 1, -14 },
  { 416, 15, 16, 16, 1, -14 },
  { 446, 12, 14, 12, -1, -14 },
  { 467, 12, 14, 12, 0, -14 },
  { 488, 11, 14, 12, 1, -14 },
  { 508, 12, 14, 13, 0, -14 },
  { 529, 11, 14, 10, 0, -14 },
  { 549, 11, 14, 10, 0, -14 },
  { 569, 12, 14, 13, 1, -14 },
  { 590, 13, 14, 13, 0, -14 },
  { 613, 9, 14, 7, -1, -14 },
  { 629, 9, 18, 6, -3, -14 },
  { 650, 13, 14, 12, 0, -14 },
  { 673, 9, 14, 10, 0, -14 },
  { 689, 17, 14, 17, 0, -14 },
  { 719, 15, 14, 14, 0, -14 },
  { 746, 12, 14, 14, 1, -14 },
  { 767, 12, 14, 12, 0, -14 },
  { 788, 12, 17, 14, 1, -14 },
  { 814, 11, 14, 12, 0, -14 },
  { 834, 10, 14, 10, 0, -14 },
  { 852, 9, 14, 10, 2, -14 },
  { 868, 12, 14, 13, 1, -14 },
  { 889, 11, 14, 11, 2, -14 },
  { 909, 17, 14, 17, 2, -14 },
  { 939, 14, 14, 12, -1, -14 },
  { 964, 10, 14, 11, 2, -14 },
  { 982, 12, 14, 10, -1, -14 },
  { 1003, 8, 17, 6, 0, -14 },
  { 1020, 5, 14, 8, 2, -14 },
  { 1029, 8, 17, 6, -1, -14 },
  { 1046, 10, 9, 10, 0, -14 },
  { 1058, 8, 1, 8, -2, 2 },
  { 1059, 4, 3, 6, 3, -15 },
  { 1061, 10, 11, 11, 1, -11 },
  { 1075, 10, 14, 11, 0, -14 },
  { 1093, 8, 11, 9, 1, -11 },
  { 1104, 11, 14, 11, 1, -14 },
  { 1124, 9, 11, 11, 1, -11 },
  { 1137, 11, 20, 7, -2, -15 },
  { 1165, 11, 16, 11, 0, -11 },
  { 1187, 11, 14, 11, 0, -14 },
  { 1207, 6, 14, 6, 0, -14 },
  { 1218, 8, 19, 6, -2, -14 },
  { 1237, 12, 14, 11, 0, -14 },
  { 1258, 6, 14, 6, 0, -14 },
  { 1269, 16, 11, 17, 0, -11 },
  { 1291, 11, 11, 11, 0, -11 },
  { 1307, 9, 11, 11, 1, -11 },
  { 1320, 11, 16, 11, -1, -11 },
  { 1342, 10, 16, 11, 1, -11 },
  { 1362, 9, 11, 8, 0, -11 },
  { 1375, 9, 11, 9, 0, -11 },
  { 1388, 7, 13, 8, 1, -13 },
  { 1400, 10, 10, 11, 1, -10 },
  { 1413, 10, 10, 10, 1, -10 },
  { 1426, 15, 10, 15, 1, -10 },
  { 1445, 12, 10, 10, -1, -10 },
  { 1460, 12, 15, 10, -1, -10 },
  { 1483, 9, 10, 9, 0, -10 },
  { 1495, 8, 17, 7, 0, -14 },
  { 1512, 2, 18, 10, 4, -14 },
  { 1517, 8, 17, 7, -1, -14 },
  { 1534, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_BOLDITALIC19PT7B_H_
