#ifndef _NOTOSANS_BOLDITALIC26PT7B_H_
#define _NOTOSANS_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0xF3, 0xFB, 0xF9, 0xFC,
  0xEE, 0x77, 0x3B, 0x18, 0x03, 0x8C, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x60, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x38, 0xC0, 0x39, 0xC0,
  0x39, 0xC0, 0x31, 0xC0, 0x73, 0x80, 0x00, 0xC0, 0x06, 0x00, 0xF8, 0x1F,
  0xF3, 0xFF, 0x9E, 0xD8, 0xE6, 0x07, 0x20, 0x3F, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0x03, 0x7A, 0x1B, 0xD8, 0xDE, 0xFF, 0xE7, 0xFE, 0x1F,
  0xE0, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x0F, 0x00, 0xE1, 0xF8, 0x1C, 0x3F,
  0x83, 0x87, 0xB8, 0x70, 0x73, 0x87, 0x07, 0x38, 0xE0, 0x73, 0x9C, 0x0F,
  0x3B, 0xC0, 0xF7, 0xBB, 0xE7, 0xF7, 0x7F, 0x7E, 0xEF, 0x73, 0x8E, 0xE7,
  0x01, 0xCE, 0x70, 0x39, 0xE7, 0x07, 0x1E, 0x70, 0x71, 0xCF, 0x0E, 0x1F,
  0xE1, 0xC0, 0xFE, 0x38, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC3, 0xCF, 0xF1, 0xCF, 0x79, 0xEF, 0x1E, 0xE7, 0x87, 0xF3,
  0xC3, 0xF1, 0xF1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xE7, 0xC0, 0xFF,
  0xEE, 0xEE, 0xC0, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x0F,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0xC6, 0x07, 0xB0, 0x7F, 0xFC, 0x3F,
  0xE3, 0xFF, 0x3F, 0x83, 0xDC, 0x0C, 0x70, 0x23, 0x80, 0x10, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0xE7, 0x9C,
  0x73, 0x80, 0x7F, 0x7F, 0x7E, 0xFE, 0x77, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC,
  0x7D, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDE, 0x3C, 0xFF, 0xC3, 0xFC,
  0x0F, 0xC0, 0x01, 0xE0, 0x78, 0x3F, 0x1F, 0xEF, 0xFC, 0xF7, 0x9C, 0xE1,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7F,
  0xF8, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xC3, 0x9F,
  0x08, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x07, 0xF0, 0x3E, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xB0, 0x3C, 0xFF, 0xF3, 0xFF,
  0x87, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x83, 0xDE, 0x1E, 0x70, 0x73, 0xC3, 0x8F, 0x1C, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0x9F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0xB0, 0x7C, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xE2, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0xF0, 0x77, 0xF3, 0xFF, 0xCF, 0x8F, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF,
  0x0F, 0x3C, 0x7C, 0x7F, 0xE1, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xDF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE,
  0x78, 0xF3, 0xC3, 0x9E, 0x1C, 0xF1, 0xE3, 0xDE, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF8, 0xF3, 0xEF, 0x0F, 0x78, 0x7B, 0x83, 0xDE, 0x1E, 0xFF, 0xE3, 0xFF,
  0x0F, 0xE0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7D, 0xE7, 0x87, 0xBC, 0x3D,
  0xC1, 0xEE, 0x0F, 0x78, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x1E, 0x3C, 0x78,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x9E, 0x00, 0x0F, 0x0F,
  0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78,
  0x70, 0xF0, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x81, 0xF0, 0x0C, 0x00, 0x00,
  0x0F, 0x1F, 0xF9, 0xFF, 0x39, 0xF4, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x1F,
  0x83, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F,
  0x03, 0xE1, 0xE0, 0x07, 0x1E, 0x0E, 0x1C, 0xE3, 0xFC, 0xEE, 0x3F, 0xE7,
  0x73, 0xCE, 0x3F, 0x1C, 0x71, 0xF9, 0xC3, 0x8F, 0xCE, 0x1C, 0x7E, 0x71,
  0xC7, 0x73, 0x8E, 0x7B, 0x9F, 0xFF, 0x8E, 0x7D, 0xF8, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x81, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x70,
  0x07, 0xB8, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x78, 0x0E, 0x3C, 0x07, 0xBC,
  0x03, 0xFE, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1,
  0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF,
  0xE3, 0xC3, 0xC7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x78, 0x7C, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3,
  0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x10, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1E, 0x1E, 0x1C, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x7C, 0xF1, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFE, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0xE3,
  0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x02,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xFE, 0xF1, 0xFC,
  0xF1, 0xFC, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF8, 0x78, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1,
  0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x00, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0x80, 0x0E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0xC3,
  0xC7, 0xC1, 0xE7, 0xC0, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x00, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xFF, 0xFF, 0xFB, 0xFF,
  0x00, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xDE, 0x3B,
  0x87, 0x70, 0xEE, 0x39, 0xC7, 0xB8, 0xEF, 0x1E, 0xE7, 0x3C, 0x79, 0x9C,
  0xE1, 0xC7, 0xE3, 0x87, 0x1F, 0x9E, 0x3C, 0x7C, 0x78, 0xF1, 0xF1, 0xE3,
  0x87, 0x87, 0x0E, 0x1E, 0x1C, 0x00, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x7E,
  0x07, 0x0F, 0xC0, 0xE1, 0xF8, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xEE,
  0x1C, 0x39, 0xE3, 0x87, 0x3C, 0xF1, 0xE3, 0x9E, 0x3C, 0x7B, 0xC7, 0x8F,
  0x70, 0xE0, 0xEE, 0x1C, 0x1F, 0xC7, 0x83, 0xF8, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C,
  0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x7F,
  0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1E,
  0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF8, 0x79, 0xE1, 0xE7, 0x87, 0x8F, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x90, 0x7C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x7F, 0xFD, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0,
  0x1E, 0x70, 0x1E, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x78, 0x70, 0x78, 0x70,
  0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x3C, 0xF0,
  0xFC, 0x3C, 0xF0, 0xFC, 0x38, 0x70, 0xFC, 0x78, 0x71, 0xDC, 0x78, 0x71,
  0xDC, 0xF0, 0x73, 0x9C, 0xF0, 0x73, 0x9C, 0xE0, 0x77, 0x9D, 0xE0, 0x77,
  0x1D, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE1, 0xE0,
  0x78, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x3C, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0xF0, 0x79, 0xE1, 0xF3,
  0xC3, 0xC7, 0x8F, 0x07, 0x3E, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0xFC,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xFC, 0x3F, 0x0F,
  0xC0, 0xE3, 0x8E, 0x3C, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x8E, 0x38, 0xE3,
  0x8E, 0x3C, 0xF1, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x84, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xE0, 0xFC, 0x3F, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1D, 0xC0, 0xE7,
  0x03, 0x9C, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0xBC, 0x07, 0xFF, 0xFF, 0xF0,
  0xF7, 0x9E, 0x70, 0x0F, 0x9C, 0x7F, 0xF3, 0xFF, 0x9F, 0x1E, 0x78, 0x79,
  0xE1, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3F, 0xFC,
  0x7F, 0xE0, 0xFB, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xEF, 0x87, 0xFF, 0x1F, 0xFC, 0x78, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xDF, 0x1E, 0x7C, 0xF9, 0xFF, 0xC7,
  0xFF, 0x3D, 0xF0, 0x0F, 0xF1, 0xFE, 0x3F, 0xE7, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x47, 0xFC, 0x7F, 0xC3, 0xF8,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x83,
  0xEF, 0x0F, 0xFE, 0x3F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07,
  0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xE1, 0xFF, 0x81,
  0xF7, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0x9E, 0xF8, 0xF7, 0x87, 0xBC, 0xFB,
  0xFF, 0x9F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x08, 0xFF, 0xC7, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xCE, 0x1F, 0xFC, 0x7F, 0xF1, 0xF1,
  0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1,
  0xE3, 0xE3, 0xFF, 0xC3, 0xF7, 0x03, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x81,
  0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xEF, 0x87, 0xFF, 0x1F, 0xFC, 0x7C,
  0xF3, 0xE1, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xDE, 0x0E, 0x78,
  0x79, 0xE1, 0xE7, 0x87, 0xBC, 0x1E, 0x06, 0x0F, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x87, 0xE0, 0xFC,
  0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x1F, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x79, 0xE0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF8, 0xF0, 0x78, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1E, 0x00, 0x1C, 0xF8, 0xF8, 0x77, 0xF7, 0xF1, 0xFF,
  0xFF, 0xC7, 0x8F, 0x8F, 0x3E, 0x3E, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3,
  0xCF, 0x0F, 0x0F, 0x38, 0x38, 0x39, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E,
  0x1E, 0x1E, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xC0, 0x1C, 0xF8, 0x77, 0xF1,
  0xFF, 0xC7, 0xCF, 0x3E, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x3D,
  0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x7B, 0xC1, 0xE0, 0x0F, 0xE0, 0xFF,
  0x8F, 0xFE, 0xF8, 0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xBC, 0x7C, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x0E, 0x7C, 0x1D, 0xFC,
  0x3F, 0xF8, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x1C,
  0x1E, 0x7C, 0x78, 0xF9, 0xF1, 0xFF, 0xC3, 0xBF, 0x87, 0x3C, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x9C,
  0x7F, 0xF3, 0xFF, 0x9F, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x1C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3F, 0xFC, 0x7E, 0xE0, 0xF7, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0xF1, 0xDF,
  0x1F, 0xE1, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0xE3, 0xFF, 0x3E, 0xE3, 0xC0,
  0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x83, 0xCF, 0xFC,
  0xFF, 0xCF, 0xF0, 0x0E, 0x03, 0x81, 0xE1, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0xF1, 0xFC, 0x7F,
  0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E, 0x78, 0x79, 0xE1, 0xE7,
  0x87, 0x9E, 0x1E, 0x70, 0xF3, 0xC3, 0xCF, 0x1F, 0x1F, 0xDC, 0x7F, 0xF0,
  0xFB, 0x80, 0xF0, 0x7D, 0xC1, 0xE7, 0x0F, 0x1C, 0x3C, 0x71, 0xE1, 0xC7,
  0x87, 0xBC, 0x1E, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0xE1, 0xF0, 0xFE, 0x1F, 0x1E, 0xE3, 0xF1, 0xEE, 0x3F,
  0x3C, 0xE7, 0x73, 0xCE, 0x77, 0x78, 0xE7, 0x77, 0x8E, 0xE7, 0x70, 0xEE,
  0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0x80, 0x1E, 0x1F, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x78, 0x78, 0xF8, 0x78, 0x1E, 0x0F, 0x87, 0x07, 0x83, 0x87,
  0x81, 0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07,
  0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x00, 0x60,
  0x7C, 0x1F, 0x03, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC3,
  0xF0, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x03, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0xF8, 0x3E, 0x0E, 0x00, 0x7E, 0x0F, 0xFF,
  0xFB, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 12, 3, -19 },
  { 28, 16, 19, 17, 1, -19 },
  { 66, 13, 22, 14, 1, -20 },
  { 102, 20, 19, 22, 1, -19 },
  { 150, 17, 19, 18, 1, -19 },
  { 191, 4, 7, 7, 3, -19 },
  { 195, 10, 23, 9, 1, -19 },
  { 224, 10, 23, 9, -2, -19 },
  { 253, 13, 13, 14, 2, -20 },
  { 275, 13, 13, 15, 1, -16 },
  { 297, 6, 6, 7, -1, -3 },
  { 302, 8, 4, 8, 0, -9 },
  { 306, 5, 4, 7, 0, -4 },
  { 309, 14, 19, 11, -1, -19 },
  { 343, 13, 19, 14, 1, -19 },
  { 374, 11, 19, 14, 2, -19 },
  { 401, 15, 19, 14, -1, -19 },
  { 437, 14, 19, 14, 0, -19 },
  { 471, 14, 19, 14, 0, -19 },
  { 505, 14, 19, 14, 0, -19 },
  { 539, 14, 19, 14, 1, -19 },
  { 573, 14, 19, 14, 1, -19 },
  { 607, 13, 19, 14, 1, -19 },
  { 638, 13, 19, 14, 1, -19 },
  { 669, 7, 14, 7, 0, -14 },
  { 682, 8, 17, 7, -1, -14 },
  { 699, 13, 13, 15, 1, -16 },
  { 721, 13, 8, 15, 1, -13 },
  { 734, 13, 13, 15, 1, -16 },
  { 756, 11, 19, 12, 2, -19 },
  { 783, 21, 21, 22, 1, -19 },
  { 839, 17, 19, 16, -2, -19 },
  { 880, 15, 19, 16, 1, -19 },
  { 916, 15, 19, 16, 2, -19 },
  { 952, 16, 19, 18, 1, -19 },
  { 990, 14, 19, 14, 1, -19 },
  { 1024, 14, 19, 14, 1, -19 },
  { 1058, 16, 19, 18, 2, -19 },
  { 1096, 17, 19, 18, 1, -19 },
  { 1137, 12, 19, 10, -1, -19 },
  { 1166, 13, 24, 9, -4, -19 },
  { 1205, 17, 19, 16, 1, -19 },
  { 1246, 11, 19, 13, 1, -19 },
  { 1273, 22, 19, 23, 1, -19 },
  { 1326, 19, 19, 20, 1, -19 },
  { 1372, 16, 19, 19, 2, -19 },
  { 1410, 15, 19, 16, 1, -19 },
  { 1446, 16, 23, 19, 2, -19 },
  { 1492, 14, 19, 16, 1, -19 },
  { 1526, 13, 19, 14, 1, -19 },
  { 1557, 14, 19, 14, 2, -19 },
  { 1591, 16, 19, 18, 2, -19 },
  { 1629, 16, 19, 15, 2, -19 },
  { 1667, 24, 19, 23, 2, -19 },
  { 1724, 19, 19, 16, -1, -19 },
  { 1770, 15, 19, 15, 2, -19 },
  { 1806, 16, 19, 14, -1, -19 },
  { 1844, 10, 23, 9, 0, -19 },
  { 1873, 6, 19, 11, 3, -19 },
  { 1888, 11, 23, 9, -2, -19 },
  { 1920, 14, 12, 14, 0, -19 },
  { 1941, 10, 2, 10, -2, 2 },
  { 1944, 5, 4, 8, 4, -20 },
  { 1947, 14, 14, 15, 1, -14 },
  { 1972, 14, 20, 15, 0, -20 },
  { 2007, 12, 14, 13, 1, -14 },
  { 2028, 15, 20, 15, 1, -20 },
  { 2066, 13, 14, 14, 1, -14 },
  { 2089, 16, 26, 10, -3, -20 },
  { 2141, 15, 20, 16, 0, -14 },
  { 2179, 14, 20, 16, 0, -20 },
  { 2214, 8, 20, 8, 0, -20 },
  { 2234, 11, 26, 8, -3, -20 },
  { 2270, 16, 20, 15, 0, -20 },
  { 2310, 9, 20, 8, 0, -20 },
  { 2333, 22, 14, 24, 0, -14 },
  { 2372, 14, 14, 16, 0, -14 },
  { 2397, 13, 14, 15, 1, -14 },
  { 2420, 15, 20, 15, -1, -14 },
  { 2458, 14, 20, 15, 1, -14 },
  { 2493, 12, 14, 11, 0, -14 },
  { 2514, 12, 14, 12, 0, -14 },
  { 2535, 10, 17, 11, 1, -17 },
  { 2557, 14, 14, 16, 1, -14 },
  { 2582, 14, 14, 13, 1, -14 },
  { 2607, 20, 14, 20, 2, -14 },
  { 2642, 16, 14, 14, -1, -14 },
  { 2670, 17, 20, 14, -2, -14 },
  { 2713, 12, 14, 12, 0, -14 },
  { 2734, 11, 23, 9, 0, -19 },
  { 2766, 3, 26, 14, 6, -20 },
  { 2776, 10, 23, 9, -1, -19 },
  { 2805, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_BOLDITALIC26PT7B_H_
