#ifndef _NOTOSANS_BOLDITALIC53PT7B_H_
#define _NOTOSANS_BOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x3F, 0x8F, 0xF3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1,
  0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x3E, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFD, 0xE7, 0xC0, 0x7F, 0x9E, 0x08, 0x0F, 0xF1, 0xC0, 0x00, 0xFF, 0x1C,
  0x00, 0x0F, 0xF3, 0xC0, 0x00, 0xFF, 0xBC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xF7, 0xFC, 0x00, 0x0F, 0x3F, 0xC0, 0x00,
  0xE3, 0xFC, 0x00, 0x1E, 0x3F, 0xCC, 0x01, 0xE3, 0xFC, 0xF0, 0x1E, 0x7F,
  0x8F, 0xF1, 0xDF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xFF,
  0x80, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x00, 0x7F,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC3, 0xF0, 0x00,
  0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F,
  0x8F, 0xC7, 0xF8, 0xFC, 0x3F, 0x9F, 0x8F, 0xFC, 0xFE, 0x7F, 0x3F, 0x3F,
  0xFE, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x7F, 0xFF, 0x7F,
  0xFC, 0xFC, 0xFF, 0x7F, 0x3F, 0xF9, 0xF8, 0xFE, 0x3F, 0x1F, 0xE3, 0xF9,
  0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x01,
  0xFF, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0x03,
  0xFC, 0x7F, 0xFF, 0xE0, 0x7F, 0x0F, 0xFB, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F,
  0xE7, 0xF8, 0x7F, 0x83, 0xFE, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x81,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x08, 0x03, 0xF0, 0x03, 0x80, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x41, 0xFF, 0xF0,
  0x00, 0xFE, 0x7C, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0xC7, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x0C, 0x0F, 0xE0, 0x01, 0x03, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x80, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xF9, 0xFC,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF,
  0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xF7, 0xF8, 0xFE, 0x3F, 0x83, 0xE1,
  0xFC, 0x1C, 0x1F, 0xE0, 0x40, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0x01, 0xFF,
  0x00, 0xF0, 0x07, 0xF8, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x7F, 0xC0, 0x1C, 0x01, 0xFF, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE3, 0x00, 0x03, 0xFF, 0x1F, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x87, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x88, 0x00, 0x0F, 0xF0, 0xC0, 0x01, 0xFF, 0x0F, 0x80,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x20, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x1C, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xF9, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x7F,
  0x80, 0x7F, 0xDF, 0xF0, 0x3F, 0xF3, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF8, 0x1F, 0xF9,
  0xFE, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x83,
  0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0,
  0x7F, 0xC6, 0x00, 0xFF, 0x10, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xC7, 0xE1, 0xFC,
  0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x03, 0xFF, 0xFE, 0x0F, 0xCF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xF9, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x3E,
  0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xC0, 0xFD, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0xBF, 0x0F, 0xE0, 0x3F, 0x03, 0xF7, 0xC1, 0xF8, 0x07, 0xC0, 0x7C, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0xBF, 0x07, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0xF8,
  0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0x01, 0xF8, 0x1F, 0x9F, 0x83, 0xE0, 0x3F,
  0x03, 0xF3, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x3E, 0x0F, 0xE3, 0xFC, 0x7F,
  0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F,
  0x83, 0xFF, 0x9F, 0xFE, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0x00,
  0xE0, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0x00, 0x38, 0x0F,
  0xFC, 0x00, 0x08, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0x00, 0x3F, 0xF8, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC7, 0xF8, 0x0F, 0xFE, 0x00, 0x38, 0x0F, 0xFE, 0x00, 0x04, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x1F,
  0xE0, 0x3F, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xC7,
  0xF8, 0x07, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xBE, 0x00, 0x3F, 0x7F, 0x00, 0xFE, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x3F,
  0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFC, 0x07, 0xF7, 0xF8, 0x07, 0xF3, 0xF0,
  0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x03,
  0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x7E,
  0x3F, 0xC0, 0x3F, 0x8F, 0xC3, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF8, 0x07, 0xF8, 0xFC, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F,
  0x80, 0x7F, 0x0F, 0xCF, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x3F, 0x07, 0xF0,
  0x07, 0xF0, 0xFD, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFF, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xFC,
  0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xDF,
  0xC0, 0x1F, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x07, 0xF1,
  0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF,
  0xF0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x80, 0x7F, 0xBF, 0x80, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xBF,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE3, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x1F,
  0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xC0,
  0x7F, 0xC0, 0x18, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x1F, 0xE0, 0xE0, 0x03, 0xFE, 0x0F,
  0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xF0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xC3, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFD, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFB, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xCF, 0xC1, 0xFE, 0x03,
  0xF8, 0x3F, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x3F, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFC, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x80, 0x3F,
  0x8F, 0xE1, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x00, 0x7E,
  0x7F, 0x07, 0xE7, 0xF8, 0x00, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0x01, 0xFB,
  0xF8, 0x1F, 0x9F, 0xC0, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x00, 0x07, 0xEF,
  0xC0, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFD, 0xF8, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xEF,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFE, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0xC3, 0xF8,
  0x07, 0xFF, 0x1F, 0x80, 0x7F, 0xFD, 0xFC, 0x07, 0xFF, 0xEF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0,
  0xFF, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x80, 0x3F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xBF, 0x80, 0x3F, 0xF9,
  0xFC, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFF, 0x80, 0x3F, 0xBF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xC0, 0xFE, 0x7F,
  0xF8, 0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x1C, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x10, 0x7F, 0xC0, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xFE, 0x7F, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0xFF, 0xFD,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0x9F, 0x80, 0x03, 0xFC,
  0x3F, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x81, 0xFC, 0x7F, 0xC0, 0x7F, 0x3F, 0xE0, 0x1F, 0xCF,
  0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFD, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0x07, 0xFC, 0x01, 0xC1, 0xFF, 0xC3, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFC,
  0x01, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x7F, 0xFE, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x02,
  0x00, 0x0F, 0xF0, 0x0E, 0x00, 0x7F, 0xC0, 0x3F, 0xDF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xF9, 0xFF, 0xC0, 0x3F, 0xBF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xF3, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x87, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x7F,
  0x80, 0x3F, 0x1F, 0xFC, 0x03, 0xF3, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x87, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87,
  0xFE, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x1F, 0xC7, 0xF8, 0x03,
  0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0xE0, 0x00, 0xFC, 0x7F, 0xE0, 0x01, 0xFB, 0xFF, 0xE0, 0x07, 0xF7, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xBF, 0xFE, 0x00, 0xFF, 0x3F, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x03, 0xFC, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xFF, 0x1F, 0x80,
  0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x80, 0x3F, 0x87,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0x80, 0x3F, 0xFB, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE3, 0xFC, 0x0F, 0xCF, 0xF8, 0x3F, 0xBF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0x07, 0xF8, 0x06, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x90, 0x01, 0xFE, 0x30, 0x03, 0xFC, 0x7F, 0x7F, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x58, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x10, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0x07, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xE0, 0x7F, 0xFC,
  0xFE, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x01, 0xF8, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xF0, 0x1F, 0xEF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xDF, 0x83, 0xF8,
  0x3F, 0x87, 0xEF, 0xC3, 0xFC, 0x1F, 0xC3, 0xF7, 0xE1, 0xFE, 0x0F, 0xE3,
  0xF3, 0xF1, 0xFE, 0x07, 0xF1, 0xF9, 0xF8, 0xFF, 0x03, 0xF9, 0xFC, 0xFC,
  0x7F, 0x01, 0xFC, 0xFC, 0x7E, 0x7F, 0x80, 0xFE, 0x7E, 0x3F, 0x3F, 0x80,
  0x7F, 0x7E, 0x1F, 0xBF, 0xC0, 0x3F, 0xBF, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF,
  0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0x07, 0xEF, 0xC1, 0xFF,
  0xF0, 0x03, 0xF7, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x40, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFA, 0x00, 0x1F, 0xFC, 0x80, 0x00,
  0x78, 0x00,
};

const GFXglyph NotoSans_BoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 39, 15, 1, -38 },
  { 79, 20, 14, 24, 5, -38 },
  { 114, 34, 38, 34, 1, -38 },
  { 276, 28, 43, 29, 1, -40 },
  { 427, 40, 38, 45, 3, -38 },
  { 617, 35, 39, 38, 2, -38 },
  { 788, 9, 14, 14, 5, -38 },
  { 804, 20, 46, 18, 2, -38 },
  { 919, 20, 46, 18, -4, -38 },
  { 1034, 26, 26, 29, 4, -41 },
  { 1119, 26, 26, 30, 3, -32 },
  { 1204, 13, 13, 15, -3, -6 },
  { 1226, 15, 6, 17, 1, -17 },
  { 1238, 10, 9, 15, 0, -8 },
  { 1250, 28, 38, 22, -2, -38 },
  { 1383, 27, 39, 29, 2, -38 },
  { 1515, 21, 38, 29, 5, -38 },
  { 1615, 29, 38, 29, -1, -38 },
  { 1753, 29, 39, 29, 0, -38 },
  { 1895, 30, 38, 29, -1, -38 },
  { 2038, 28, 39, 29, 1, -38 },
  { 2175, 28, 39, 29, 2, -38 },
  { 2312, 29, 38, 29, 2, -38 },
  { 2450, 28, 39, 29, 1, -38 },
  { 2587, 26, 39, 29, 2, -38 },
  { 2714, 14, 30, 15, 0, -29 },
  { 2767, 17, 36, 15, -3, -29 },
  { 2844, 26, 28, 30, 3, -33 },
  { 2935, 26, 16, 30, 3, -27 },
  { 2987, 26, 28, 30, 3, -33 },
  { 3078, 22, 39, 24, 4, -38 },
  { 3186, 43, 43, 45, 2, -38 },
  { 3418, 33, 38, 33, -3, -38 },
  { 3575, 31, 38, 33, 1, -38 },
  { 3723, 32, 39, 32, 3, -38 },
  { 3879, 33, 38, 36, 1, -38 },
  { 4036, 30, 38, 29, 1, -38 },
  { 4179, 29, 38, 28, 1, -38 },
  { 4317, 33, 39, 37, 3, -38 },
  { 4478, 36, 38, 37, 1, -38 },
  { 4649, 25, 38, 20, -2, -38 },
  { 4768, 26, 49, 18, -8, -38 },
  { 4928, 36, 38, 32, 1, -38 },
  { 5099, 23, 38, 27, 1, -38 },
  { 5209, 46, 38, 47, 1, -38 },
  { 5428, 39, 38, 40, 1, -38 },
  { 5614, 34, 39, 39, 3, -38 },
  { 5780, 32, 38, 32, 1, -38 },
  { 5932, 34, 47, 39, 3, -38 },
  { 6132, 30, 38, 33, 1, -38 },
  { 6275, 28, 39, 28, 1, -38 },
  { 6412, 28, 38, 28, 4, -38 },
  { 6545, 33, 39, 37, 4, -38 },
  { 6706, 31, 38, 31, 5, -38 },
  { 6854, 47, 38, 47, 5, -38 },
  { 7078, 39, 38, 32, -3, -38 },
  { 7264, 30, 38, 30, 5, -38 },
  { 7407, 33, 38, 28, -2, -38 },
  { 7564, 22, 46, 18, -1, -38 },
  { 7691, 12, 38, 22, 6, -38 },
  { 7748, 23, 46, 18, -4, -38 },
  { 7881, 27, 25, 29, 1, -38 },
  { 7966, 22, 3, 21, -5, 5 },
  { 7975, 11, 9, 17, 8, -41 },
  { 7988, 29, 30, 31, 2, -29 },
  { 8097, 28, 41, 32, 1, -40 },
  { 8241, 24, 30, 26, 2, -29 },
  { 8331, 31, 41, 31, 2, -40 },
  { 8490, 26, 30, 30, 2, -29 },
  { 8588, 32, 54, 20, -6, -41 },
  { 8804, 30, 42, 32, 1, -29 },
  { 8962, 28, 40, 32, 1, -40 },
  { 9102, 16, 40, 16, 1, -40 },
  { 9182, 24, 53, 16, -7, -40 },
  { 9341, 32, 40, 30, 1, -40 },
  { 9501, 16, 40, 16, 1, -40 },
  { 9581, 44, 29, 48, 1, -29 },
  { 9741, 28, 29, 32, 1, -29 },
  { 9843, 27, 30, 31, 2, -29 },
  { 9945, 31, 42, 32, -2, -29 },
  { 10108, 29, 42, 31, 2, -29 },
  { 10261, 23, 29, 22, 1, -29 },
  { 10345, 23, 30, 25, 1, -29 },
  { 10432, 21, 36, 22, 2, -35 },
  { 10527, 28, 30, 32, 3, -29 },
  { 10632, 27, 29, 27, 3, -29 },
  { 10730, 41, 29, 42, 3, -29 },
  { 10879, 34, 29, 28, -3, -29 },
  { 11003, 34, 42, 28, -4, -29 },
  { 11182, 26, 29, 25, -1, -29 },
  { 11277, 22, 46, 19, 0, -38 },
  { 11404, 5, 52, 29, 12, -40 },
  { 11437, 22, 46, 19, -3, -38 },
  { 11564, 26, 9, 30, 3, -23 },
};

const GFXfont NotoSans_BoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_BOLDITALIC53PT7B_H_
