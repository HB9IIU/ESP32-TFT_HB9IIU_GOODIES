#ifndef _NOTOSANS_BOLDITALIC9PT7B_H_
#define _NOTOSANS_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xB4, 0x39, 0xF3, 0x3E, 0x51, 0x40, 0x13, 0xD8,
  0xE3, 0xD9, 0x88, 0x22, 0xE9, 0xE7, 0x75, 0xE5, 0x53, 0x80, 0x10, 0xE2,
  0x8C, 0x57, 0x67, 0xC0, 0xC0, 0x34, 0x4C, 0xCC, 0x40, 0x23, 0x11, 0x32,
  0x2C, 0x2A, 0x7A, 0x27, 0xC8, 0x40, 0xE0, 0xE0, 0xC0, 0x12, 0x24, 0xC8,
  0x13, 0xD3, 0xBD, 0xE9, 0xC0, 0x75, 0xB4, 0x80, 0x23, 0xC6, 0x22, 0x23,
  0xC0, 0x13, 0xC6, 0xE1, 0x0B, 0xC0, 0x19, 0x95, 0x2F, 0x98, 0x7A, 0x1C,
  0x21, 0x78, 0x09, 0xD0, 0xED, 0xE9, 0xC0, 0x78, 0xCC, 0x46, 0x60, 0x13,
  0xD2, 0x65, 0x6D, 0xC0, 0x23, 0xD6, 0xB7, 0x8B, 0x80, 0x50, 0xC0, 0x50,
  0xE0, 0x08, 0xF8, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00, 0x5C,
  0xA8, 0x20, 0x3E, 0x5D, 0x75, 0xAA, 0xBE, 0x40, 0x3C, 0x1C, 0x53, 0x4F,
  0x67, 0x10, 0x79, 0xB7, 0x92, 0x4B, 0xC0, 0x23, 0xE1, 0x08, 0x43, 0xC0,
  0x79, 0xB4, 0xD3, 0x5B, 0xC0, 0x7B, 0x1E, 0x84, 0x78, 0x7B, 0x1C, 0x84,
  0x60, 0x13, 0xF1, 0x79, 0xCB, 0xC0, 0x65, 0x97, 0xD3, 0x4B, 0x20, 0x76,
  0x64, 0x4E, 0x13, 0x22, 0x26, 0x6C, 0x6D, 0xE7, 0x14, 0x53, 0x60, 0x66,
  0x44, 0x4F, 0x63, 0x67, 0x56, 0x5A, 0x5A, 0xD6, 0x66, 0xA9, 0x52, 0xA5,
  0xD9, 0x80, 0x23, 0xE3, 0x18, 0xCF, 0xC0, 0x79, 0xB5, 0x9C, 0x43, 0x00,
  0x23, 0xE3, 0x18, 0xCF, 0xC6, 0x10, 0x7B, 0x5E, 0xE5, 0x6C, 0x13, 0xD0,
  0xC3, 0x4B, 0xC0, 0xF4, 0x44, 0xCC, 0xCC, 0x67, 0x29, 0x78, 0x9C, 0xAD,
  0x4E, 0x60, 0x93, 0xB2, 0xB6, 0xFC, 0xD4, 0xC8, 0x36, 0x38, 0x61, 0xC2,
  0x99, 0x80, 0x9F, 0x98, 0x84, 0x60, 0x78, 0x8C, 0xCC, 0x78, 0x74, 0x44,
  0xC8, 0xC0, 0xAD, 0x50, 0x31, 0x32, 0x22, 0xE0, 0x31, 0x95, 0x10, 0xF0,
  0xD0, 0x7A, 0xF7, 0xA7, 0x00, 0x23, 0x1E, 0x94, 0xEE, 0xC0, 0x34, 0xCC,
  0x70, 0x0C, 0x27, 0x96, 0xDB, 0x47, 0x00, 0x32, 0xFD, 0x87, 0x00, 0x18,
  0x9E, 0x42, 0x11, 0x8C, 0xC0, 0x7A, 0xF7, 0xA7, 0x0B, 0x80, 0x23, 0x16,
  0xD5, 0xEF, 0x40, 0x61, 0xA5, 0xB0, 0x30, 0x32, 0x26, 0x64, 0xC0, 0x21,
  0x84, 0xD4, 0x63, 0xCD, 0x80, 0x2D, 0x25, 0xB0, 0x5E, 0x6B, 0x5B, 0xDA,
  0xD2, 0x5B, 0x57, 0xBD, 0x00, 0x72, 0xF7, 0xB7, 0x00, 0x7A, 0x53, 0xBF,
  0x42, 0x00, 0x7A, 0xF7, 0xA7, 0x08, 0xC0, 0x56, 0x4C, 0xC0, 0x74, 0x63,
  0xE0, 0x2F, 0x44, 0x46, 0x4A, 0x57, 0xB7, 0x00, 0xCA, 0x94, 0xC6, 0x00,
  0xB7, 0x6B, 0x66, 0xC9, 0x00, 0x5B, 0x88, 0xE9, 0x00, 0x64, 0xA2, 0x8C,
  0x30, 0x8E, 0x00, 0x73, 0x64, 0xF0, 0x32, 0x48, 0x44, 0x40, 0xFF, 0x80,
  0x6D, 0x14, 0xA0, 0x6C, 0x80,
};

const GFXglyph NotoSans_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 3, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 6, 6, 6, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 7, 7, 8, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 1, 2, 2, 1, -6 },
  { 29, 4, 7, 3, 0, -6 },
  { 33, 4, 8, 3, -1, -7 },
  { 37, 4, 4, 5, 1, -7 },
  { 39, 5, 4, 5, 0, -5 },
  { 42, 2, 2, 3, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 2, 1, 3, 0, -1 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 5, 7, 5, 0, -7 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 2, 5, 3, 0, -5 },
  { 95, 2, 6, 3, 0, -5 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 5, 3, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 3, 7, 4, 1, -7 },
  { 110, 8, 7, 8, 0, -6 },
  { 117, 6, 6, 6, -1, -6 },
  { 122, 6, 6, 6, 0, -6 },
  { 127, 5, 7, 6, 1, -7 },
  { 132, 6, 6, 6, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 6, 6, 6, 0, -6 },
  { 155, 4, 6, 3, 0, -6 },
  { 158, 4, 8, 3, -1, -6 },
  { 162, 6, 6, 6, 0, -6 },
  { 167, 4, 6, 5, 0, -6 },
  { 170, 8, 6, 8, 0, -6 },
  { 176, 7, 6, 7, 0, -6 },
  { 182, 5, 7, 7, 1, -7 },
  { 187, 6, 6, 5, 0, -6 },
  { 192, 5, 9, 7, 1, -7 },
  { 198, 5, 6, 6, 0, -6 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 4, 6, 5, 1, -6 },
  { 210, 5, 6, 6, 1, -6 },
  { 214, 5, 6, 5, 1, -6 },
  { 218, 8, 6, 8, 1, -6 },
  { 224, 7, 6, 5, -1, -6 },
  { 230, 5, 6, 5, 1, -6 },
  { 234, 5, 6, 5, 0, -6 },
  { 238, 4, 7, 3, 0, -6 },
  { 242, 2, 6, 4, 1, -6 },
  { 244, 4, 7, 3, -1, -6 },
  { 248, 5, 4, 5, 0, -6 },
  { 251, 4, 1, 4, -1, 1 },
  { 252, 2, 2, 3, 1, -7 },
  { 253, 5, 5, 5, 0, -5 },
  { 257, 5, 7, 5, 0, -7 },
  { 262, 4, 5, 4, 0, -5 },
  { 265, 6, 7, 5, 0, -7 },
  { 271, 5, 5, 5, 0, -5 },
  { 275, 5, 9, 3, -1, -7 },
  { 281, 5, 7, 5, 0, -5 },
  { 286, 5, 7, 5, 0, -7 },
  { 291, 3, 7, 3, 0, -7 },
  { 294, 4, 9, 3, -1, -7 },
  { 299, 6, 7, 5, 0, -7 },
  { 305, 3, 7, 3, 0, -7 },
  { 308, 8, 5, 8, 0, -5 },
  { 313, 5, 5, 5, 0, -5 },
  { 317, 5, 5, 5, 0, -5 },
  { 321, 5, 7, 5, 0, -5 },
  { 326, 5, 7, 5, 0, -5 },
  { 331, 4, 5, 4, 0, -5 },
  { 334, 4, 5, 4, 0, -5 },
  { 337, 4, 6, 4, 0, -6 },
  { 340, 5, 5, 5, 0, -5 },
  { 344, 5, 5, 5, 0, -5 },
  { 348, 7, 5, 7, 1, -5 },
  { 353, 5, 5, 5, 0, -5 },
  { 357, 6, 7, 5, -1, -5 },
  { 363, 4, 5, 4, 0, -5 },
  { 366, 4, 7, 3, 0, -6 },
  { 370, 1, 9, 5, 2, -7 },
  { 372, 3, 7, 3, 0, -6 },
  { 375, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_BOLDITALIC9PT7B_H_
