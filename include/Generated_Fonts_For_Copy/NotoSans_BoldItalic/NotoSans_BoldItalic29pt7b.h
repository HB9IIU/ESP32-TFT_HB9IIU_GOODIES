#ifndef _NOTOSANS_BOLDITALIC29PT7B_H_
#define _NOTOSANS_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x10, 0x3C, 0x3E, 0x1F, 0x07,
  0x80, 0x79, 0xEE, 0x79, 0xCF, 0x79, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x18,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xCF, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0,
  0x1C, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x79, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x8F,
  0x31, 0x1E, 0x60, 0x3D, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xDF, 0x01, 0xBE, 0x83, 0x79, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x70,
  0xFE, 0x03, 0x87, 0xF8, 0x1C, 0x1C, 0xF0, 0xF0, 0xF3, 0xC3, 0x83, 0xCF,
  0x1C, 0x0E, 0x38, 0xE0, 0x38, 0xE7, 0x80, 0xE7, 0x9C, 0xE3, 0x9E, 0xEF,
  0xEF, 0xF7, 0x7F, 0xBF, 0xBD, 0xEF, 0x3C, 0xEF, 0x3C, 0x07, 0x3C, 0xF0,
  0x38, 0xF3, 0xC1, 0xE3, 0x8E, 0x07, 0x0E, 0x38, 0x38, 0x39, 0xE1, 0xE0,
  0xFF, 0x0F, 0x03, 0xFC, 0x78, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x07, 0xDF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80,
  0x7B, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0x9F, 0xF1, 0xE7,
  0xDF, 0x3D, 0xF1, 0xEF, 0x3E, 0x3F, 0xE7, 0x83, 0xF8, 0xF8, 0x3E, 0x1F,
  0x9F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0xFC, 0x7B, 0x9D, 0xEF,
  0x73, 0x9C, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x1C, 0x70, 0x7B, 0x83, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFF, 0x0F, 0xC4, 0x7F, 0x07, 0xDE, 0x0E, 0x38, 0x10,
  0xF0, 0x02, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x3E, 0x79, 0xE3, 0xC7, 0x1E, 0x38, 0x00, 0x7F,
  0xBF, 0x9F, 0xDF, 0xE0, 0x13, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x87, 0xDF,
  0x0F, 0xBC, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xF7, 0x81, 0xEF, 0x03,
  0xDE, 0x0F, 0xBC, 0x1F, 0x78, 0x3C, 0xF0, 0xF9, 0xF3, 0xE1, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x9F, 0xE7, 0xFD, 0xFF,
  0xBC, 0xF3, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x60, 0xF8, 0x20, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFE, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C,
  0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x80, 0x7C, 0xE0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0x78,
  0x78, 0x78, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x18, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x80, 0x7C, 0xF1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0,
  0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7, 0xE3, 0xEF, 0x83,
  0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF8, 0x78, 0xFB, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF0, 0xF9, 0xF3, 0xE1, 0xE7, 0xC3, 0xCF, 0x87, 0x8F,
  0x1E, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFF, 0x87, 0xCF, 0x9F, 0x0F,
  0x3C, 0x1F, 0x78, 0x3E, 0xF0, 0x79, 0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x7C, 0x3D, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE1, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F,
  0xBC, 0x39, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF2, 0x1F, 0x8F, 0xFE, 0x3F,
  0xE0, 0xFF, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x78, 0xF8, 0xF8, 0xF8, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0xF0,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xC0,
  0xFC, 0x03, 0x80, 0x08, 0x00, 0x00, 0x0F, 0xC7, 0xFE, 0x7F, 0xF7, 0xFF,
  0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07,
  0xC0, 0x7C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3C, 0x3F, 0xCE, 0x38,
  0x7F, 0xCE, 0x78, 0xF3, 0x8F, 0x71, 0xE3, 0x8F, 0x71, 0xC3, 0x8E, 0xF3,
  0x87, 0x8E, 0xF3, 0x87, 0x0E, 0xE3, 0x87, 0x1E, 0xE3, 0x8F, 0x1C, 0xF3,
  0xFF, 0xFC, 0x73, 0xFB, 0xF8, 0x71, 0xF3, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF0,
  0xE0, 0x3C, 0x38, 0x1E, 0x0F, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8,
  0x03, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0,
  0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xC3, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x3E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0x31, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x04, 0x3F,
  0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x7C,
  0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C,
  0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x7C, 0x78, 0x3E, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x01, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xEF, 0x07, 0xF3, 0xC3, 0xFC, 0xF0,
  0xFF, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x1F, 0x9F,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0x81, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3F, 0x0F, 0x87, 0xC1,
  0xF1, 0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78,
  0x1F, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3B, 0x83,
  0xFC, 0x3D, 0xC1, 0xDE, 0x1E, 0xE1, 0xEF, 0x0F, 0x70, 0xE7, 0x87, 0xBC,
  0xF7, 0x83, 0x9E, 0x73, 0xC3, 0xCF, 0x79, 0xE1, 0xE7, 0xB8, 0xF0, 0xF3,
  0xFC, 0xF0, 0x78, 0xFC, 0x78, 0x78, 0x7E, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x7E, 0x03, 0xC3,
  0xF0, 0x1E, 0x3F, 0x81, 0xE1, 0xFC, 0x0F, 0x0F, 0xF0, 0x78, 0x7F, 0x83,
  0xC3, 0xBC, 0x1E, 0x3C, 0xF1, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x78,
  0xF3, 0xC3, 0xC7, 0x9E, 0x3C, 0x3D, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8,
  0x78, 0x3F, 0xC7, 0x80, 0xFE, 0x3C, 0x07, 0xE1, 0xE0, 0x3F, 0x0F, 0x00,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB,
  0xE0, 0x3E, 0xF8, 0x1F, 0x1F, 0xBF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x8F,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x83, 0xFC, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x07, 0xCF, 0x81,
  0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xE0, 0x3E, 0xF8,
  0x1F, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x3C,
  0xF0, 0x3E, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3,
  0xE0, 0x87, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x80, 0xF1,
  0xE7, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8,
  0xF8, 0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81,
  0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x0E,
  0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x1C, 0x07,
  0xFC, 0x0F, 0x81, 0xEF, 0x03, 0xE0, 0xFB, 0xC1, 0xF8, 0x3C, 0xF0, 0x7E,
  0x0F, 0x3C, 0x3F, 0x87, 0x8F, 0x0F, 0xE1, 0xE3, 0xC7, 0xF8, 0xF0, 0xF1,
  0xFE, 0x3C, 0x3C, 0xF7, 0x9F, 0x0F, 0x3D, 0xE7, 0x83, 0xCE, 0x79, 0xE0,
  0xF7, 0x9E, 0xF0, 0x3D, 0xC7, 0xBC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0,
  0x3C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F,
  0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x01,
  0xF0, 0xFC, 0x07, 0xC0, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C,
  0x78, 0x78, 0x78, 0xF0, 0x79, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x78, 0xF1, 0xE0,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x00, 0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x80, 0x77, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x71,
  0xC0, 0x77, 0x80, 0xFE, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xF9, 0xE3, 0xC7,
  0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFE, 0x3F, 0x7E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8,
  0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xBE, 0x0F, 0xFE, 0x3F,
  0xFC, 0x7E, 0x7C, 0xF8, 0xF9, 0xE0, 0xF3, 0xC1, 0xEF, 0x07, 0xDE, 0x0F,
  0xBC, 0x1E, 0x78, 0x3D, 0xF0, 0xFB, 0xF3, 0xE7, 0xFF, 0xCE, 0xFF, 0x1C,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x7E, 0x67, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC6, 0x3F,
  0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xBF, 0x0F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xE0, 0xF1,
  0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFB, 0xC0, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D,
  0xF0, 0xF7, 0x8F, 0xDF, 0xFE, 0xFF, 0xF3, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x31, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x20, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x04, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xCF, 0x0F,
  0xEF, 0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFD, 0xF8, 0x7F,
  0xF8, 0x7F, 0x78, 0x3E, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x81, 0xF0, 0xE7,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x9E, 0x0F, 0xFE, 0x3F, 0xFE,
  0x7E, 0x7C, 0xF8, 0x79, 0xF0, 0xF3, 0xC1, 0xEF, 0x87, 0xDE, 0x0F, 0x3C,
  0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xE1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x3E, 0x3C, 0x3E, 0x3E, 0x3E, 0x1E, 0x3E, 0x0F, 0x3E, 0x07, 0xBE,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7D, 0xE0, 0x7C,
  0xF8, 0x3E, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0x83, 0xE0, 0x07, 0xC1,
  0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x3E, 0x00, 0x1C, 0xF8, 0x7C, 0x1D, 0xFC, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xBF, 0xDF, 0x3E, 0x1F, 0x1F, 0x3E, 0x1E, 0x1F, 0x3C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x3E, 0xF8,
  0x7C, 0x3E, 0xF8, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0,
  0xF8, 0x7C, 0x1C, 0xF8, 0x3B, 0xF8, 0xFF, 0xF9, 0xF9, 0xF3, 0xE1, 0xE7,
  0xC3, 0xCF, 0x07, 0xBE, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0xC1,
  0xEF, 0x87, 0xDE, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0x07, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFB, 0xE7, 0xC3, 0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xE7, 0xCF, 0x8F, 0xFE, 0x0F, 0xF8,
  0x0F, 0xE0, 0x07, 0x3E, 0x03, 0xBF, 0x83, 0xFF, 0xC1, 0xF9, 0xF0, 0xF8,
  0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0x87,
  0x83, 0xC7, 0xC3, 0xE3, 0xF3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7B, 0xE0,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x07, 0xCF, 0x0F, 0xEE, 0x1F, 0xFE, 0x3F, 0x7E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x1C, 0x71, 0xDF, 0x3F, 0xF3, 0xFF, 0x3F, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x7C, 0x63, 0xC0, 0x1F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xEC, 0x1F, 0x7F, 0xF3,
  0xFF, 0x8F, 0xF0, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC4, 0x7F, 0x8F, 0xF0, 0xFE, 0x00, 0x3C, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xE7, 0x8F, 0xCF, 0x3F, 0x1F, 0xEE, 0x3F, 0x9C, 0x3E, 0x78,
  0xF8, 0x1F, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x3B, 0xE0, 0x3B, 0xC0, 0x3B, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF0, 0xF8, 0x3F, 0xC3,
  0xE1, 0xFF, 0x0F, 0x87, 0xBC, 0x7E, 0x1E, 0xF1, 0xF8, 0xF3, 0xCE, 0xE3,
  0xCF, 0x3B, 0x9E, 0x3D, 0xEE, 0x78, 0xF7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F,
  0xE3, 0xB8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0xF9, 0xF0, 0x1E,
  0xF8, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x07,
  0xC3, 0xC3, 0xE0, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x39, 0xF0, 0x07,
  0x3C, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xF0, 0x3E, 0x07, 0xC3, 0xF8, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x3F, 0x07, 0xC0, 0xF0, 0x10, 0x00, 0x10,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
};

const GFXglyph NotoSans_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 8, 13, 3, -21 },
  { 36, 18, 21, 19, 1, -21 },
  { 84, 15, 24, 16, 1, -22 },
  { 129, 22, 21, 25, 2, -21 },
  { 187, 19, 21, 21, 1, -21 },
  { 237, 5, 8, 7, 3, -21 },
  { 242, 11, 26, 10, 1, -21 },
  { 278, 11, 26, 10, -2, -21 },
  { 314, 14, 14, 16, 2, -22 },
  { 339, 14, 14, 17, 2, -17 },
  { 364, 7, 7, 8, -1, -3 },
  { 371, 9, 4, 9, 0, -10 },
  { 376, 5, 5, 8, 0, -5 },
  { 380, 15, 21, 12, -1, -21 },
  { 420, 15, 21, 16, 1, -21 },
  { 460, 11, 21, 16, 3, -21 },
  { 489, 17, 21, 16, -1, -21 },
  { 534, 16, 21, 16, 0, -21 },
  { 576, 16, 21, 16, 0, -21 },
  { 618, 16, 21, 16, 0, -21 },
  { 660, 15, 21, 16, 1, -21 },
  { 700, 16, 21, 16, 1, -21 },
  { 742, 15, 21, 16, 1, -21 },
  { 782, 14, 21, 16, 1, -21 },
  { 819, 8, 16, 8, 0, -16 },
  { 835, 10, 20, 8, -2, -16 },
  { 860, 14, 15, 17, 2, -18 },
  { 887, 14, 9, 17, 2, -15 },
  { 903, 14, 15, 17, 2, -18 },
  { 930, 12, 21, 13, 2, -21 },
  { 962, 24, 24, 25, 1, -21 },
  { 1034, 18, 21, 18, -2, -21 },
  { 1082, 17, 21, 18, 1, -21 },
  { 1127, 17, 21, 18, 2, -21 },
  { 1172, 18, 21, 20, 1, -21 },
  { 1220, 16, 21, 16, 1, -21 },
  { 1262, 16, 21, 15, 1, -21 },
  { 1304, 18, 21, 20, 2, -21 },
  { 1352, 19, 21, 20, 1, -21 },
  { 1402, 14, 21, 11, -1, -21 },
  { 1439, 15, 27, 10, -5, -21 },
  { 1490, 19, 21, 18, 1, -21 },
  { 1540, 12, 21, 15, 1, -21 },
  { 1572, 25, 21, 26, 1, -21 },
  { 1638, 21, 21, 22, 1, -21 },
  { 1694, 18, 21, 21, 2, -21 },
  { 1742, 17, 21, 18, 1, -21 },
  { 1787, 18, 26, 21, 2, -21 },
  { 1846, 16, 21, 18, 1, -21 },
  { 1888, 15, 21, 15, 1, -21 },
  { 1928, 15, 21, 15, 2, -21 },
  { 1968, 18, 21, 20, 2, -21 },
  { 2016, 17, 21, 17, 3, -21 },
  { 2061, 26, 21, 26, 3, -21 },
  { 2130, 22, 21, 18, -2, -21 },
  { 2188, 16, 21, 16, 3, -21 },
  { 2230, 18, 21, 16, -1, -21 },
  { 2278, 13, 26, 10, -1, -21 },
  { 2321, 7, 21, 12, 3, -21 },
  { 2340, 12, 26, 10, -2, -21 },
  { 2379, 15, 14, 16, 0, -21 },
  { 2406, 12, 2, 12, -3, 3 },
  { 2409, 6, 4, 9, 4, -22 },
  { 2412, 16, 16, 17, 1, -16 },
  { 2444, 15, 22, 17, 1, -22 },
  { 2486, 13, 16, 14, 1, -16 },
  { 2512, 17, 22, 17, 1, -22 },
  { 2559, 14, 16, 16, 1, -16 },
  { 2587, 17, 29, 11, -3, -22 },
  { 2649, 16, 23, 17, 1, -16 },
  { 2695, 15, 22, 18, 1, -22 },
  { 2737, 8, 22, 9, 1, -22 },
  { 2759, 13, 29, 9, -4, -22 },
  { 2807, 17, 22, 16, 1, -22 },
  { 2854, 10, 22, 9, 0, -22 },
  { 2882, 24, 16, 26, 1, -16 },
  { 2930, 15, 16, 18, 1, -16 },
  { 2960, 15, 16, 17, 1, -16 },
  { 2990, 17, 23, 17, -1, -16 },
  { 3039, 16, 23, 17, 1, -16 },
  { 3085, 12, 16, 12, 1, -16 },
  { 3109, 13, 16, 14, 0, -16 },
  { 3135, 11, 19, 12, 1, -19 },
  { 3162, 15, 16, 18, 2, -16 },
  { 3192, 16, 16, 15, 1, -16 },
  { 3224, 22, 16, 23, 2, -16 },
  { 3268, 18, 16, 15, -1, -16 },
  { 3304, 19, 23, 15, -2, -16 },
  { 3359, 15, 16, 14, -1, -16 },
  { 3389, 12, 26, 10, 0, -21 },
  { 3428, 4, 29, 16, 6, -22 },
  { 3443, 11, 26, 10, -1, -21 },
  { 3479, 14, 5, 17, 2, -13 },
};

const GFXfont NotoSans_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_BOLDITALIC29PT7B_H_
