#ifndef _NOTOSANS_BOLDITALIC11PT7B_H_
#define _NOTOSANS_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x40, 0x4C, 0xDF, 0xA0, 0x16, 0x29, 0xF9, 0x62, 0x9F,
  0xD2, 0x28, 0x19, 0xF7, 0x1C, 0x18, 0xBF, 0x88, 0x20, 0x62, 0xA4, 0xAC,
  0xAF, 0xD5, 0x2D, 0x6F, 0xCE, 0x1C, 0x34, 0x2C, 0x39, 0x7A, 0xDE, 0xCC,
  0x7E, 0xF8, 0x19, 0x18, 0x84, 0x63, 0x18, 0x42, 0x00, 0x31, 0x11, 0x11,
  0x32, 0x6C, 0x37, 0x0F, 0xE5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x78, 0xFC,
  0x70, 0x04, 0x30, 0x86, 0x30, 0x86, 0x30, 0x39, 0xB6, 0xD3, 0xCF, 0x3D,
  0x9C, 0x37, 0xF3, 0x22, 0x66, 0x39, 0xB0, 0xC2, 0x19, 0x8C, 0x3E, 0x78,
  0xB0, 0xCE, 0x38, 0x29, 0xBC, 0x0C, 0x73, 0x9A, 0x5B, 0xF1, 0x84, 0x3C,
  0xF6, 0x1E, 0x58, 0x29, 0xBC, 0x1C, 0xC6, 0x1E, 0x6F, 0x34, 0x9E, 0x7E,
  0xF8, 0x30, 0xC1, 0x06, 0x18, 0x70, 0x39, 0xB6, 0xCE, 0x7B, 0x3C, 0x9E,
  0x39, 0xB4, 0xD3, 0x7C, 0x21, 0xBC, 0x6C, 0x05, 0x80, 0x33, 0x00, 0x06,
  0xC0, 0x09, 0xF9, 0x83, 0x84, 0xFF, 0xC1, 0xF0, 0x86, 0x0C, 0x7E, 0x40,
  0xF9, 0x17, 0x48, 0xCC, 0x0F, 0x18, 0xDB, 0xAB, 0x55, 0x6E, 0xA5, 0x6C,
  0xC0, 0x3E, 0x00, 0x0C, 0x1C, 0x78, 0xB3, 0x67, 0xD8, 0xE1, 0x3C, 0x7D,
  0x9B, 0xE7, 0xC8, 0x93, 0x7C, 0x3D, 0xBC, 0x30, 0x82, 0x0C, 0x9E, 0x3C,
  0x7D, 0x9B, 0x36, 0x68, 0xD3, 0x7C, 0x3C, 0xF6, 0x1F, 0x79, 0x04, 0x3E,
  0x3C, 0xF6, 0x18, 0x79, 0x04, 0x30, 0x3D, 0xDC, 0x30, 0x9E, 0x3C, 0x9E,
  0x33, 0x22, 0x62, 0x7E, 0x7E, 0x46, 0x44, 0xCC, 0x79, 0x88, 0x46, 0x31,
  0x9C, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x04, 0x33, 0x80, 0x33, 0x26, 0x6C,
  0x78, 0x78, 0x58, 0x4C, 0xCC, 0x31, 0x18, 0xC6, 0x21, 0x1F, 0x31, 0xCC,
  0x67, 0x39, 0xCA, 0x57, 0x95, 0x65, 0xD3, 0x64, 0x31, 0x31, 0x7B, 0x7B,
  0x6A, 0x4E, 0x4E, 0xC6, 0x3C, 0xDB, 0x1E, 0x38, 0x71, 0xB3, 0x3C, 0x3C,
  0x7D, 0x9B, 0x37, 0xC8, 0x10, 0x60, 0x3C, 0xDB, 0x1E, 0x38, 0x71, 0xB7,
  0x3C, 0x18, 0x38, 0x3C, 0x59, 0x9B, 0x67, 0x89, 0x13, 0x66, 0x3D, 0xB6,
  0x1C, 0x38, 0x69, 0xBC, 0xFF, 0xE2, 0x18, 0x61, 0x84, 0x30, 0x66, 0x8B,
  0x16, 0x6C, 0xD1, 0xB6, 0x78, 0xC7, 0x3C, 0xB6, 0xD3, 0xC6, 0x18, 0xCC,
  0xF3, 0x2D, 0xDB, 0x74, 0xFF, 0x3B, 0x8E, 0xE3, 0x18, 0x33, 0x89, 0x87,
  0x83, 0x81, 0xC1, 0xE1, 0x99, 0xCC, 0xCF, 0x25, 0x9C, 0x61, 0x86, 0x10,
  0x7D, 0xF1, 0x84, 0x31, 0x8C, 0x3E, 0x32, 0x66, 0x44, 0xCC, 0xAC, 0xD9,
  0x24, 0x9B, 0x38, 0xC4, 0x21, 0x18, 0x84, 0x27, 0x00, 0x10, 0x62, 0x9A,
  0xCC, 0xF8, 0xC0, 0x3D, 0xB4, 0xF3, 0x59, 0xE0, 0x30, 0x87, 0xDB, 0x4D,
  0x34, 0xBE, 0x3B, 0x51, 0x84, 0xBC, 0x06, 0x08, 0xD3, 0x64, 0xD9, 0x92,
  0x3C, 0x39, 0xB5, 0xFC, 0x49, 0xE0, 0x1C, 0x43, 0xCC, 0x30, 0xC2, 0x08,
  0x63, 0x8C, 0x00, 0x35, 0xB4, 0xF3, 0x59, 0xA1, 0xBE, 0x60, 0x30, 0x87,
  0xDB, 0x6D, 0x34, 0xF2, 0x30, 0x66, 0x64, 0x4C, 0x18, 0x0C, 0x63, 0x10,
  0x8C, 0x66, 0x20, 0x30, 0x41, 0xBB, 0x45, 0x0E, 0x16, 0x66, 0x32, 0x66,
  0x64, 0x4C, 0x7F, 0xB7, 0x5B, 0x29, 0xB4, 0x9E, 0x4C, 0x7D, 0xB6, 0xD3,
  0x4F, 0x20, 0x39, 0xB4, 0xF3, 0x49, 0xE0, 0x7D, 0xB4, 0xD3, 0x4B, 0xEC,
  0x20, 0x80, 0x3D, 0xB4, 0xF3, 0x59, 0xA1, 0x86, 0x18, 0x7B, 0xD8, 0x84,
  0x60, 0x7A, 0x58, 0x69, 0x78, 0x23, 0xF8, 0xC4, 0x21, 0xC0, 0xCE, 0x67,
  0x3B, 0xF8, 0x9C, 0xAD, 0x4E, 0x60, 0x9B, 0xBB, 0xAE, 0xAE, 0xCC, 0xCC,
  0x36, 0x78, 0x60, 0xC2, 0xDD, 0x80, 0x26, 0x48, 0xB1, 0x43, 0x86, 0x0C,
  0x70, 0xC0, 0x78, 0xCC, 0xCC, 0x78, 0x19, 0x88, 0x4E, 0x61, 0x08, 0x63,
  0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x84, 0x61, 0x9C, 0x84, 0xE6, 0x00, 0xCD,
  0xC0,
};

const GFXglyph NotoSans_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 8, 3, 0, -8 },
  { 5, 4, 3, 5, 1, -8 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 6, 9, 6, 0, -8 },
  { 21, 8, 8, 9, 1, -8 },
  { 29, 8, 8, 8, 0, -8 },
  { 37, 2, 3, 3, 1, -8 },
  { 38, 5, 10, 4, 0, -8 },
  { 45, 4, 10, 4, -1, -8 },
  { 50, 5, 5, 6, 1, -8 },
  { 54, 5, 6, 6, 1, -7 },
  { 58, 3, 2, 3, -1, -1 },
  { 59, 3, 2, 4, 0, -4 },
  { 60, 2, 2, 3, 0, -2 },
  { 61, 6, 8, 5, -1, -8 },
  { 67, 6, 8, 6, 0, -8 },
  { 73, 4, 8, 6, 1, -8 },
  { 77, 6, 8, 6, 0, -8 },
  { 83, 6, 8, 6, 0, -8 },
  { 89, 6, 8, 6, 0, -8 },
  { 95, 6, 8, 6, 0, -8 },
  { 101, 6, 8, 6, 0, -8 },
  { 107, 7, 8, 6, 0, -8 },
  { 114, 6, 8, 6, 0, -8 },
  { 120, 6, 8, 6, 0, -8 },
  { 126, 3, 6, 3, 0, -6 },
  { 129, 4, 7, 3, -1, -6 },
  { 133, 5, 6, 6, 1, -7 },
  { 137, 5, 4, 6, 1, -6 },
  { 140, 5, 6, 6, 1, -7 },
  { 144, 4, 8, 5, 1, -8 },
  { 148, 9, 9, 9, 0, -8 },
  { 159, 7, 8, 7, -1, -8 },
  { 166, 7, 8, 7, 0, -8 },
  { 173, 6, 8, 7, 1, -8 },
  { 179, 7, 8, 7, 0, -8 },
  { 186, 6, 8, 6, 0, -8 },
  { 192, 6, 8, 6, 0, -8 },
  { 198, 6, 8, 8, 1, -8 },
  { 204, 8, 8, 8, 0, -8 },
  { 212, 5, 8, 4, 0, -8 },
  { 217, 6, 10, 4, -2, -8 },
  { 225, 8, 8, 7, 0, -8 },
  { 233, 5, 8, 6, 0, -8 },
  { 238, 10, 8, 10, 0, -8 },
  { 248, 8, 8, 8, 0, -8 },
  { 256, 7, 8, 8, 1, -8 },
  { 263, 7, 8, 7, 0, -8 },
  { 270, 7, 10, 8, 1, -8 },
  { 279, 7, 8, 7, 0, -8 },
  { 286, 6, 8, 6, 0, -8 },
  { 292, 6, 8, 6, 1, -8 },
  { 298, 7, 8, 8, 1, -8 },
  { 305, 6, 8, 6, 1, -8 },
  { 311, 10, 8, 10, 1, -8 },
  { 321, 9, 8, 7, -1, -8 },
  { 330, 6, 8, 6, 1, -8 },
  { 336, 6, 8, 6, 0, -8 },
  { 342, 4, 10, 4, 0, -8 },
  { 347, 3, 8, 5, 1, -8 },
  { 350, 5, 10, 4, -1, -8 },
  { 357, 6, 5, 6, 0, -8 },
  { 361, 5, 1, 4, -1, 1 },
  { 362, 2, 1, 4, 2, -8 },
  { 363, 6, 6, 7, 0, -6 },
  { 368, 6, 8, 7, 0, -8 },
  { 374, 5, 6, 5, 0, -6 },
  { 378, 7, 8, 7, 0, -8 },
  { 385, 6, 6, 6, 0, -6 },
  { 390, 6, 11, 4, -1, -8 },
  { 399, 6, 9, 7, 0, -6 },
  { 406, 6, 8, 7, 0, -8 },
  { 412, 4, 8, 3, 0, -8 },
  { 416, 5, 11, 3, -1, -8 },
  { 423, 7, 8, 6, 0, -8 },
  { 430, 4, 8, 3, 0, -8 },
  { 434, 9, 6, 10, 0, -6 },
  { 441, 6, 6, 7, 0, -6 },
  { 446, 6, 6, 6, 0, -6 },
  { 451, 6, 9, 7, 0, -6 },
  { 458, 6, 9, 7, 0, -6 },
  { 465, 5, 6, 5, 0, -6 },
  { 469, 5, 6, 5, 0, -6 },
  { 473, 5, 7, 5, 0, -7 },
  { 478, 5, 6, 7, 1, -6 },
  { 482, 5, 6, 6, 1, -6 },
  { 486, 8, 6, 9, 1, -6 },
  { 492, 7, 6, 6, -1, -6 },
  { 498, 7, 9, 6, -1, -6 },
  { 506, 5, 6, 5, 0, -6 },
  { 510, 5, 10, 4, 0, -8 },
  { 517, 2, 11, 6, 2, -8 },
  { 520, 5, 10, 4, -1, -8 },
  { 527, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_BOLDITALIC11PT7B_H_
