#ifndef _NOTOSANS_BOLDITALIC41PT7B_H_
#define _NOTOSANS_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0xC0,
  0x08, 0x00, 0x7E, 0x7E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x0F, 0x1E, 0x1E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE0, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F,
  0x80, 0x03, 0xC3, 0xC1, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xCC, 0x70, 0xFC, 0xE0, 0x07, 0xE7,
  0x00, 0x3F, 0x38, 0x01, 0xFD, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0x7F, 0x00, 0x39, 0xFA, 0x01, 0x8F, 0xDC, 0x1C, 0xFC, 0xFE,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x1F,
  0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x7C,
  0x7C, 0x0F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x1E, 0x00, 0xFC,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0xF1, 0xF8, 0xF8, 0xF9, 0xF7, 0xFC, 0x7D, 0xFB, 0xEF, 0xFE, 0x7F,
  0xF7, 0xCF, 0xFE, 0x7F, 0xE7, 0x9F, 0xBE, 0x3F, 0xCF, 0x9F, 0x1F, 0x07,
  0x1F, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x3C, 0x3E, 0x3E, 0x00,
  0x7C, 0x3E, 0x3E, 0x00, 0xF8, 0x3C, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x01,
  0xF0, 0x7C, 0x7E, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x3F, 0xFC, 0x0F,
  0x80, 0x3F, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x1F, 0xFF, 0x07, 0xE3, 0xFF,
  0xF0, 0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xE1, 0xFD, 0xF8, 0x7E, 0x0F, 0xFF,
  0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x7F, 0x00, 0xFF, 0xC3, 0xFC, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x1E, 0x7C, 0xF1, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x30, 0x7C, 0x07,
  0xC7, 0x80, 0x7F, 0x78, 0x07, 0xFF, 0x1F, 0xBF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0x9F, 0x0F, 0xFC, 0x01, 0xFB, 0xC0, 0x3F, 0x3E,
  0x03, 0xF3, 0xE0, 0x1E, 0x1F, 0x00, 0x41, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x00,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0x3E, 0x7E, 0xFF,
  0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFF,
  0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE,
  0xFF, 0x7C, 0x7C, 0xFC, 0x78, 0xFC, 0x20, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3F, 0x80, 0xC0, 0x3F, 0x01, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0x8F, 0xF0, 0x30, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x20, 0x01, 0xFC, 0xC0, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x1F,
  0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0x8F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x88, 0x00, 0xFE, 0x30, 0x07, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x08, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x07, 0xEF, 0xF8,
  0x3E, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF9, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0x81, 0xF8,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE,
  0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFC, 0xFE, 0x3F, 0x07, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xF7, 0xE0, 0xFF, 0x7F, 0x1F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0x7E, 0x1F, 0xE7, 0xE0, 0x38, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFC, 0x1F, 0x00, 0x80, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9,
  0xF1, 0xFC, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x03, 0xFF, 0x0F, 0x1F, 0x07, 0xFF, 0xC7,
  0x9F, 0x07, 0xFF, 0xC3, 0xEF, 0x87, 0xE1, 0xE1, 0xF7, 0x87, 0xE1, 0xF0,
  0xFF, 0xC3, 0xE0, 0xF8, 0x7F, 0xE3, 0xE0, 0x78, 0x3F, 0xF1, 0xF0, 0x3C,
  0x1E, 0xF0, 0xF8, 0x3E, 0x0F, 0x78, 0x78, 0x1E, 0x0F, 0xBC, 0x3C, 0x1F,
  0x07, 0x9E, 0x1E, 0x0F, 0x87, 0xCF, 0x0F, 0x8F, 0xC7, 0xC7, 0xC7, 0xFF,
  0xFF, 0xE3, 0xE1, 0xFF, 0x7F, 0xE1, 0xF0, 0xFF, 0x3F, 0xE0, 0x7C, 0x1E,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x40, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xE0,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x38, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x60, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x20,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x30, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0x7E, 0x07, 0xFF, 0x3F, 0x83,
  0xFF, 0xCF, 0xE0, 0xFF, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F,
  0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0xF9, 0xF8,
  0x3F, 0x3C, 0x1F, 0x3E, 0x07, 0xE7, 0x87, 0xC7, 0xC0, 0xF8, 0xF0, 0xF9,
  0xF8, 0x1F, 0x1E, 0x3E, 0x3F, 0x07, 0xE3, 0xC7, 0xC7, 0xE0, 0xFC, 0x79,
  0xF0, 0xF8, 0x1F, 0x8F, 0xBE, 0x3F, 0x03, 0xE1, 0xFF, 0x87, 0xE0, 0x7C,
  0x3F, 0xF0, 0xFC, 0x1F, 0x87, 0xFC, 0x1F, 0x03, 0xF0, 0xFF, 0x83, 0xE0,
  0x7E, 0x1F, 0xE0, 0xFC, 0x0F, 0x83, 0xFC, 0x1F, 0x81, 0xF0, 0x7F, 0x03,
  0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC1, 0xFF, 0x80,
  0x3E, 0x07, 0xFE, 0x00, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0xF0, 0x1F,
  0x81, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0x01, 0xF0, 0x3E, 0x7C, 0x07, 0xC0,
  0xF9, 0xF8, 0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0x0F, 0x8F, 0x83, 0xF0, 0x7E,
  0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x3E, 0x07, 0xC1, 0xF1, 0xF8, 0x1F, 0x07,
  0xE7, 0xE0, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xFD,
  0xF0, 0x3E, 0x03, 0xF7, 0xC0, 0xF8, 0x07, 0xFF, 0x07, 0xE0, 0x1F, 0xF8,
  0x1F, 0x80, 0x7F, 0xE0, 0x7E, 0x00, 0xFF, 0x81, 0xF0, 0x03, 0xFE, 0x07,
  0xC0, 0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x10, 0x03, 0xF8, 0xE0, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xC0, 0x1F, 0xBE, 0x00, 0xFE, 0x01, 0xF9, 0xF0, 0x07, 0xF0, 0x0F,
  0xCF, 0x80, 0x7F, 0x80, 0xFC, 0x7C, 0x03, 0xFC, 0x07, 0xE3, 0xE0, 0x3F,
  0xE0, 0x3F, 0x1F, 0x01, 0xFF, 0x03, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x87,
  0xC0, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0xBE, 0x0F, 0xC1, 0xF8, 0x7D, 0xF0,
  0xFC, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0x7E, 0x3E, 0x7C, 0x3E, 0x03, 0xF1,
  0xF3, 0xE3, 0xF0, 0x1F, 0x9F, 0x1F, 0x1F, 0x80, 0xFC, 0xF8, 0xF9, 0xF8,
  0x07, 0xEF, 0xC7, 0xCF, 0xC0, 0x3F, 0x7C, 0x3E, 0x7C, 0x01, 0xF3, 0xE1,
  0xF7, 0xE0, 0x0F, 0xBE, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F,
  0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80,
  0x7E, 0x7E, 0x00, 0x7D, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xE7,
  0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x0F,
  0x80, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x3E, 0x7C, 0x00, 0xF7, 0xC0, 0x07,
  0xBE, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x3F, 0x0F, 0x87,
  0xE1, 0xF0, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0xF3, 0xF0, 0x7F, 0xEF, 0x83,
  0xFF, 0xBE, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC0,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xBE, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0x80, 0x3F, 0x3F, 0x80, 0xFD,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F,
  0x87, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7C, 0x07, 0xF3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x9F, 0x80,
  0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFB, 0xFF, 0x83, 0xE7, 0xFC, 0x0F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xF0, 0xE3, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x81, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xF0, 0xFC, 0x03, 0xFC, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF7, 0x80, 0x3F, 0xEF, 0x80, 0x1F, 0xCF, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xF8,
  0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x07, 0xE7, 0xE1, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x08, 0xFF, 0x07, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xE6, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x8F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFC, 0xFC, 0x0F, 0xFD, 0xF0, 0x3F, 0xFB, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x03,
  0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x02, 0x00, 0x7E, 0x07, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xC0, 0x3F,
  0x3F, 0xC0, 0xFD, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xC7,
  0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE3,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00,
  0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x20, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x02, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F,
  0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xE3, 0xFC, 0x3F,
  0xC0, 0xF9, 0xFF, 0x1F, 0xF8, 0x3E, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFC, 0x7F, 0xC7, 0xF1, 0xFE, 0x1F, 0xE0, 0xFC, 0x7F, 0x07,
  0xF8, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x03, 0xF3, 0xF8,
  0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x03,
  0xF3, 0xF8, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x3F, 0xC0,
  0xF9, 0xFF, 0x83, 0xEF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF1, 0xFE,
  0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC,
  0x7F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xE7, 0xF8, 0x03, 0xEF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0x7F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x04, 0x0F, 0xF1, 0xE0, 0x7F, 0xEF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xEF, 0x80, 0xFF, 0x7E, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC3, 0xE3, 0xF0, 0xF9,
  0xF8, 0x3E, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x03,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x90, 0x07, 0xF3, 0xE1, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0xC1, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFF, 0x70, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xFD, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFD, 0xF0, 0x7F, 0xE7, 0xC0, 0x7E, 0x1E, 0x00,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFC, 0xF8, 0x0F, 0xC7, 0xC0,
  0xFE, 0x3E, 0x07, 0xE1, 0xF0, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83,
  0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7E,
  0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x7C, 0x0F, 0xE0, 0x7F, 0x7C, 0x0F, 0xE0, 0x7E, 0x7C, 0x1F,
  0xE0, 0x7E, 0x7C, 0x1F, 0xE0, 0xFC, 0x7C, 0x3F, 0xE0, 0xFC, 0x7C, 0x3D,
  0xE1, 0xF8, 0x7C, 0x3D, 0xE1, 0xF8, 0x7C, 0x7D, 0xE3, 0xF0, 0x7C, 0x79,
  0xE3, 0xF0, 0x7C, 0xF9, 0xE7, 0xE0, 0x7C, 0xF9, 0xE7, 0xE0, 0x7D, 0xF1,
  0xE7, 0xC0, 0x7D, 0xF1, 0xEF, 0xC0, 0x7D, 0xE1, 0xEF, 0x80, 0x7F, 0xE1,
  0xEF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x07, 0xE3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x17, 0xFE, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 30, 12, 0, -29 },
  { 50, 15, 10, 19, 4, -29 },
  { 69, 26, 29, 26, 1, -29 },
  { 164, 21, 33, 23, 1, -31 },
  { 251, 32, 30, 35, 2, -30 },
  { 371, 28, 30, 29, 1, -30 },
  { 476, 7, 10, 10, 4, -29 },
  { 485, 16, 35, 14, 1, -29 },
  { 555, 15, 36, 14, -3, -30 },
  { 623, 20, 19, 22, 3, -31 },
  { 671, 20, 19, 23, 2, -24 },
  { 719, 10, 10, 12, -2, -5 },
  { 732, 11, 6, 13, 1, -14 },
  { 741, 8, 7, 12, 0, -6 },
  { 748, 22, 30, 17, -2, -30 },
  { 831, 21, 30, 23, 1, -30 },
  { 910, 16, 29, 23, 4, -29 },
  { 968, 23, 30, 23, -1, -30 },
  { 1055, 22, 30, 23, 0, -30 },
  { 1138, 22, 29, 23, 0, -29 },
  { 1218, 22, 29, 23, 1, -29 },
  { 1298, 21, 30, 23, 2, -30 },
  { 1377, 22, 29, 23, 2, -29 },
  { 1457, 22, 30, 23, 1, -30 },
  { 1540, 20, 30, 23, 2, -30 },
  { 1615, 11, 24, 12, 0, -23 },
  { 1648, 13, 28, 12, -2, -23 },
  { 1694, 20, 22, 23, 2, -26 },
  { 1749, 20, 13, 23, 2, -21 },
  { 1782, 20, 22, 23, 2, -26 },
  { 1837, 17, 31, 19, 3, -30 },
  { 1903, 33, 33, 35, 2, -29 },
  { 2040, 25, 29, 26, -2, -29 },
  { 2131, 24, 29, 25, 1, -29 },
  { 2218, 25, 30, 25, 2, -30 },
  { 2312, 25, 29, 28, 1, -29 },
  { 2403, 23, 29, 22, 1, -29 },
  { 2487, 23, 29, 22, 1, -29 },
  { 2571, 26, 30, 28, 2, -30 },
  { 2669, 28, 29, 29, 1, -29 },
  { 2771, 19, 29, 16, -1, -29 },
  { 2840, 20, 38, 14, -6, -29 },
  { 2935, 28, 29, 25, 1, -29 },
  { 3037, 17, 29, 21, 1, -29 },
  { 3099, 35, 29, 36, 1, -29 },
  { 3226, 30, 29, 31, 1, -29 },
  { 3335, 27, 30, 30, 2, -30 },
  { 3437, 24, 29, 25, 1, -29 },
  { 3524, 27, 37, 30, 2, -30 },
  { 3649, 23, 29, 25, 1, -29 },
  { 3733, 21, 30, 22, 1, -30 },
  { 3812, 22, 29, 22, 3, -29 },
  { 3892, 26, 29, 28, 3, -29 },
  { 3987, 24, 29, 24, 4, -29 },
  { 4074, 37, 29, 37, 4, -29 },
  { 4209, 30, 29, 25, -2, -29 },
  { 4318, 23, 29, 23, 4, -29 },
  { 4402, 25, 29, 22, -1, -29 },
  { 4493, 17, 35, 14, -1, -29 },
  { 4568, 10, 30, 17, 4, -30 },
  { 4606, 17, 35, 14, -3, -29 },
  { 4681, 21, 19, 23, 1, -29 },
  { 4731, 17, 2, 16, -4, 4 },
  { 4736, 9, 6, 13, 6, -31 },
  { 4743, 22, 23, 24, 2, -23 },
  { 4807, 22, 31, 24, 1, -31 },
  { 4893, 18, 23, 20, 2, -23 },
  { 4945, 24, 31, 24, 2, -31 },
  { 5038, 20, 23, 23, 2, -23 },
  { 5096, 24, 41, 15, -4, -31 },
  { 5219, 23, 33, 24, 1, -23 },
  { 5314, 22, 31, 25, 1, -31 },
  { 5400, 12, 31, 12, 1, -31 },
  { 5447, 18, 41, 12, -5, -31 },
  { 5540, 24, 31, 23, 1, -31 },
  { 5633, 12, 31, 12, 1, -31 },
  { 5680, 34, 23, 37, 1, -23 },
  { 5778, 22, 23, 25, 1, -23 },
  { 5842, 20, 23, 24, 2, -23 },
  { 5900, 24, 33, 24, -1, -23 },
  { 5999, 22, 33, 24, 2, -23 },
  { 6090, 18, 23, 17, 1, -23 },
  { 6142, 19, 23, 19, 0, -23 },
  { 6197, 16, 27, 17, 2, -27 },
  { 6251, 22, 22, 25, 2, -22 },
  { 6312, 21, 22, 21, 2, -22 },
  { 6370, 32, 22, 32, 2, -22 },
  { 6458, 26, 22, 22, -2, -22 },
  { 6530, 26, 32, 21, -3, -22 },
  { 6634, 21, 22, 19, -1, -22 },
  { 6692, 17, 35, 15, 0, -29 },
  { 6767, 4, 40, 23, 9, -31 },
  { 6787, 17, 35, 15, -2, -29 },
  { 6862, 20, 7, 23, 2, -18 },
};

const GFXfont NotoSans_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_BOLDITALIC41PT7B_H_
