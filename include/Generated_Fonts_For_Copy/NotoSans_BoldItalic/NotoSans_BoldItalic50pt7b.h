#ifndef _NOTOSANS_BOLDITALIC50PT7B_H_
#define _NOTOSANS_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x3F,
  0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF9, 0xF0, 0x7C, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0x3C, 0x70, 0x3F, 0xCE, 0x04, 0x0F, 0xE3, 0x80, 0x03,
  0xF8, 0xE0, 0x00, 0xFF, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1E, 0xFF, 0x00, 0x07, 0x9F, 0xC0, 0x01, 0xC7, 0xF2, 0x00, 0x71, 0xFC,
  0xE0, 0x3C, 0xFF, 0x3E, 0x0F, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x07,
  0xF1, 0xF8, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x7E, 0x1F, 0x81,
  0xF8, 0x03, 0xF8, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x3F,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x7E,
  0x00, 0x0F, 0xC3, 0xF1, 0xF0, 0xFC, 0x3F, 0x1F, 0xCF, 0xCF, 0xFC, 0xFC,
  0xFE, 0x7E, 0x7F, 0xFB, 0xFF, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x9F,
  0xFF, 0xDF, 0xFE, 0x7E, 0x7F, 0x7F, 0x3F, 0xF3, 0xF3, 0xF8, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x7E, 0x00, 0xFC, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xE0, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x00, 0x0F, 0xFF,
  0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xF0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0xF8, 0x1F, 0xE3, 0xFF, 0xFE, 0x0F,
  0xE3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xE7, 0xF1, 0xFE, 0x0F, 0xF7,
  0xF8, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0x7F,
  0xF8, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x20, 0x1F, 0x80, 0x30, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7F,
  0x1F, 0x00, 0x7F, 0xDE, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0x07,
  0xFF, 0x00, 0x0F, 0xEF, 0x80, 0x1F, 0xCF, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0x07, 0xE0, 0x06, 0x07, 0xE0, 0x02, 0x07, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0E, 0x1F, 0xDF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xF7,
  0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x1F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0x9F, 0xC3, 0xF1, 0xFC,
  0x1C, 0x1F, 0xC1, 0x83, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFC, 0x3F,
  0xF0, 0x1F, 0x00, 0xFF, 0x00, 0xE0, 0x0F, 0xF0, 0x04, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x08, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7C, 0x0F, 0xF8, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC8, 0x00, 0x0F, 0xF1, 0xE0, 0x07, 0xFE, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC4, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xC7, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x08, 0x00, 0x3F, 0xE1, 0xC0, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0xFB, 0xFF, 0x81, 0xFD,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8,
  0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFC, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7,
  0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFE,
  0x7F, 0x81, 0xFF, 0x3F, 0xF3, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xF0, 0x1F, 0xE3, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x04, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x18, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF8,
  0x3F, 0xC6, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xF0, 0x3F, 0x1F, 0x80, 0xFF, 0xFE, 0x3F, 0x1F, 0x81, 0xFF,
  0xFC, 0x1F, 0x3F, 0x03, 0xFF, 0xFC, 0x1F, 0x3F, 0x07, 0xF8, 0xFC, 0x1F,
  0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x7C, 0x1F,
  0x80, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x7C, 0x3F, 0x01, 0xF8,
  0x3F, 0xFC, 0x3F, 0x01, 0xF0, 0x3F, 0xFC, 0x3F, 0x03, 0xF0, 0x3E, 0xFC,
  0x3E, 0x03, 0xF0, 0x7E, 0xFC, 0x3E, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0xFC, 0x3F, 0xBF, 0xFF, 0xF8,
  0x7C, 0x1F, 0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0xFD, 0xFF, 0xE0, 0x7E, 0x0F,
  0xF8, 0xFF, 0xC0, 0x7E, 0x03, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81,
  0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE0, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0x03,
  0xFF, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x20, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x02, 0x01, 0xFF, 0x80,
  0x78, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xF3, 0xFC, 0x07,
  0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0x1F, 0xE0, 0x7F,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x17, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0xC0, 0x7E, 0xF8, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F, 0xFE, 0x03, 0xFB, 0xE0, 0x0F, 0xDF,
  0xC0, 0x7F, 0x7C, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x03, 0xF3, 0xF8, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0x1F, 0x8F, 0xE0, 0x3F, 0x9F, 0x83,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE0, 0x3F, 0x8F, 0xC7, 0xE1, 0xFC, 0x07, 0xF1, 0xF8, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE7, 0xE1, 0xFC, 0x03, 0xF0,
  0x7D, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xBF, 0x07, 0xF0, 0x1F, 0xC1, 0xFF,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x00, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xE0,
  0x03, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x00, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0xFD, 0xFC, 0x03,
  0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0x03, 0xF9,
  0xFC, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F, 0x00, 0xFC, 0x7F, 0x03, 0xF8,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F, 0x00, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0x0F, 0xE7,
  0xE0, 0x1F, 0xC0, 0x7F, 0x7F, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0x80, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03,
  0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF9, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC1, 0xF0, 0x1F, 0xE0, 0x04, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xC0, 0x03,
  0xFC, 0x3C, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x8F,
  0xE0, 0x1F, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0xF0, 0x0F, 0xE0, 0xFE, 0x07,
  0xEF, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFB,
  0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0xFC,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE7, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x3F, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0,
  0x07, 0xF3, 0xF8, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0x83, 0xF3, 0xF8, 0x01,
  0xFC, 0xFC, 0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x7F,
  0x7E, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xFC, 0x7F, 0x00, 0x7F, 0x87,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x83,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3E,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x07, 0xFF, 0x3F, 0x81, 0xFF, 0xF7, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xF0, 0xFF, 0x83,
  0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFC, 0x07, 0xFF,
  0xBF, 0x80, 0x7F, 0xE7, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE1,
  0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xF0, 0x0F, 0xEF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFC, 0x0F, 0xC7, 0xFF, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFE, 0x1E, 0x0F, 0xF8, 0x04, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x02,
  0x0F, 0xF0, 0x1C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0x83, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xFD, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFD, 0xF8, 0x01, 0xFF,
  0xCF, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x7F, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xC1, 0xFF, 0x03, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFC, 0x3F, 0x00, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFD, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x80,
  0x07, 0xF8, 0x0E, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE1, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xF8, 0x0F,
  0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xE1, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x23, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x40,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x7F, 0xC0, 0xFF, 0x80, 0x7E, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0x9F, 0xFE,
  0x3F, 0xFE, 0x07, 0xEF, 0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x7F,
  0x00, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x3F, 0xE0, 0x1F, 0x8F, 0xFE, 0x03, 0xF3, 0xFF, 0xE0, 0x7E, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xF8, 0x7F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xE3, 0xFC, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F,
  0xE3, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x0F, 0xCF,
  0xFE, 0x00, 0x3F, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0x7F, 0xFC, 0x01, 0xFC, 0xFF, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x1F,
  0xC0, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xF0, 0xFC, 0x07, 0xFF, 0x3F, 0x01, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x80,
  0x7F, 0xEF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1, 0xF9, 0xFE, 0x07, 0xEF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xC4, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFC, 0x07, 0x0F,
  0xF0, 0x04, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE2, 0x00, 0x7F, 0x8F, 0x03, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xEF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0x1F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC,
  0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x8F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x1F, 0xF0, 0xFE, 0x0F, 0xFC, 0x3F, 0xEF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF7, 0xE0, 0x7F, 0xF9, 0xF8, 0x0F, 0xFC, 0x7E, 0x01, 0xFE, 0x1F,
  0x80, 0x08, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0x07, 0xF9, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xFC, 0x07, 0xE0,
  0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0xE0, 0x7F,
  0x9F, 0xC0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x7F, 0x07,
  0xDF, 0x07, 0xF0, 0xFE, 0x1F, 0xBE, 0x0F, 0xE0, 0xFC, 0x3F, 0x7C, 0x3F,
  0x81, 0xF8, 0x7C, 0xF8, 0x7F, 0x03, 0xF1, 0xF9, 0xF1, 0xFC, 0x07, 0xE3,
  0xE3, 0xE3, 0xF8, 0x0F, 0xCF, 0xC7, 0xCF, 0xE0, 0x1F, 0x9F, 0x8F, 0x9F,
  0xC0, 0x3F, 0x7E, 0x1F, 0x3F, 0x00, 0x7E, 0xFC, 0x3E, 0xFE, 0x00, 0xFD,
  0xF0, 0x7D, 0xFC, 0x01, 0xFF, 0xE0, 0xFB, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFF, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0x7F, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC,
  0x80, 0x00, 0x40,
};

const GFXglyph NotoSans_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 37, 14, 1, -36 },
  { 71, 18, 13, 23, 5, -36 },
  { 101, 32, 36, 32, 1, -36 },
  { 245, 26, 41, 28, 1, -38 },
  { 379, 38, 36, 43, 3, -36 },
  { 550, 33, 37, 35, 2, -36 },
  { 703, 8, 13, 13, 5, -36 },
  { 716, 19, 44, 17, 2, -36 },
  { 821, 19, 44, 17, -4, -36 },
  { 926, 24, 24, 27, 4, -38 },
  { 998, 24, 24, 29, 3, -30 },
  { 1070, 12, 12, 14, -2, -6 },
  { 1088, 14, 7, 16, 1, -17 },
  { 1101, 9, 9, 14, 0, -8 },
  { 1112, 27, 36, 21, -2, -36 },
  { 1234, 25, 37, 28, 2, -36 },
  { 1350, 20, 36, 28, 4, -36 },
  { 1440, 28, 36, 28, -1, -36 },
  { 1566, 27, 37, 28, 0, -36 },
  { 1691, 28, 36, 28, -1, -36 },
  { 1817, 27, 37, 28, 1, -36 },
  { 1942, 26, 37, 28, 2, -36 },
  { 2063, 28, 36, 28, 2, -36 },
  { 2189, 27, 37, 28, 1, -36 },
  { 2314, 25, 37, 28, 2, -36 },
  { 2430, 14, 29, 14, 0, -28 },
  { 2481, 17, 34, 14, -3, -28 },
  { 2554, 24, 26, 29, 3, -31 },
  { 2632, 24, 15, 29, 3, -25 },
  { 2677, 24, 26, 29, 3, -31 },
  { 2755, 21, 37, 23, 4, -36 },
  { 2853, 40, 41, 43, 2, -36 },
  { 3058, 31, 36, 31, -3, -36 },
  { 3198, 30, 36, 31, 1, -36 },
  { 3333, 30, 37, 31, 3, -36 },
  { 3472, 31, 36, 34, 1, -36 },
  { 3612, 28, 36, 27, 1, -36 },
  { 3738, 28, 36, 27, 1, -36 },
  { 3864, 31, 37, 35, 3, -36 },
  { 4008, 34, 36, 35, 1, -36 },
  { 4161, 23, 36, 19, -1, -36 },
  { 4265, 25, 47, 17, -8, -36 },
  { 4412, 34, 36, 31, 1, -36 },
  { 4565, 22, 36, 26, 1, -36 },
  { 4664, 43, 36, 44, 1, -36 },
  { 4858, 37, 36, 38, 1, -36 },
  { 5025, 32, 37, 37, 3, -36 },
  { 5173, 30, 36, 31, 1, -36 },
  { 5308, 32, 45, 37, 3, -36 },
  { 5488, 29, 36, 31, 1, -36 },
  { 5619, 26, 37, 27, 1, -36 },
  { 5740, 26, 36, 27, 4, -36 },
  { 5857, 32, 37, 35, 3, -36 },
  { 6005, 30, 36, 30, 4, -36 },
  { 6140, 45, 36, 45, 4, -36 },
  { 6343, 37, 36, 31, -3, -36 },
  { 6510, 28, 36, 28, 5, -36 },
  { 6636, 31, 36, 27, -2, -36 },
  { 6776, 21, 44, 17, -1, -36 },
  { 6892, 12, 36, 21, 5, -36 },
  { 6946, 20, 44, 17, -3, -36 },
  { 7056, 25, 23, 28, 1, -36 },
  { 7128, 21, 4, 20, -5, 4 },
  { 7139, 11, 8, 16, 7, -38 },
  { 7150, 27, 29, 30, 2, -28 },
  { 7248, 27, 39, 30, 1, -38 },
  { 7380, 23, 29, 24, 2, -28 },
  { 7464, 29, 39, 30, 2, -38 },
  { 7606, 25, 29, 28, 2, -28 },
  { 7697, 29, 50, 19, -5, -38 },
  { 7879, 28, 40, 30, 1, -28 },
  { 8019, 27, 38, 30, 1, -38 },
  { 8148, 15, 38, 15, 1, -38 },
  { 8220, 22, 50, 15, -6, -38 },
  { 8358, 30, 38, 28, 1, -38 },
  { 8501, 15, 38, 15, 1, -38 },
  { 8573, 42, 28, 45, 1, -28 },
  { 8720, 27, 28, 30, 1, -28 },
  { 8815, 25, 29, 29, 2, -28 },
  { 8906, 30, 40, 30, -2, -28 },
  { 9056, 27, 40, 30, 2, -28 },
  { 9191, 22, 28, 21, 1, -28 },
  { 9268, 22, 29, 24, 1, -28 },
  { 9348, 19, 34, 21, 2, -33 },
  { 9429, 26, 28, 30, 3, -27 },
  { 9520, 27, 27, 26, 2, -27 },
  { 9612, 39, 27, 39, 3, -27 },
  { 9744, 32, 27, 27, -3, -27 },
  { 9852, 32, 39, 26, -3, -27 },
  { 10008, 25, 27, 23, -1, -27 },
  { 10093, 21, 44, 18, 0, -36 },
  { 10209, 5, 49, 28, 11, -38 },
  { 10240, 21, 44, 18, -3, -36 },
  { 10356, 24, 9, 29, 3, -22 },
};

const GFXfont NotoSans_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_BOLDITALIC50PT7B_H_
