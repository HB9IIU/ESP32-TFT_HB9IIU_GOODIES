#ifndef _NOTOSANS_BOLDITALIC49PT7B_H_
#define _NOTOSANS_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0x80, 0x00, 0x7F, 0x1F, 0xDF,
  0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F, 0xC7, 0xC3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFE, 0xE7, 0xC0, 0xFF, 0x38, 0x30, 0x3F, 0x8E, 0x00, 0x0F, 0xE7,
  0x80, 0x03, 0xF9, 0xE0, 0x00, 0xFF, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x77,
  0xFC, 0x00, 0x1C, 0xFF, 0x00, 0x07, 0x1F, 0xC0, 0x01, 0xC7, 0xF3, 0x00,
  0xF3, 0xF8, 0xF8, 0x39, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xF0,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x7E, 0x03,
  0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xE0, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x8F, 0x81, 0x03, 0xF1, 0xF8,
  0xF8, 0xFF, 0x1F, 0x8F, 0xCF, 0xCF, 0xFE, 0xFF, 0xFC, 0xFC, 0xFF, 0xF7,
  0xFF, 0xE7, 0xCF, 0xFF, 0xDF, 0xFE, 0x7E, 0xFF, 0xFE, 0x7F, 0xE7, 0xE7,
  0xE3, 0xF1, 0xFE, 0x7E, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0xFC, 0x00,
  0x3F, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE1,
  0xF8, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0xFC, 0x01, 0xF8,
  0x1F, 0x87, 0xE0, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03,
  0xF8, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0x07,
  0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xC0, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F,
  0xDF, 0xE1, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0xFF, 0x07, 0xFB, 0xF8, 0xFF,
  0x07, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0x07, 0xFC, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x20, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x7F, 0xBE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0xFE, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x7F, 0x8F, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x06, 0x0F, 0xE0, 0x02, 0x07, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE1,
  0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xE0, 0x04, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x1C,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xF7, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFC, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFD,
  0xFC, 0x3F, 0x1F, 0xC3, 0xE3, 0xF8, 0x18, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7E, 0x07, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1E,
  0x03, 0xFC, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF2, 0x00, 0x03, 0xFC, 0xE0, 0x03,
  0xFE, 0x3F, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE2,
  0x00, 0x0F, 0xF0, 0xE0, 0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x70, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xF0, 0x03,
  0xF9, 0xFF, 0x01, 0xFD, 0xFF, 0xE0, 0x7F, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xC1, 0xFF, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x88, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0xDF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x87,
  0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFB, 0xFE, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC3,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFE,
  0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x83,
  0xF8, 0x1F, 0xC0, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFB, 0xFF, 0x38, 0x07, 0xF2, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x0E, 0x00, 0xFC, 0x7E, 0x01, 0xFF, 0xE1,
  0xF8, 0xFC, 0x0F, 0xFF, 0xE1, 0xF3, 0xF0, 0x3F, 0xFF, 0xC3, 0xE7, 0xE0,
  0xFF, 0xFF, 0x07, 0xCF, 0x83, 0xF8, 0x3E, 0x0F, 0xBF, 0x07, 0xE0, 0xFC,
  0x1F, 0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0xF8, 0x3E, 0x03, 0xE0, 0x7D, 0xF0,
  0xFC, 0x07, 0xC0, 0xFF, 0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xC3, 0xE0, 0x3E,
  0x07, 0xFF, 0x87, 0xC0, 0x7C, 0x0F, 0xBF, 0x0F, 0x81, 0xF8, 0x3F, 0x7E,
  0x1F, 0x03, 0xF0, 0x7E, 0xFC, 0x3E, 0x0F, 0xE1, 0xF9, 0xF8, 0x7E, 0x7F,
  0xCF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0xFF, 0xCF, 0xFE, 0x07,
  0xE0, 0xFF, 0x9F, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3C, 0x0F, 0xF8,
  0x00, 0x40, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x20, 0x3F, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF,
  0x81, 0xFC, 0x03, 0xFF, 0x03, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x02, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x3C,
  0x0F, 0xFC, 0x00, 0x10, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFB, 0xFC, 0x07,
  0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFC, 0xFF, 0x03, 0xFF,
  0xF3, 0xFC, 0x0F, 0xFF, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0x80, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F,
  0xC7, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F,
  0xDF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7F, 0x01, 0xF9, 0xF0,
  0x1F, 0x9F, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x03, 0xF3,
  0xF8, 0x0F, 0xE7, 0xC0, 0xFC, 0xFE, 0x03, 0xF9, 0xF0, 0x7E, 0x3F, 0x80,
  0xFC, 0x7C, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x0F, 0xC7, 0xF0, 0x1F, 0xC7,
  0xE3, 0xF1, 0xFC, 0x07, 0xF1, 0xF9, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0xBF, 0x07, 0xE0, 0x3F, 0x87, 0xEF, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0xF8, 0x3F, 0x80, 0xFC,
  0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xFF,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x01,
  0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFE,
  0x00, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0x7F, 0x7F, 0x01, 0xFC, 0x07,
  0xE7, 0xF0, 0x1F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x07, 0xE3, 0xF8, 0x1F,
  0x80, 0xFE, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0x80, 0xFE, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x3F, 0x01, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F,
  0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0, 0x7E, 0x7F,
  0x01, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0x7F, 0x7E, 0x03, 0xF8, 0x07,
  0xF7, 0xE0, 0x3F, 0x80, 0x3F, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x87, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0x60, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x0F, 0xE0, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0xC7, 0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xFF, 0xC0, 0x7F, 0x87, 0xE0, 0x1F, 0xFC, 0x07, 0xF0, 0x7E, 0x03,
  0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xEF,
  0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xEF, 0xC1,
  0xFC, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF8,
  0x07, 0xE1, 0xF8, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x8F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF8, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0x07, 0xE7,
  0xF0, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x00, 0x7E, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x04, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x3F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x00, 0x7F, 0x0F, 0xC0, 0x7F,
  0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x07, 0xFC, 0x1F, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFD, 0xF8, 0x07, 0xFE, 0x7E, 0x00, 0xFF, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xF8, 0x07, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x1F, 0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xCF, 0xFF, 0x03, 0xF3, 0xFF, 0x80, 0xFC, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x01, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xC1, 0xFF, 0xBF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xF9, 0xFC, 0x03, 0xFF, 0xDF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFD, 0xF8, 0x01, 0xFF, 0x9F, 0x80, 0x0F, 0xF1, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x10, 0x7F, 0xC0, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x10, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x23, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFC, 0x03, 0xFF, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x04, 0x00, 0x3F, 0x80, 0xF0, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xCF, 0xFC, 0x07,
  0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xC3, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x08, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFD,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xDF, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x01, 0xFC, 0x03, 0xF1, 0xFF, 0x83, 0xFF, 0x01, 0xF9, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0xFF,
  0xC0, 0x7E, 0x7F, 0xF8, 0x1F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC3, 0xFC, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3,
  0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F,
  0xC7, 0xF0, 0x3F, 0xC3, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xFE, 0x00, 0x3F, 0x7F, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC,
  0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x83, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xDF, 0xFE, 0x00, 0xFE, 0x7F, 0xE0, 0x07, 0xF1, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07,
  0xC0, 0x7F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F,
  0x81, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF0, 0x78, 0xFF,
  0x00, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC8,
  0x01, 0xFE, 0x78, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x30, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x1F, 0xF0, 0xFE, 0x0F, 0xF8, 0x3F, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xF7, 0xE0, 0x7F, 0xF9, 0xF8, 0x1F, 0xFC, 0x7C, 0x01, 0xFC,
  0x1F, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xBF, 0x81, 0xFF, 0x81,
  0xFE, 0xFE, 0x07, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xF8, 0x3F, 0xCF, 0xE0,
  0xFB, 0xE0, 0xFE, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0xFE, 0x1F, 0xBE, 0x1F,
  0xC3, 0xF8, 0x7D, 0xF8, 0x7F, 0x0F, 0xE3, 0xF7, 0xE3, 0xF8, 0x1F, 0x8F,
  0xDF, 0x8F, 0xE0, 0x7E, 0x3E, 0x7E, 0x7F, 0x01, 0xF9, 0xF9, 0xF9, 0xFC,
  0x07, 0xE7, 0xC7, 0xE7, 0xE0, 0x1F, 0xBF, 0x1F, 0xBF, 0x80, 0x7E, 0xFC,
  0x7E, 0xFC, 0x01, 0xFB, 0xE1, 0xFB, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x07,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF2, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x40, 0x00, 0xF8,
};

const GFXglyph NotoSans_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 36, 14, 1, -35 },
  { 69, 18, 13, 22, 5, -35 },
  { 99, 31, 35, 32, 1, -35 },
  { 235, 26, 40, 27, 1, -37 },
  { 365, 37, 35, 42, 3, -35 },
  { 527, 32, 36, 35, 2, -36 },
  { 671, 8, 13, 13, 5, -35 },
  { 684, 18, 43, 17, 2, -35 },
  { 781, 18, 44, 17, -3, -36 },
  { 880, 24, 23, 27, 4, -37 },
  { 949, 23, 24, 28, 3, -29 },
  { 1018, 11, 12, 14, -2, -6 },
  { 1035, 14, 6, 16, 1, -16 },
  { 1046, 9, 9, 14, 0, -8 },
  { 1057, 26, 35, 21, -2, -35 },
  { 1171, 25, 36, 27, 2, -36 },
  { 1284, 20, 35, 27, 4, -35 },
  { 1372, 27, 35, 27, -1, -35 },
  { 1491, 26, 35, 27, 0, -35 },
  { 1605, 27, 35, 27, -1, -35 },
  { 1724, 26, 35, 27, 1, -35 },
  { 1838, 26, 36, 27, 2, -36 },
  { 1955, 27, 35, 27, 2, -35 },
  { 2074, 26, 36, 27, 1, -36 },
  { 2191, 24, 36, 27, 2, -36 },
  { 2299, 13, 28, 14, 0, -27 },
  { 2345, 16, 33, 14, -3, -27 },
  { 2411, 23, 26, 28, 3, -31 },
  { 2486, 23, 15, 28, 3, -25 },
  { 2530, 23, 26, 28, 3, -31 },
  { 2605, 20, 36, 22, 4, -35 },
  { 2695, 39, 39, 42, 2, -35 },
  { 2886, 31, 35, 31, -3, -35 },
  { 3022, 29, 35, 30, 1, -35 },
  { 3149, 29, 36, 30, 3, -36 },
  { 3280, 31, 35, 33, 1, -35 },
  { 3416, 27, 35, 27, 1, -35 },
  { 3535, 27, 35, 26, 1, -35 },
  { 3654, 30, 36, 34, 3, -36 },
  { 3789, 34, 35, 34, 1, -35 },
  { 3938, 22, 35, 19, -1, -35 },
  { 4035, 25, 45, 16, -8, -35 },
  { 4176, 34, 35, 30, 1, -35 },
  { 4325, 21, 35, 25, 1, -35 },
  { 4417, 42, 35, 43, 1, -35 },
  { 4601, 36, 35, 37, 1, -35 },
  { 4759, 31, 36, 36, 3, -36 },
  { 4899, 29, 35, 30, 1, -35 },
  { 5026, 31, 44, 36, 3, -36 },
  { 5197, 28, 35, 30, 1, -35 },
  { 5320, 26, 35, 26, 1, -35 },
  { 5434, 26, 35, 26, 4, -35 },
  { 5548, 31, 35, 34, 3, -35 },
  { 5684, 29, 35, 29, 4, -35 },
  { 5811, 44, 35, 44, 4, -35 },
  { 6004, 37, 35, 30, -3, -35 },
  { 6166, 28, 35, 28, 4, -35 },
  { 6289, 30, 35, 26, -1, -35 },
  { 6421, 21, 43, 16, -1, -35 },
  { 6534, 12, 35, 21, 5, -35 },
  { 6587, 20, 43, 16, -3, -35 },
  { 6695, 25, 23, 27, 1, -35 },
  { 6767, 20, 4, 20, -4, 4 },
  { 6777, 10, 8, 16, 7, -38 },
  { 6787, 26, 27, 29, 2, -27 },
  { 6875, 26, 37, 29, 1, -37 },
  { 6996, 22, 27, 24, 2, -27 },
  { 7071, 28, 37, 29, 2, -37 },
  { 7201, 24, 27, 27, 2, -27 },
  { 7282, 29, 49, 18, -5, -37 },
  { 7460, 27, 39, 29, 1, -27 },
  { 7592, 26, 37, 30, 1, -37 },
  { 7713, 15, 37, 15, 1, -37 },
  { 7783, 22, 49, 15, -6, -37 },
  { 7918, 29, 37, 28, 1, -37 },
  { 8053, 15, 37, 15, 1, -37 },
  { 8123, 41, 27, 44, 1, -27 },
  { 8262, 26, 27, 30, 1, -27 },
  { 8350, 25, 27, 29, 2, -27 },
  { 8435, 29, 39, 29, -2, -27 },
  { 8577, 26, 39, 29, 2, -27 },
  { 8704, 22, 27, 21, 1, -27 },
  { 8779, 21, 27, 23, 1, -27 },
  { 8850, 19, 32, 20, 2, -32 },
  { 8926, 26, 27, 30, 3, -27 },
  { 9014, 26, 27, 25, 2, -27 },
  { 9102, 38, 27, 39, 3, -27 },
  { 9231, 31, 27, 26, -2, -27 },
  { 9336, 31, 39, 25, -3, -27 },
  { 9488, 24, 27, 23, -1, -27 },
  { 9569, 21, 43, 17, 0, -35 },
  { 9682, 5, 48, 27, 11, -37 },
  { 9712, 21, 43, 17, -3, -35 },
  { 9825, 23, 8, 28, 3, -21 },
};

const GFXfont NotoSans_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_BoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_BOLDITALIC49PT7B_H_
