#ifndef _ROBOTOMONO_MEDIUM18PT7B_H_
#define _ROBOTOMONO_MEDIUM18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xC0, 0x7C, 0x9C, 0xE7, 0x39, 0x80, 0x0C, 0x82,
  0x60, 0x98, 0x24, 0x7F, 0xC6, 0x41, 0x30, 0x4C, 0xFF, 0xCC, 0x83, 0x20,
  0xC8, 0x26, 0x00, 0x0C, 0x06, 0x07, 0x8F, 0xE6, 0x3B, 0x0D, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x1B, 0xF8, 0xF8, 0x10, 0x08, 0x00, 0x70,
  0x16, 0x0C, 0x9B, 0x2C, 0x7A, 0x0D, 0x80, 0x40, 0x30, 0x0B, 0xC6, 0x93,
  0x24, 0x09, 0x03, 0xC0, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x6E, 0x0F, 0x03,
  0x81, 0xE2, 0xCD, 0xB1, 0xEC, 0x73, 0xFE, 0x7D, 0xC0, 0xFF, 0xC0, 0x19,
  0x88, 0xC6, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x31, 0x86, 0x10, 0x40, 0x86,
  0x18, 0x63, 0x18, 0xC3, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0xC4, 0x00, 0x0C,
  0x06, 0x02, 0x0D, 0x3F, 0xF0, 0xE0, 0x58, 0xE6, 0x22, 0x00, 0x18, 0x0C,
  0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x6D, 0xBC,
  0xFE, 0x5F, 0x80, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x18, 0x30, 0x61,
  0x83, 0x06, 0x18, 0x00, 0x3C, 0x3F, 0x98, 0xD8, 0x6C, 0x3E, 0x3F, 0x3F,
  0xE7, 0xE3, 0xE1, 0x98, 0xCF, 0xE3, 0xE0, 0x0B, 0xFF, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x80, 0x3C, 0x3F, 0x30, 0xD8, 0x60, 0x30, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x1F, 0xFF, 0xF8, 0x3C, 0x7F, 0xC3, 0xC3, 0x03,
  0x06, 0x1C, 0x07, 0x03, 0x03, 0xC3, 0xFF, 0x7E, 0x06, 0x07, 0x03, 0x83,
  0xC3, 0x61, 0xB1, 0x99, 0x8C, 0xFF, 0xFF, 0xC1, 0x80, 0xC0, 0x60, 0x7F,
  0x3F, 0x98, 0x0C, 0x06, 0x03, 0xF1, 0x9C, 0x06, 0x01, 0x80, 0xF8, 0xCF,
  0xE3, 0xE0, 0x0E, 0x1F, 0x1C, 0x0C, 0x0C, 0x07, 0xF3, 0x9D, 0x86, 0xC3,
  0xE1, 0xB8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x00, 0x3E, 0x3F, 0x98, 0xDC,
  0x66, 0x33, 0xB8, 0xF8, 0xCE, 0xC3, 0x61, 0xF8, 0xCF, 0xE3, 0xE0, 0x3C,
  0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03, 0x06, 0x3E, 0x38,
  0x7F, 0x80, 0x03, 0xFC, 0x7D, 0x80, 0x00, 0x6D, 0xAC, 0x01, 0x07, 0x1F,
  0x78, 0xE0, 0x78, 0x1F, 0x03, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x80, 0xE0, 0x7C, 0x0F, 0x03, 0x1F, 0xF8, 0xE0, 0x80, 0x7C, 0xFE, 0xC6,
  0x07, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x00, 0x00, 0x38, 0x38, 0x0E, 0x07,
  0xE2, 0x0D, 0xBD, 0x4B, 0x56, 0xDD, 0x37, 0x49, 0x52, 0x57, 0xE6, 0x00,
  0xC4, 0x1F, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x05, 0x81, 0xB0, 0x36, 0x06,
  0xC1, 0x8C, 0x3F, 0x87, 0xF1, 0x83, 0x30, 0x6E, 0x0E, 0xFC, 0x7F, 0xB0,
  0xF8, 0x3C, 0x1E, 0x3B, 0xF9, 0x87, 0xC1, 0xE0, 0xF0, 0x7F, 0xEF, 0xE0,
  0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xF8,
  0xEF, 0xE3, 0xE0, 0xF8, 0x7F, 0x31, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0xDF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00,
  0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x06, 0x03, 0x01, 0x9F, 0xC1, 0xE0, 0xF8,
  0x6F, 0xF3, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC7, 0xFF, 0xE0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xC3, 0xC3, 0x7F, 0x3E, 0xC1, 0xF0, 0xEC, 0x73, 0x18,
  0xCC, 0x36, 0x0F, 0xC3, 0xF0, 0xEE, 0x31, 0xCC, 0x33, 0x0E, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1F, 0xFF, 0xF8, 0xE3, 0xF1, 0xF9, 0xFE, 0xFF, 0x5E, 0xEF, 0x77, 0xB3,
  0xC9, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xC3, 0xF1, 0xF8, 0xFE, 0x7F, 0x3E,
  0xDF, 0x6F, 0x9F, 0xCF, 0xE3, 0xF1, 0xF8, 0x7C, 0x38, 0x3C, 0x3F, 0xB8,
  0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xCF, 0xE3, 0xE0,
  0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0xFD, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x00, 0x3C, 0x1F, 0xCE, 0x33, 0x06, 0xC1, 0xB0, 0x6C, 0x1B,
  0x06, 0xC1, 0xB0, 0x6E, 0x31, 0xFC, 0x3F, 0x00, 0xF0, 0x18, 0xFC, 0x7F,
  0xB0, 0xF8, 0x3C, 0x1E, 0x1F, 0xFD, 0xFC, 0xC6, 0x63, 0xB0, 0xD8, 0x7C,
  0x18, 0x3E, 0x3F, 0xB8, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x1E, 0x01, 0xE0,
  0xF0, 0x6F, 0xF3, 0xE0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0,
  0xE0, 0xD8, 0x36, 0x1D, 0xC6, 0x31, 0x8C, 0x63, 0x30, 0x6C, 0x1B, 0x07,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0xC4, 0x6D, 0x99, 0xBB, 0x37, 0x66, 0xEC,
  0xD5, 0x9A, 0xB3, 0xD6, 0x7B, 0x87, 0x70, 0xCE, 0x18, 0xC3, 0x18, 0x60,
  0xCE, 0x38, 0xC6, 0x1D, 0xC1, 0xB0, 0x1C, 0x03, 0x80, 0x70, 0x1B, 0x03,
  0x70, 0xC6, 0x38, 0xEE, 0x0E, 0xE0, 0xD8, 0x33, 0x18, 0xC6, 0x3B, 0x06,
  0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x1F, 0xFF,
  0xF8, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xFC, 0xC0, 0x81, 0x83, 0x03,
  0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x40, 0xC0, 0xFD, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0xFC, 0x10, 0x70, 0xA3, 0x66, 0xC8, 0xB1, 0x80, 0xFF,
  0xFF, 0xC7, 0x1C, 0x3F, 0x38, 0xC0, 0x63, 0xF3, 0xFB, 0x0D, 0x86, 0xFF,
  0x3F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xC7, 0xFB, 0x8D, 0xC7, 0xE1,
  0xF0, 0xF8, 0x7C, 0x6F, 0xF6, 0xF0, 0x1C, 0x3F, 0x98, 0xD8, 0x6C, 0x06,
  0x03, 0x01, 0xC6, 0x7F, 0x1F, 0x00, 0x03, 0x03, 0x03, 0x03, 0x1B, 0x7F,
  0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x1C, 0x1F, 0x98, 0xD8,
  0x3F, 0xFF, 0xFF, 0x01, 0xC2, 0x7F, 0x9F, 0x00, 0x07, 0x8F, 0xC6, 0x03,
  0x0F, 0xF7, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x19, 0x7F, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x03, 0x43,
  0x7E, 0x1C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xE6, 0xFB, 0x8D, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1C, 0x18, 0x18, 0x00, 0xF8, 0xF8, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1C, 0x70, 0x1F, 0x7C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0xBE, 0xF0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x3E, 0x3B, 0x39, 0xB8, 0xF8, 0x7E, 0x3B, 0x98, 0xCC, 0x36, 0x1C,
  0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0xD3, 0x7F, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9,
  0xEC, 0xC0, 0xCE, 0x6F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xC0, 0x1C, 0x3F, 0x18, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0xC6, 0x7F,
  0x1F, 0x00, 0xCC, 0x7F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x0F, 0xC6, 0xFF,
  0x6F, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x19, 0x7F, 0x63, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0xCF, 0xFF, 0xCE, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x1C, 0x3F, 0x98, 0xCC, 0x17, 0x81, 0xF8,
  0x0F, 0x83, 0x77, 0x1F, 0x00, 0x38, 0x1C, 0x3F, 0xDF, 0xE3, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0C, 0x07, 0xC1, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8E, 0xC7, 0x7F, 0x9E, 0xC0, 0xC1, 0xE0, 0xD8, 0xCC, 0x66,
  0x21, 0xB0, 0xD8, 0x68, 0x1C, 0x0E, 0x00, 0xC4, 0x53, 0x36, 0xCD, 0xBB,
  0x6A, 0xDA, 0xA7, 0xA8, 0xCE, 0x33, 0x8C, 0x60, 0xC1, 0xB1, 0x9D, 0xC6,
  0xC1, 0xC0, 0xE0, 0xF8, 0x6C, 0x63, 0x70, 0xC0, 0xC1, 0xF0, 0x6E, 0x39,
  0x8C, 0x63, 0x0D, 0x83, 0x60, 0x70, 0x1C, 0x03, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xC0, 0x0C, 0x63, 0x0C, 0x30, 0xC3, 0x18, 0xC1, 0x83, 0x0C, 0x30,
  0xC3, 0x06, 0x1C, 0xFF, 0xFF, 0x80, 0xC1, 0x86, 0x18, 0x61, 0x83, 0x0C,
  0x1C, 0xE3, 0x08, 0x61, 0x86, 0x18, 0xC0, 0x78, 0x5F, 0x3C, 0x7C, 0x04,
};

const GFXglyph RobotoMono_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -14 },
  { 10, 10, 13, 11, 0, -13 },
  { 27, 9, 17, 11, 1, -15 },
  { 47, 10, 13, 11, 0, -13 },
  { 64, 10, 13, 11, 1, -13 },
  { 81, 2, 5, 11, 4, -14 },
  { 83, 5, 18, 11, 3, -14 },
  { 95, 5, 18, 11, 3, -14 },
  { 107, 9, 9, 11, 1, -13 },
  { 118, 9, 10, 11, 1, -11 },
  { 130, 3, 5, 11, 3, -2 },
  { 132, 7, 1, 11, 2, -6 },
  { 133, 3, 3, 11, 4, -3 },
  { 135, 7, 14, 11, 2, -13 },
  { 148, 9, 13, 11, 1, -13 },
  { 163, 5, 13, 11, 2, -13 },
  { 172, 9, 13, 11, 1, -13 },
  { 187, 8, 13, 11, 1, -13 },
  { 200, 9, 13, 11, 1, -13 },
  { 215, 9, 13, 11, 1, -13 },
  { 230, 9, 13, 11, 1, -13 },
  { 245, 9, 13, 11, 1, -13 },
  { 260, 9, 13, 11, 1, -13 },
  { 275, 8, 13, 11, 1, -13 },
  { 288, 3, 10, 11, 4, -10 },
  { 292, 3, 13, 11, 4, -10 },
  { 297, 8, 9, 11, 1, -10 },
  { 306, 9, 5, 11, 1, -8 },
  { 312, 8, 9, 11, 1, -10 },
  { 321, 8, 13, 11, 2, -13 },
  { 334, 10, 13, 11, 0, -13 },
  { 351, 11, 13, 11, 0, -13 },
  { 369, 9, 13, 11, 1, -13 },
  { 384, 9, 13, 11, 1, -13 },
  { 399, 9, 13, 11, 1, -13 },
  { 414, 9, 13, 11, 1, -13 },
  { 429, 9, 13, 11, 1, -13 },
  { 444, 9, 13, 11, 1, -13 },
  { 459, 9, 13, 11, 1, -13 },
  { 474, 7, 13, 11, 2, -13 },
  { 486, 8, 13, 11, 1, -13 },
  { 499, 10, 13, 11, 1, -13 },
  { 516, 9, 13, 11, 1, -13 },
  { 531, 9, 13, 11, 1, -13 },
  { 546, 9, 13, 11, 1, -13 },
  { 561, 9, 13, 11, 1, -13 },
  { 576, 9, 13, 11, 1, -13 },
  { 591, 10, 15, 11, 1, -13 },
  { 610, 9, 13, 11, 1, -13 },
  { 625, 9, 13, 11, 1, -13 },
  { 640, 10, 13, 11, 0, -13 },
  { 657, 9, 13, 11, 1, -13 },
  { 672, 10, 13, 11, 0, -13 },
  { 689, 11, 13, 11, 0, -13 },
  { 707, 11, 13, 11, 0, -13 },
  { 725, 10, 13, 11, 0, -13 },
  { 742, 9, 13, 11, 1, -13 },
  { 757, 3, 18, 11, 4, -15 },
  { 764, 7, 14, 11, 2, -13 },
  { 777, 3, 18, 11, 4, -15 },
  { 784, 7, 7, 11, 2, -13 },
  { 791, 8, 2, 11, 1, 0 },
  { 793, 4, 2, 11, 4, -13 },
  { 794, 9, 10, 11, 1, -10 },
  { 806, 9, 14, 11, 1, -14 },
  { 822, 9, 10, 11, 1, -10 },
  { 834, 8, 14, 11, 1, -14 },
  { 848, 9, 10, 11, 1, -10 },
  { 860, 9, 14, 11, 1, -14 },
  { 876, 8, 14, 11, 1, -10 },
  { 890, 9, 14, 11, 1, -14 },
  { 906, 8, 13, 11, 2, -13 },
  { 919, 6, 17, 11, 2, -13 },
  { 932, 9, 14, 11, 1, -14 },
  { 948, 8, 14, 11, 2, -14 },
  { 962, 9, 10, 11, 1, -10 },
  { 974, 9, 10, 11, 1, -10 },
  { 986, 9, 10, 11, 1, -10 },
  { 998, 9, 14, 11, 1, -10 },
  { 1014, 8, 14, 11, 1, -10 },
  { 1028, 7, 10, 11, 3, -10 },
  { 1037, 9, 10, 11, 1, -10 },
  { 1049, 9, 12, 11, 1, -12 },
  { 1063, 9, 10, 11, 1, -10 },
  { 1075, 9, 10, 11, 1, -10 },
  { 1087, 10, 10, 11, 0, -10 },
  { 1100, 9, 10, 11, 1, -10 },
  { 1112, 10, 14, 11, 1, -10 },
  { 1130, 9, 10, 11, 1, -10 },
  { 1142, 6, 17, 11, 3, -14 },
  { 1155, 1, 17, 11, 5, -13 },
  { 1158, 6, 17, 11, 3, -14 },
  { 1171, 10, 4, 11, 0, -7 },
};

const GFXfont RobotoMono_Medium18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium18pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_MEDIUM18PT7B_H_
