#ifndef _ROBOTOMONO_MEDIUM46PT7B_H_
#define _ROBOTOMONO_MEDIUM46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xCF, 0xFF, 0xBF, 0x7C, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x77, 0x83, 0xBC, 0x1D,
  0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x0F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0x1F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF,
  0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0,
  0x20, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC1, 0xC3, 0xC0, 0xF0,
  0x70, 0xE0, 0x3C, 0x3C, 0x78, 0x0F, 0x8F, 0x3C, 0x01, 0xFF, 0x8F, 0x00,
  0x3F, 0xE7, 0x80, 0x07, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE1, 0xF0, 0x00, 0x79, 0xFF, 0x00, 0x3C, 0xFF, 0xE0, 0x0F, 0x3E, 0xF8,
  0x07, 0x9E, 0x1E, 0x01, 0xC7, 0x83, 0xC0, 0xF1, 0xE0, 0xF0, 0x38, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x87, 0x83, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x07, 0xCF, 0xFF, 0x03, 0xC7, 0xEF, 0xC1, 0xE7,
  0xE3, 0xF1, 0xF3, 0xE1, 0xF8, 0xFB, 0xF0, 0x7E, 0x7D, 0xF0, 0x1F, 0xFE,
  0xF8, 0x07, 0xFE, 0x7C, 0x03, 0xFF, 0x3F, 0x00, 0xFF, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0x7E, 0x07, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x00,
  0x20, 0x06, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x60, 0x40, 0x03,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x38,
  0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x80, 0xBC, 0x1C,
  0x0E, 0xFC, 0x70, 0xFB, 0xFD, 0xDF, 0xEF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x80, 0x07,
  0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03,
  0xE0, 0x38, 0x0E, 0x00, 0x40, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C,
  0xF9, 0xE7, 0xC7, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0x01, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xDF, 0xFC, 0xFC, 0xFF, 0xEF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE3, 0xF0, 0x7F,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF0, 0x7F, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xCF, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x9F,
  0x00, 0x3E, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7F, 0x03, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7E, 0x07,
  0xF0, 0x30, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x30, 0x0F, 0x8F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x07, 0xE3, 0xF0,
  0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF9,
  0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFE,
  0x1F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFD, 0xFE, 0x1F, 0x80, 0xFC, 0x7C, 0x01, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF8, 0xFE, 0x3F, 0x03, 0xF1, 0xF0, 0x0F,
  0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x7E, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x1E,
  0x1F, 0x9F, 0xEF, 0xF7, 0xF9, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x9F, 0xEF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x0E, 0x0E, 0x3C, 0x1F, 0xC7, 0x1C,
  0x1F, 0xF1, 0xCE, 0x1F, 0x78, 0xEF, 0x1E, 0x1C, 0x77, 0x0E, 0x1E, 0x3B,
  0x8F, 0x0E, 0x1F, 0xC7, 0x87, 0x0F, 0xE3, 0x83, 0x87, 0xF1, 0xC1, 0xC3,
  0xF8, 0xE0, 0xE1, 0xF8, 0xF0, 0x70, 0xFE, 0x78, 0x38, 0x7F, 0x1C, 0x1C,
  0x77, 0x8E, 0x1E, 0x3B, 0xC7, 0x9F, 0x3C, 0xE3, 0xFF, 0xFC, 0x70, 0xFC,
  0xFC, 0x3C, 0x3C, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x06, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x07,
  0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x7F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xE1, 0xF8,
  0x1F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0x81, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC7, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xC0, 0x1F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF8, 0x01, 0xF1, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x3F, 0x83, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0,
  0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF7, 0xE0,
  0x0F, 0xF3, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xBC, 0xF7, 0xFE, 0xF3, 0xDF, 0xFB, 0xDF, 0x7F, 0xE7, 0xF9, 0xFF,
  0x9F, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F,
  0xC7, 0xFE, 0x3E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF,
  0xBE, 0x0F, 0xFC, 0xF8, 0x7F, 0xE7, 0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC3, 0xE7, 0xFE, 0x1F, 0x3F, 0xF0, 0x79, 0xFF, 0x83, 0xEF, 0xFC,
  0x0F, 0x7F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8, 0x3F, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xBE, 0x00, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xF8, 0x0F, 0xE0,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x01,
  0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x3F, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x7E, 0x7E, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0x00, 0xFE,
  0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F,
  0x80, 0xFE, 0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xF8,
  0x1E, 0x7C, 0x3F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF9, 0xF0,
  0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x9F, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0xF9,
  0xF1, 0xFE, 0x3C, 0x3C, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7, 0xC3, 0xE7, 0x79,
  0xF0, 0xFB, 0xCE, 0x7C, 0x3E, 0xF3, 0xDF, 0x0F, 0xBC, 0xF7, 0xC3, 0xEF,
  0x3D, 0xE0, 0x7B, 0xCF, 0x78, 0x1E, 0xE3, 0xDE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF,
  0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF9,
  0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xF9, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0x9F, 0x0F, 0xF8, 0xF8, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1E,
  0x01, 0xF3, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F,
  0xC0, 0xFC, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x3F,
  0x7E, 0x01, 0xFB, 0xF8, 0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xDF,
  0xFC, 0x3C, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x3E, 0x0F, 0xF9, 0xF1, 0xFF, 0xEF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xF7, 0xC1, 0xFE, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0,
  0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x02, 0x1F, 0xC0,
  0x1C, 0x3F, 0x81, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x20, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xE7, 0xC7, 0xFF, 0xBE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x81, 0xFD,
  0xF8, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x03,
  0xF7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xDF, 0x07,
  0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x20, 0x03, 0xF1, 0x80, 0x1F,
  0x1E, 0x03, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x3F, 0x1F,
  0xF0, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xC0, 0xFE,
  0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xBE,
  0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F,
  0xC0, 0xF8, 0x7E, 0x03, 0xE3, 0xF8, 0x0F, 0x9F, 0xC0, 0x3E, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x3E, 0x0F, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFE, 0x3E, 0x01, 0xFC, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x70, 0xFB, 0xF9, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xF8, 0x7E, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0x00, 0x1E, 0x07, 0xC7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x07, 0xCF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xEF,
  0xE0, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0x7F, 0xF0, 0xF9, 0xFE,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0x81, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0xFF, 0xDF, 0x07, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x3E, 0x1F, 0xFF,
  0x9F, 0xFB, 0xEF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0x8F, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7E,
  0x01, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x40, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xDF, 0x3F, 0xF9, 0xF0, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x1E, 0x07, 0xFE,
  0x07, 0x81, 0xEF, 0x83, 0xE0, 0xF9, 0xE0, 0xF8, 0x3E, 0x78, 0x3F, 0x0F,
  0x9F, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF1, 0xF1, 0xFC, 0x3C, 0x7C, 0x77,
  0x1F, 0x0F, 0x1D, 0xE7, 0xC3, 0xC7, 0x79, 0xF0, 0xF3, 0xCE, 0x78, 0x3E,
  0xF3, 0x9E, 0x0F, 0xB8, 0xE7, 0x81, 0xEE, 0x3D, 0xE0, 0x7B, 0x8F, 0xF8,
  0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x07,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x03,
  0xDF, 0xFE, 0x01, 0xEF, 0xFF, 0xC1, 0xFF, 0xCF, 0xF9, 0xF7, 0x81, 0xFF,
  0xFB, 0xC0, 0x3F, 0xF9, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 33, 28, 10, -33 },
  { 30, 13, 12, 28, 7, -35 },
  { 50, 25, 33, 28, 1, -33 },
  { 154, 22, 43, 28, 3, -38 },
  { 273, 26, 33, 28, 1, -33 },
  { 381, 25, 33, 28, 2, -33 },
  { 485, 4, 12, 28, 11, -35 },
  { 491, 12, 47, 28, 8, -37 },
  { 562, 13, 47, 28, 7, -37 },
  { 639, 22, 23, 28, 4, -33 },
  { 703, 23, 24, 28, 2, -27 },
  { 772, 7, 13, 28, 8, -5 },
  { 784, 18, 5, 28, 6, -17 },
  { 796, 8, 7, 28, 10, -7 },
  { 803, 18, 36, 28, 5, -33 },
  { 884, 21, 33, 28, 3, -33 },
  { 971, 14, 33, 28, 4, -33 },
  { 1029, 22, 33, 28, 2, -33 },
  { 1120, 22, 33, 28, 2, -33 },
  { 1211, 24, 33, 28, 1, -33 },
  { 1310, 22, 33, 28, 3, -33 },
  { 1401, 21, 33, 28, 3, -33 },
  { 1488, 23, 33, 28, 2, -33 },
  { 1583, 22, 33, 28, 3, -33 },
  { 1674, 21, 33, 28, 3, -33 },
  { 1761, 8, 26, 28, 11, -26 },
  { 1787, 9, 34, 28, 10, -26 },
  { 1826, 19, 21, 28, 4, -25 },
  { 1876, 20, 14, 28, 4, -21 },
  { 1911, 20, 21, 28, 4, -25 },
  { 1964, 20, 33, 28, 4, -33 },
  { 2047, 25, 33, 28, 1, -33 },
  { 2151, 26, 33, 28, 1, -33 },
  { 2259, 23, 33, 28, 3, -33 },
  { 2354, 23, 33, 28, 2, -33 },
  { 2449, 23, 33, 28, 3, -33 },
  { 2544, 21, 33, 28, 4, -33 },
  { 2631, 21, 33, 28, 4, -33 },
  { 2718, 23, 33, 28, 2, -33 },
  { 2813, 21, 33, 28, 3, -33 },
  { 2900, 19, 33, 28, 4, -33 },
  { 2979, 22, 33, 28, 2, -33 },
  { 3070, 25, 33, 28, 3, -33 },
  { 3174, 21, 33, 28, 4, -33 },
  { 3261, 22, 33, 28, 3, -33 },
  { 3352, 21, 33, 28, 3, -33 },
  { 3439, 24, 33, 28, 2, -33 },
  { 3538, 22, 33, 28, 4, -33 },
  { 3629, 25, 39, 28, 2, -33 },
  { 3751, 23, 33, 28, 3, -33 },
  { 3846, 24, 33, 28, 2, -33 },
  { 3945, 26, 33, 28, 1, -33 },
  { 4053, 22, 33, 28, 3, -33 },
  { 4144, 25, 33, 28, 1, -33 },
  { 4248, 26, 33, 28, 1, -33 },
  { 4356, 26, 33, 28, 1, -33 },
  { 4464, 26, 33, 28, 1, -33 },
  { 4572, 23, 33, 28, 2, -33 },
  { 4667, 10, 45, 28, 9, -38 },
  { 4724, 18, 36, 28, 5, -33 },
  { 4805, 10, 45, 28, 9, -38 },
  { 4862, 18, 18, 28, 5, -33 },
  { 4903, 21, 4, 28, 3, 0 },
  { 4914, 10, 6, 28, 9, -33 },
  { 4922, 21, 25, 28, 3, -25 },
  { 4988, 21, 35, 28, 4, -35 },
  { 5080, 21, 25, 28, 3, -25 },
  { 5146, 21, 35, 28, 3, -35 },
  { 5238, 22, 25, 28, 3, -25 },
  { 5307, 23, 35, 28, 3, -35 },
  { 5408, 21, 35, 28, 3, -25 },
  { 5500, 22, 35, 28, 3, -35 },
  { 5597, 20, 34, 28, 5, -34 },
  { 5682, 15, 44, 28, 5, -34 },
  { 5765, 22, 35, 28, 4, -35 },
  { 5862, 20, 35, 28, 5, -35 },
  { 5950, 24, 25, 28, 2, -25 },
  { 6025, 21, 25, 28, 3, -25 },
  { 6091, 23, 25, 28, 2, -25 },
  { 6163, 21, 34, 28, 4, -25 },
  { 6253, 21, 34, 28, 3, -25 },
  { 6343, 18, 25, 28, 7, -25 },
  { 6400, 22, 25, 28, 3, -25 },
  { 6469, 21, 30, 28, 3, -30 },
  { 6548, 20, 24, 28, 4, -24 },
  { 6608, 24, 24, 28, 2, -24 },
  { 6680, 26, 24, 28, 1, -24 },
  { 6758, 24, 24, 28, 2, -24 },
  { 6830, 26, 34, 28, 1, -24 },
  { 6941, 22, 24, 28, 3, -24 },
  { 7007, 15, 44, 28, 7, -36 },
  { 7090, 4, 42, 28, 12, -33 },
  { 7111, 15, 44, 28, 7, -36 },
  { 7194, 25, 9, 28, 1, -18 },
};

const GFXfont RobotoMono_Medium46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium46pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_MEDIUM46PT7B_H_
