#ifndef _ROBOTOMONO_MEDIUM45PT7B_H_
#define _ROBOTOMONO_MEDIUM45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x43, 0xEF, 0xDF, 0xFF, 0x3E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x78,
  0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x07,
  0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0x80, 0x3E, 0x7E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x06, 0x07, 0x87, 0x83, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE3, 0xC0, 0xF0,
  0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x1F, 0xF8, 0xE0, 0x0F, 0xFC, 0xF0, 0x03,
  0xFC, 0x70, 0x00, 0x30, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x0E, 0x3F,
  0xC0, 0x0F, 0x3F, 0xF0, 0x07, 0x1F, 0xF8, 0x07, 0x9E, 0x1E, 0x03, 0x8F,
  0x0F, 0x03, 0xC7, 0x87, 0x81, 0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0x20,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00,
  0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE3, 0xE0,
  0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0x8F, 0xFF,
  0x07, 0xCF, 0xCF, 0xC3, 0xE7, 0xC3, 0xF1, 0xF7, 0xE0, 0xFC, 0xF3, 0xE0,
  0x7E, 0xF9, 0xF0, 0x1F, 0xFC, 0xF8, 0x07, 0xFC, 0x7E, 0x01, 0xFE, 0x3F,
  0x00, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFC, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE0, 0x00, 0x20, 0x06, 0x01, 0xE0, 0x3F, 0x03, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x06, 0x40,
  0x06, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x02, 0x03, 0x80, 0x9F, 0x0E, 0x0E, 0x7F, 0x39, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x3E,
  0x07, 0xC0, 0xFC, 0x06, 0x01, 0xC0, 0x08, 0x06, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xFB,
  0xE7, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFB, 0xFF, 0x0F, 0x9F, 0xF9, 0xF8, 0xFF, 0xDF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80,
  0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xF1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xF0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xFE, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xF3, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7D, 0xFC, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xE3, 0xFE, 0x1C, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80,
  0x7C, 0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF1, 0xFC, 0x0F, 0x9F, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xE1, 0xFC, 0xFE, 0x03, 0xF7, 0xE0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80,
  0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC,
  0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7E, 0x07,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xF9, 0xF0, 0x0C,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xF8, 0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7E, 0x0F, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x78, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x3F, 0x0E,
  0x38, 0x3F, 0xC7, 0x1C, 0x3F, 0xE3, 0x9E, 0x3C, 0x71, 0xCE, 0x1C, 0x38,
  0x77, 0x1E, 0x1C, 0x3B, 0x8E, 0x0E, 0x1F, 0xC7, 0x07, 0x0F, 0xC3, 0x83,
  0x87, 0xE3, 0xC1, 0xC3, 0x71, 0xE0, 0xE3, 0xB8, 0xF0, 0x71, 0xDC, 0x78,
  0x78, 0xEF, 0x3C, 0x38, 0x67, 0x8F, 0x3E, 0x71, 0xC7, 0xFF, 0xF8, 0xE1,
  0xFB, 0xF8, 0x78, 0x78, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x1F, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x7F, 0xCF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xC0, 0x1F, 0xBF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xF8, 0x7F, 0xE3, 0xE0, 0x3F, 0x8F,
  0x80, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x0F, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F,
  0x00, 0x3E, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xF9,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0x7F, 0xFC, 0x7B, 0xFE, 0xF3, 0xDF, 0xF7, 0xBC, 0xFF, 0xBD,
  0xE7, 0xFD, 0xEF, 0x3F, 0xE7, 0xF1, 0xFF, 0x3F, 0x8F, 0xF9, 0xFC, 0x7F,
  0xC7, 0xC3, 0xFE, 0x3E, 0x1F, 0xF1, 0xF0, 0xFF, 0x87, 0x0F, 0xFC, 0x38,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0xBE,
  0x0F, 0xFC, 0xF8, 0x7F, 0xE7, 0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF,
  0xC3, 0xC7, 0xFE, 0x1F, 0x3F, 0xF0, 0x79, 0xFF, 0x83, 0xEF, 0xFC, 0x0F,
  0x7F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x81, 0xFF,
  0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xF9, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0xFB, 0xE1, 0xF0, 0x7D,
  0xF0, 0xFC, 0x3C, 0xF8, 0xFE, 0x1E, 0x7C, 0x7F, 0x1F, 0x3E, 0x3F, 0x8F,
  0x9F, 0x1F, 0xC7, 0xCF, 0x8F, 0xE3, 0xE3, 0xC7, 0x79, 0xF1, 0xE7, 0xBC,
  0xF8, 0xFB, 0xDE, 0x78, 0x7D, 0xEF, 0x3C, 0x3E, 0xF3, 0x9E, 0x1F, 0x79,
  0xDF, 0x0F, 0xB8, 0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0,
  0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0,
  0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x81, 0xE1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x1E,
  0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x3E,
  0x01, 0xFB, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x00, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xFD,
  0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xF7, 0xE1, 0xFE,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x3F, 0xC1, 0xFB, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x83, 0xFB, 0xFF, 0xFF, 0x9F, 0x7F,
  0xFC, 0xF9, 0xFF, 0xC7, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xDF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0x7E, 0x07, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x03,
  0xF9, 0xF0, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x87, 0xF7,
  0xE0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xF0,
  0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0x7F, 0x8F, 0x01,
  0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F,
  0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0x1F, 0x80,
  0x1C, 0x7F, 0x03, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0xF8, 0x7F, 0xF7, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF7, 0xF8, 0x7F, 0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x84,
  0x00, 0x7C, 0x30, 0x07, 0xE3, 0xC0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0xC1, 0xF9,
  0xFF, 0x8F, 0xDF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x1F, 0xDF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x01,
  0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7E, 0x01, 0xFC,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01,
  0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF1, 0xF9, 0xEF, 0xF7, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E,
  0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1,
  0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F,
  0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF,
  0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8,
  0x7F, 0x87, 0xC7, 0xFE, 0x3E, 0xFF, 0xF9, 0xF7, 0xFF, 0xEF, 0xF8, 0x7F,
  0x7F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xF8,
  0xFF, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF,
  0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00,
  0xFD, 0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F,
  0x9F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFF, 0xFF,
  0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7E,
  0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE7, 0xF0, 0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x40, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF0,
  0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xC0,
  0x03, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x1C, 0x0F, 0xFC, 0x1E, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xE7,
  0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x79, 0xE1, 0xF8, 0x7C, 0xF8, 0xFE, 0x3E,
  0x7C, 0x77, 0x1E, 0x1E, 0x3B, 0x8F, 0x0F, 0x1D, 0xC7, 0x87, 0x9E, 0xF3,
  0xC3, 0xCE, 0x7B, 0xE1, 0xF7, 0x1D, 0xF0, 0x7B, 0x8E, 0xF0, 0x3F, 0xC7,
  0x78, 0x1F, 0xE3, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xC7,
  0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0x7F, 0xF8, 0x07, 0x7F,
  0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0xF8,
};

const GFXglyph RobotoMono_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 32, 27, 10, -32 },
  { 29, 12, 11, 27, 7, -34 },
  { 46, 25, 32, 27, 1, -32 },
  { 146, 22, 42, 27, 3, -37 },
  { 262, 25, 32, 27, 1, -32 },
  { 362, 25, 32, 27, 2, -32 },
  { 462, 5, 12, 27, 10, -34 },
  { 470, 12, 46, 27, 8, -36 },
  { 539, 12, 46, 27, 7, -36 },
  { 608, 22, 22, 27, 3, -32 },
  { 669, 22, 24, 27, 2, -27 },
  { 735, 7, 13, 27, 8, -5 },
  { 747, 17, 4, 27, 6, -16 },
  { 756, 8, 7, 27, 10, -7 },
  { 763, 18, 35, 27, 5, -32 },
  { 842, 21, 32, 27, 3, -32 },
  { 926, 14, 32, 27, 4, -32 },
  { 982, 22, 32, 27, 2, -32 },
  { 1070, 21, 32, 27, 2, -32 },
  { 1154, 24, 32, 27, 1, -32 },
  { 1250, 21, 32, 27, 3, -32 },
  { 1334, 21, 32, 27, 3, -32 },
  { 1418, 22, 32, 27, 2, -32 },
  { 1506, 21, 32, 27, 3, -32 },
  { 1590, 20, 32, 27, 3, -32 },
  { 1670, 7, 26, 27, 11, -26 },
  { 1693, 9, 34, 27, 10, -26 },
  { 1732, 19, 20, 27, 4, -24 },
  { 1780, 20, 14, 27, 4, -21 },
  { 1815, 19, 20, 27, 4, -24 },
  { 1863, 20, 32, 27, 4, -32 },
  { 1943, 25, 32, 27, 1, -32 },
  { 2043, 25, 32, 27, 1, -32 },
  { 2143, 22, 32, 27, 3, -32 },
  { 2231, 23, 32, 27, 2, -32 },
  { 2323, 22, 32, 27, 3, -32 },
  { 2411, 20, 32, 27, 4, -32 },
  { 2491, 20, 32, 27, 4, -32 },
  { 2571, 23, 32, 27, 2, -32 },
  { 2663, 21, 32, 27, 3, -32 },
  { 2747, 19, 32, 27, 4, -32 },
  { 2823, 22, 32, 27, 2, -32 },
  { 2911, 24, 32, 27, 3, -32 },
  { 3007, 20, 32, 27, 4, -32 },
  { 3087, 21, 32, 27, 3, -32 },
  { 3171, 21, 32, 27, 3, -32 },
  { 3255, 23, 32, 27, 2, -32 },
  { 3347, 21, 32, 27, 4, -32 },
  { 3431, 24, 38, 27, 2, -32 },
  { 3545, 23, 32, 27, 3, -32 },
  { 3637, 23, 32, 27, 2, -32 },
  { 3729, 25, 32, 27, 1, -32 },
  { 3829, 21, 32, 27, 3, -32 },
  { 3913, 25, 32, 27, 1, -32 },
  { 4013, 25, 32, 27, 1, -32 },
  { 4113, 25, 32, 27, 1, -32 },
  { 4213, 25, 32, 27, 1, -32 },
  { 4313, 23, 32, 27, 2, -32 },
  { 4405, 9, 44, 27, 9, -37 },
  { 4455, 18, 35, 27, 5, -32 },
  { 4534, 9, 44, 27, 9, -37 },
  { 4584, 18, 17, 27, 5, -32 },
  { 4623, 20, 4, 27, 3, 0 },
  { 4633, 10, 7, 27, 9, -33 },
  { 4642, 21, 24, 27, 3, -24 },
  { 4705, 21, 34, 27, 3, -34 },
  { 4795, 21, 24, 27, 3, -24 },
  { 4858, 20, 34, 27, 3, -34 },
  { 4943, 21, 24, 27, 3, -24 },
  { 5006, 22, 35, 27, 3, -35 },
  { 5103, 21, 33, 27, 3, -24 },
  { 5190, 21, 34, 27, 3, -34 },
  { 5280, 19, 33, 27, 5, -33 },
  { 5359, 14, 43, 27, 5, -33 },
  { 5435, 23, 34, 27, 3, -34 },
  { 5533, 20, 34, 27, 4, -34 },
  { 5618, 23, 24, 27, 2, -24 },
  { 5687, 21, 24, 27, 3, -24 },
  { 5750, 23, 24, 27, 2, -24 },
  { 5819, 21, 33, 27, 3, -24 },
  { 5906, 20, 33, 27, 3, -24 },
  { 5989, 17, 24, 27, 7, -24 },
  { 6040, 21, 24, 27, 3, -24 },
  { 6103, 21, 30, 27, 3, -30 },
  { 6182, 20, 24, 27, 4, -24 },
  { 6242, 23, 24, 27, 2, -24 },
  { 6311, 25, 24, 27, 1, -24 },
  { 6386, 24, 24, 27, 2, -24 },
  { 6458, 25, 34, 27, 1, -24 },
  { 6565, 21, 24, 27, 3, -24 },
  { 6628, 15, 43, 27, 7, -35 },
  { 6709, 3, 41, 27, 12, -32 },
  { 6725, 15, 43, 27, 7, -35 },
  { 6806, 24, 9, 27, 1, -18 },
};

const GFXfont RobotoMono_Medium45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium45pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_MEDIUM45PT7B_H_
