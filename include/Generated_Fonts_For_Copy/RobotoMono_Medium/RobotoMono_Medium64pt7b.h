#ifndef _ROBOTOMONO_MEDIUM64PT7B_H_
#define _ROBOTOMONO_MEDIUM64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x8F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x60, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0xFC,
  0x3E, 0x00, 0xFC, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x7C, 0x00, 0x7E,
  0x1F, 0x87, 0xC0, 0x07, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0x80,
  0x01, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x1F, 0xF0, 0x00, 0x07, 0xC3, 0xFF, 0x80, 0x00, 0xF8, 0x7F, 0xFC, 0x00,
  0x0F, 0x8F, 0xFF, 0xE0, 0x01, 0xF0, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x83,
  0xF0, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00,
  0x78, 0x1F, 0x01, 0xF0, 0x01, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0xFF,
  0xC0, 0x7F, 0x1F, 0xE7, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0xC1, 0xFC, 0xFF,
  0x07, 0xF8, 0x3F, 0x3F, 0xC0, 0x7F, 0x8F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFC,
  0xFE, 0x00, 0xFF, 0xBF, 0x9F, 0xC0, 0x0F, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xE1, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xF1, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x0F, 0x80, 0x11, 0xF0,
  0x1F, 0x00, 0xF3, 0xF8, 0x3E, 0x07, 0xE7, 0xFC, 0x7C, 0x7F, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x40, 0x01, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x0F, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0xF1, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xFD, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x03, 0xFE, 0x3F, 0xFC, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0x8F, 0xF0, 0x07,
  0xFE, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x07, 0xFE, 0x3F,
  0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x7F, 0xF8, 0x0F, 0xF7, 0xFF, 0xF8,
  0x3F, 0xBF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0x8F,
  0xF8, 0x07, 0xFE, 0x3F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x3F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xBF, 0x81, 0xFF, 0xF1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xC7, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0xC0, 0x40, 0x03, 0x00, 0xFF, 0x0F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xFC, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xCF, 0xF8, 0x03, 0xFE,
  0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xFC,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xFF, 0x83, 0xC1, 0xF0, 0x3F, 0xFC, 0x3E,
  0x1F, 0x07, 0xFF, 0xE3, 0xE1, 0xE0, 0x7F, 0xFC, 0x1E, 0x3E, 0x0F, 0xC3,
  0xC1, 0xE3, 0xE0, 0xF8, 0x3C, 0x1E, 0x3C, 0x1F, 0x03, 0xC1, 0xE7, 0xC1,
  0xF0, 0x3C, 0x1E, 0x7C, 0x3E, 0x03, 0xC1, 0xE7, 0xC3, 0xE0, 0x3C, 0x1E,
  0x78, 0x3E, 0x03, 0xC1, 0xE7, 0x83, 0xE0, 0x7C, 0x1E, 0x78, 0x3C, 0x07,
  0xC1, 0xE7, 0x83, 0xC0, 0x7C, 0x1E, 0x78, 0x7C, 0x07, 0xC1, 0xE7, 0x87,
  0xC0, 0x78, 0x1E, 0x78, 0x7C, 0x07, 0x83, 0xC7, 0x87, 0xC0, 0x78, 0x3C,
  0x78, 0x3E, 0x07, 0x83, 0xC7, 0xC3, 0xE0, 0xF8, 0x7C, 0x7C, 0x3F, 0xBF,
  0xCF, 0x87, 0xC3, 0xFF, 0xFF, 0xF8, 0x7C, 0x1F, 0xFB, 0xFF, 0x03, 0xE0,
  0xFF, 0x3F, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0xC7, 0xF0, 0x07,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x00, 0xFF,
  0xE3, 0xF8, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF,
  0x80, 0x03, 0xFF, 0x7F, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xE0, 0x00,
  0x7F, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00,
  0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0xC3, 0xF8, 0x00,
  0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x01, 0xFC,
  0x1F, 0xF0, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F,
  0x8F, 0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x07,
  0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x07,
  0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x83, 0xF8, 0x00,
  0x3F, 0xE1, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0x01, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x3F, 0xEF, 0xE0,
  0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xEF, 0xFF, 0xDF, 0x0F, 0xDF, 0xFF, 0xBF, 0x1F, 0xBF, 0xFF, 0x7E,
  0x3E, 0x7F, 0xFE, 0x7C, 0xFC, 0xFF, 0xFC, 0xF9, 0xF9, 0xFF, 0xF9, 0xFB,
  0xE3, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07,
  0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF, 0x81, 0xF0, 0x3F,
  0xFF, 0x03, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x7E, 0x03, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xCF,
  0xE0, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xF1, 0xFC,
  0x3F, 0xFF, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xCF,
  0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x03, 0xFB, 0xFF,
  0xFC, 0x07, 0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0x0F,
  0xFC, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x80,
  0x7F, 0x7F, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0x7F, 0x7F, 0x01,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0x7F, 0x7F, 0x03, 0xFC, 0x07, 0xF7,
  0xF0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0xE0,
  0xFE, 0x3F, 0x83, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xE0, 0xFE, 0x3F, 0x83,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0xE0, 0xFE, 0x3F, 0x87, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0xF0, 0xFC, 0x1F, 0x87, 0xFF, 0x0F, 0xC1, 0xF8, 0x7D, 0xF1,
  0xFC, 0x1F, 0x87, 0xDF, 0x1F, 0xC1, 0xFC, 0xFD, 0xF1, 0xFC, 0x1F, 0xCF,
  0xDF, 0x1F, 0xC1, 0xFC, 0xF9, 0xF9, 0xFC, 0x1F, 0xCF, 0x9F, 0x9F, 0xC1,
  0xFC, 0xF8, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF8, 0xF9,
  0xF8, 0x0F, 0xDF, 0x8F, 0xBF, 0x80, 0xFD, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0,
  0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFE, 0x0F,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE1, 0xFF,
  0x80, 0x3F, 0x8F, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xE3,
  0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFE,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFF,
  0x80, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF,
  0xE0, 0x3F, 0x87, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x0F, 0xE0, 0x7F, 0xFE, 0x7F, 0x07, 0xFF, 0xFB, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x01,
  0xFF, 0x9F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xCF, 0xE0,
  0x1F, 0xFC, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x20, 0xFF, 0x80, 0x00, 0xC0,
  0xFF, 0x80, 0x03, 0xC1, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xF3, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF8, 0x02, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xC7, 0xF0, 0x7F,
  0xFF, 0xDF, 0xC3, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x07,
  0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03,
  0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x07, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0x8F, 0xF0, 0x01,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x10, 0x00,
  0x1F, 0xE0, 0xE0, 0x00, 0x7F, 0x83, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC3, 0xFF, 0xE0, 0xFE, 0x7F,
  0xFF, 0xC7, 0xF7, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00,
  0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x07,
  0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0xFE, 0x3F,
  0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x0F, 0xFC, 0xFE, 0x00,
  0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0x87, 0xF8, 0x7E, 0x7F, 0xE7, 0xFE, 0x3F, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xF8, 0x3F, 0xC1, 0xFD, 0xFC, 0x1F, 0xE0, 0xFF, 0xFC, 0x07, 0xF0,
  0x3F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x03,
  0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xF8,
  0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF,
  0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFF,
  0xE0, 0x3F, 0x81, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F,
  0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFE,
  0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xF1, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0x7F, 0xDF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x1F, 0xF8,
  0x07, 0xF3, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0x9F, 0xF0,
  0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFF,
  0x80, 0x7F, 0xCF, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xDF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFE, 0x07, 0xF0, 0xFF, 0xC0,
  0x3F, 0x80, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF, 0x8F, 0xC1, 0xFF, 0xFE, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x7F, 0xE7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xF3, 0xF8,
  0x07, 0xFF, 0x1F, 0xC0, 0x03, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x02, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xEF, 0xE1, 0xFF, 0xFE, 0x7F, 0x07,
  0xFF, 0xE3, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0x80, 0x7F, 0x7E, 0x01, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x80,
  0x7E, 0x7F, 0x01, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0xE0, 0xFC, 0x3F, 0x07, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0xE0,
  0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xF8, 0x7D, 0xE1, 0xF8, 0x1F, 0x87,
  0x9F, 0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x81,
  0xFC, 0xF9, 0xF1, 0xF8, 0x0F, 0xCF, 0x0F, 0x1F, 0x80, 0xFC, 0xF0, 0xFB,
  0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF,
  0x07, 0xBF, 0x00, 0x7D, 0xE0, 0x7B, 0xF0, 0x07, 0xDE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x78, 0x7F, 0xFF, 0x00, 0x0F, 0x9F, 0xFF, 0xF0, 0x01, 0xF7,
  0xFF, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFF, 0xEF,
  0xF7, 0xE0, 0x0F, 0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0x00, 0x0F,
  0xFF, 0xF3, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00,
};

const GFXglyph RobotoMono_Medium64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 8, 46, 38, 15, -46 },
  { 47, 18, 16, 38, 10, -48 },
  { 83, 34, 46, 38, 2, -46 },
  { 279, 31, 60, 38, 4, -53 },
  { 512, 36, 47, 38, 1, -46 },
  { 724, 35, 47, 38, 3, -46 },
  { 930, 6, 16, 38, 15, -48 },
  { 942, 17, 65, 38, 11, -51 },
  { 1081, 17, 65, 38, 10, -51 },
  { 1220, 31, 32, 38, 5, -46 },
  { 1344, 32, 33, 38, 3, -38 },
  { 1476, 10, 19, 38, 11, -7 },
  { 1500, 25, 6, 38, 8, -23 },
  { 1519, 11, 11, 38, 14, -10 },
  { 1535, 25, 50, 38, 7, -46 },
  { 1692, 30, 47, 38, 4, -46 },
  { 1869, 19, 46, 38, 6, -46 },
  { 1979, 32, 46, 38, 2, -46 },
  { 2163, 30, 47, 38, 3, -46 },
  { 2340, 33, 46, 38, 2, -46 },
  { 2530, 29, 47, 38, 5, -46 },
  { 2701, 30, 47, 38, 4, -46 },
  { 2878, 31, 46, 38, 3, -46 },
  { 3057, 30, 47, 38, 4, -46 },
  { 3234, 29, 46, 38, 4, -46 },
  { 3401, 11, 37, 38, 15, -36 },
  { 3452, 13, 48, 38, 14, -36 },
  { 3530, 27, 29, 38, 5, -34 },
  { 3628, 29, 19, 38, 5, -29 },
  { 3697, 28, 29, 38, 5, -34 },
  { 3799, 29, 46, 38, 5, -46 },
  { 3966, 36, 45, 38, 1, -45 },
  { 4169, 36, 46, 38, 2, -46 },
  { 4376, 31, 46, 38, 5, -46 },
  { 4555, 32, 47, 38, 3, -46 },
  { 4743, 32, 46, 38, 4, -46 },
  { 4927, 30, 46, 38, 5, -46 },
  { 5100, 30, 46, 38, 5, -46 },
  { 5273, 32, 47, 38, 3, -46 },
  { 5461, 30, 46, 38, 4, -46 },
  { 5634, 27, 46, 38, 6, -46 },
  { 5790, 31, 47, 38, 3, -46 },
  { 5973, 33, 46, 38, 5, -46 },
  { 6163, 30, 46, 38, 5, -46 },
  { 6336, 31, 46, 38, 4, -46 },
  { 6515, 30, 46, 38, 4, -46 },
  { 6688, 33, 47, 38, 3, -46 },
  { 6882, 31, 46, 38, 5, -46 },
  { 7061, 34, 54, 38, 3, -46 },
  { 7291, 32, 46, 38, 5, -46 },
  { 7475, 33, 47, 38, 3, -46 },
  { 7669, 36, 46, 38, 1, -46 },
  { 7876, 30, 47, 38, 4, -46 },
  { 8053, 36, 46, 38, 1, -46 },
  { 8260, 36, 46, 38, 1, -46 },
  { 8467, 35, 46, 38, 2, -46 },
  { 8669, 36, 46, 38, 1, -46 },
  { 8876, 32, 46, 38, 3, -46 },
  { 9060, 13, 62, 38, 13, -52 },
  { 9161, 25, 50, 38, 7, -46 },
  { 9318, 13, 62, 38, 13, -52 },
  { 9419, 25, 25, 38, 7, -46 },
  { 9498, 28, 6, 38, 5, 0 },
  { 9519, 14, 8, 38, 13, -46 },
  { 9533, 30, 35, 38, 4, -34 },
  { 9665, 30, 49, 38, 5, -48 },
  { 9849, 30, 35, 38, 4, -34 },
  { 9981, 29, 49, 38, 4, -48 },
  { 10159, 31, 35, 38, 4, -34 },
  { 10295, 32, 49, 38, 4, -49 },
  { 10491, 30, 47, 38, 4, -34 },
  { 10668, 29, 48, 38, 5, -48 },
  { 10842, 27, 47, 38, 7, -47 },
  { 11001, 20, 61, 38, 7, -47 },
  { 11154, 32, 48, 38, 5, -48 },
  { 11346, 29, 48, 38, 6, -48 },
  { 11520, 33, 34, 38, 3, -34 },
  { 11661, 29, 34, 38, 5, -34 },
  { 11785, 32, 35, 38, 3, -34 },
  { 11925, 29, 47, 38, 5, -34 },
  { 12096, 29, 47, 38, 4, -34 },
  { 12267, 24, 34, 38, 10, -34 },
  { 12369, 30, 35, 38, 4, -34 },
  { 12501, 30, 43, 38, 4, -42 },
  { 12663, 29, 35, 38, 5, -34 },
  { 12790, 33, 34, 38, 3, -34 },
  { 12931, 36, 34, 38, 1, -34 },
  { 13084, 33, 34, 38, 3, -34 },
  { 13225, 35, 48, 38, 2, -34 },
  { 13435, 31, 34, 38, 4, -34 },
  { 13567, 21, 61, 38, 10, -50 },
  { 13728, 5, 59, 38, 17, -46 },
  { 13765, 21, 61, 38, 10, -50 },
  { 13926, 35, 13, 38, 1, -25 },
};

const GFXfont RobotoMono_Medium64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium64pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_MEDIUM64PT7B_H_
