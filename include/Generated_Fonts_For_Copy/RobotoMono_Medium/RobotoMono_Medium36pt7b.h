#ifndef _ROBOTOMONO_MEDIUM36PT7B_H_
#define _ROBOTOMONO_MEDIUM36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78,
  0x00, 0x00, 0x11, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0x78, 0xEF,
  0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x1F,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xEF, 0x80,
  0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0E, 0x38, 0x40,
  0xE3, 0x87, 0x0E, 0x38, 0x60, 0xE3, 0x8E, 0x0E, 0x38, 0xC0, 0xF3, 0x9C,
  0x07, 0xF3, 0x80, 0x3E, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x78, 0x01, 0x9F, 0xE0, 0x39, 0xFE, 0x03,
  0x38, 0x70, 0x73, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x02, 0x38, 0x70,
  0x03, 0xCF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xBE, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x01,
  0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x7B, 0xEF, 0x0F, 0xF9, 0xF1, 0xFE,
  0x1F, 0x7B, 0xC1, 0xFF, 0x78, 0x1F, 0xEF, 0x03, 0xF9, 0xE0, 0x3E, 0x3E,
  0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0x7C, 0xFF, 0xFF, 0xFE,
  0xEE, 0xE0, 0x00, 0x80, 0x60, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x06, 0x00,
  0x80, 0x80, 0x60, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x0E, 0x0B, 0xC7, 0x1F, 0xFB, 0xBF,
  0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x73,
  0xC0, 0x78, 0xF0, 0x78, 0x3C, 0x1C, 0x1C, 0x04, 0x04, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0x9E, 0x73, 0xC2, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xEF, 0xF7,
  0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0x00, 0x20, 0x1C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F,
  0x9E, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x81, 0xF7, 0xC0,
  0x7B, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7B, 0xF0,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0E, 0xF8, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0x8F,
  0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC1, 0xC0, 0xF8, 0x78, 0x1F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7B, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE,
  0x70, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x00, 0x38, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0xF8, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF7, 0xE0, 0xFB, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xE0,
  0x78, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1F, 0x78,
  0x0F, 0x3E, 0x07, 0x8F, 0x87, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF8, 0xF8, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC1,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xE0, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xEF, 0x00, 0x87, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0xFB,
  0xFB, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x7D, 0xFD, 0xF3, 0xE0, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E,
  0x3C, 0x71, 0xC0, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0,
  0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x7C, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFC, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xC3, 0x87, 0xCE, 0x71,
  0xFE, 0x67, 0x1E, 0xC6, 0x63, 0x8C, 0x6E, 0x30, 0xC6, 0xE7, 0x0C, 0x6E,
  0x70, 0xC6, 0xE7, 0x0C, 0x6E, 0x71, 0xC6, 0xE7, 0x1C, 0x6E, 0x71, 0xCE,
  0xE7, 0x3C, 0xCE, 0x7F, 0xFC, 0xE3, 0xEF, 0x87, 0x08, 0x20, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x1C, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0x9E, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xBC, 0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xF3, 0xC1, 0xFD,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC1, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E,
  0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x1F, 0x78, 0x07, 0x9F,
  0x03, 0xE3, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x3F, 0x3E, 0x07,
  0xCF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07,
  0xCF, 0x9F, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF3,
  0xE0, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x79, 0xF0, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07,
  0xF8, 0x00, 0xF0, 0x07, 0xDE, 0x01, 0xF3, 0xC0, 0x7E, 0x78, 0x0F, 0x8F,
  0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF1, 0xF0, 0x1E,
  0x7C, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xEF, 0x80, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x03, 0xE1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0x7C, 0xF0,
  0x07, 0xDE, 0x00, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xFC, 0xEF, 0xF7, 0x3B, 0xFD, 0xDE, 0xFF, 0x7F, 0x3F, 0xCF, 0xCF, 0xF3,
  0xF3, 0xFC, 0xF8, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xC3, 0xFC, 0x70,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0xE1, 0xFF, 0x78, 0xFF, 0x9C, 0x7F, 0xCF,
  0x3F, 0xE7, 0x9F, 0xF1, 0xEF, 0xF8, 0xF7, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7C, 0x1F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1E,
  0x78, 0x07, 0x9F, 0x03, 0xE3, 0xE3, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01,
  0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x03, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xC1, 0xF0, 0xF0, 0x1F,
  0x3E, 0x01, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x03, 0xE7, 0x80, 0x78,
  0xF8, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0xFF, 0x80,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xCF,
  0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x7C, 0xF0, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F,
  0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0xE0,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0x7C,
  0xF8, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0xF8, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C,
  0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF9,
  0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x1F, 0x0E, 0x71, 0xF1, 0xE7, 0x9F, 0x9E, 0x79, 0xF9,
  0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0xBF, 0x9E, 0x7B, 0xB9, 0xC3, 0xB9,
  0xDC, 0x3B, 0x9D, 0xC3, 0xB9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F,
  0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0x78, 0xF8, 0x01, 0xF7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81,
  0xE0, 0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07,
  0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1,
  0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xF0, 0xE1, 0xC7, 0x87,
  0x9C, 0x0E, 0x70, 0x3B, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3C, 0x1E, 0x0E, 0x0F, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0x83, 0xE7, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x9F, 0x83, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0,
  0x3C, 0xF8, 0x7E, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF9, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF3, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xF3, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3,
  0xE7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x3D, 0xF0, 0x3E,
  0x7C, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x0F, 0xE7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0,
  0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x3E, 0xFC, 0x3F,
  0x3F, 0xFF, 0x8F, 0xFB, 0xC3, 0xF9, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x30, 0xFC, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE7, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xC3, 0xF7, 0xC0, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0,
  0x3E, 0x7C, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xF9, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x80, 0x78, 0xE0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x0F, 0xFF, 0xF7, 0xFC, 0xFF, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x07, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0,
  0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xE7, 0xC0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0,
  0xF8, 0xF0, 0x3F, 0x3C, 0x07, 0xCF, 0x00, 0xFC, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xEF, 0x9E, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xF8, 0xFF,
  0x0F, 0x1F, 0xE1, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE,
  0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x78, 0xFF, 0x0F, 0x1F, 0xE1, 0xE3, 0xFC,
  0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0x80,
  0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF8, 0x7C, 0x7C,
  0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF9,
  0xF8, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xF7, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xF7, 0xF0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0F, 0xE7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xFB,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x3E, 0xFC, 0x3F, 0x3F,
  0xFF, 0x8F, 0xFB, 0xC3, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF1, 0xFF, 0xCF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xFE, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x08, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF,
  0x1F, 0xCF, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xC0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x07, 0x78, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0xE0, 0xFF, 0x0E, 0x0F, 0xF0, 0xF0, 0xEF, 0x0F, 0x0E, 0xF1, 0xF1,
  0xE7, 0x1F, 0x1E, 0x71, 0xF9, 0xE7, 0x9B, 0x9C, 0x79, 0xB9, 0xC7, 0xBB,
  0x9C, 0x3B, 0x9B, 0xC3, 0xB9, 0xFC, 0x3B, 0x1F, 0x83, 0xB1, 0xF8, 0x3F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x00,
  0xF8, 0x07, 0xCF, 0x80, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x81, 0xF3, 0xE0,
  0x1E, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0x7C, 0x07, 0xC7, 0x81,
  0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1F, 0x80, 0xF8, 0x01,
  0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0,
  0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x87, 0xE0, 0xF8,
  0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF8, 0x0E, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x83, 0xF9,
  0xFD, 0xFE, 0x0F, 0xFD, 0xC0, 0xFF, 0x80, 0x07, 0xE0,
};

const GFXglyph RobotoMono_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 26, 22, 8, -26 },
  { 18, 11, 9, 22, 5, -27 },
  { 31, 19, 26, 22, 1, -26 },
  { 93, 18, 34, 22, 2, -30 },
  { 170, 20, 26, 22, 1, -26 },
  { 235, 19, 26, 22, 2, -26 },
  { 297, 4, 9, 22, 8, -27 },
  { 302, 10, 37, 22, 6, -29 },
  { 349, 9, 37, 22, 6, -29 },
  { 391, 17, 18, 22, 3, -26 },
  { 430, 17, 18, 22, 2, -21 },
  { 469, 6, 11, 22, 6, -4 },
  { 478, 15, 3, 22, 4, -13 },
  { 484, 6, 5, 22, 8, -5 },
  { 488, 14, 28, 22, 4, -26 },
  { 537, 16, 26, 22, 3, -26 },
  { 589, 11, 26, 22, 3, -26 },
  { 625, 18, 26, 22, 1, -26 },
  { 684, 17, 26, 22, 2, -26 },
  { 740, 19, 26, 22, 1, -26 },
  { 802, 16, 26, 22, 3, -26 },
  { 854, 17, 26, 22, 2, -26 },
  { 910, 17, 26, 22, 2, -26 },
  { 966, 17, 26, 22, 2, -26 },
  { 1022, 17, 26, 22, 2, -26 },
  { 1078, 7, 20, 22, 8, -20 },
  { 1096, 7, 27, 22, 8, -20 },
  { 1120, 15, 16, 22, 3, -19 },
  { 1150, 16, 11, 22, 3, -17 },
  { 1172, 16, 16, 22, 3, -19 },
  { 1204, 16, 26, 22, 3, -26 },
  { 1256, 20, 25, 22, 1, -25 },
  { 1319, 20, 26, 22, 1, -26 },
  { 1384, 17, 26, 22, 3, -26 },
  { 1440, 18, 26, 22, 2, -26 },
  { 1499, 18, 26, 22, 2, -26 },
  { 1558, 16, 26, 22, 3, -26 },
  { 1610, 17, 26, 22, 3, -26 },
  { 1666, 18, 26, 22, 2, -26 },
  { 1725, 17, 26, 22, 2, -26 },
  { 1781, 15, 26, 22, 3, -26 },
  { 1830, 17, 26, 22, 2, -26 },
  { 1886, 19, 26, 22, 3, -26 },
  { 1948, 16, 26, 22, 3, -26 },
  { 2000, 18, 26, 22, 2, -26 },
  { 2059, 17, 26, 22, 2, -26 },
  { 2115, 18, 26, 22, 2, -26 },
  { 2174, 17, 26, 22, 3, -26 },
  { 2230, 19, 30, 22, 2, -26 },
  { 2302, 18, 26, 22, 3, -26 },
  { 2361, 18, 26, 22, 2, -26 },
  { 2420, 20, 26, 22, 1, -26 },
  { 2485, 17, 26, 22, 2, -26 },
  { 2541, 20, 26, 22, 1, -26 },
  { 2606, 20, 26, 22, 1, -26 },
  { 2671, 20, 26, 22, 1, -26 },
  { 2736, 20, 26, 22, 1, -26 },
  { 2801, 18, 26, 22, 2, -26 },
  { 2860, 8, 36, 22, 7, -30 },
  { 2896, 14, 28, 22, 4, -26 },
  { 2945, 8, 36, 22, 7, -30 },
  { 2981, 14, 14, 22, 4, -26 },
  { 3006, 16, 3, 22, 3, 0 },
  { 3012, 8, 5, 22, 7, -26 },
  { 3017, 17, 19, 22, 2, -19 },
  { 3058, 16, 27, 22, 3, -27 },
  { 3112, 17, 19, 22, 2, -19 },
  { 3153, 17, 27, 22, 2, -27 },
  { 3211, 18, 19, 22, 2, -19 },
  { 3254, 18, 28, 22, 2, -28 },
  { 3317, 17, 26, 22, 2, -19 },
  { 3373, 16, 27, 22, 3, -27 },
  { 3427, 15, 26, 22, 4, -26 },
  { 3476, 11, 34, 22, 4, -26 },
  { 3523, 18, 27, 22, 3, -27 },
  { 3584, 16, 27, 22, 4, -27 },
  { 3638, 19, 19, 22, 1, -19 },
  { 3684, 16, 19, 22, 3, -19 },
  { 3722, 18, 19, 22, 2, -19 },
  { 3765, 16, 26, 22, 3, -19 },
  { 3817, 17, 26, 22, 2, -19 },
  { 3873, 14, 19, 22, 5, -19 },
  { 3907, 16, 19, 22, 3, -19 },
  { 3945, 17, 24, 22, 2, -24 },
  { 3996, 16, 19, 22, 3, -19 },
  { 4034, 19, 19, 22, 1, -19 },
  { 4080, 20, 19, 22, 1, -19 },
  { 4128, 19, 19, 22, 2, -19 },
  { 4174, 20, 27, 22, 1, -19 },
  { 4242, 18, 19, 22, 2, -19 },
  { 4285, 11, 34, 22, 6, -28 },
  { 4332, 3, 33, 22, 9, -26 },
  { 4345, 12, 34, 22, 6, -28 },
  { 4396, 19, 7, 22, 1, -14 },
};

const GFXfont RobotoMono_Medium36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium36pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_MEDIUM36PT7B_H_
