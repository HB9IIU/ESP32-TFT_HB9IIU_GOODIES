#ifndef _ROBOTOMONO_MEDIUM63PT7B_H_
#define _ROBOTOMONO_MEDIUM63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF3, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xC0, 0x3C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0xEF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x04, 0x00, 0xFC, 0x0F,
  0x80, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0xFC, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x78, 0x00, 0x7F, 0x3F,
  0x8F, 0x80, 0x07, 0xFF, 0xF1, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x01,
  0xFF, 0xC3, 0xE0, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x3F,
  0xF0, 0x00, 0x0F, 0x87, 0xFF, 0x80, 0x00, 0xF8, 0xFF, 0xFC, 0x00, 0x1F,
  0x1F, 0xFF, 0xE0, 0x01, 0xF1, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x03, 0xE0,
  0x03, 0xE3, 0xF0, 0x3E, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x07, 0x83, 0xF0,
  0x3F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x07, 0x03, 0xF0, 0x3F, 0x00, 0x30,
  0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0x87, 0xFF, 0xF8, 0x07,
  0xE3, 0xFE, 0xFF, 0x01, 0xF9, 0xFF, 0x1F, 0xE0, 0xFE, 0x7F, 0x87, 0xFC,
  0x3F, 0xBF, 0xC0, 0xFF, 0x0F, 0xEF, 0xF0, 0x1F, 0xE3, 0xF3, 0xF8, 0x03,
  0xFD, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xE0,
  0x03, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x1F, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xEF,
  0xF8, 0x1F, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02, 0x40, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x07, 0xC0, 0x01, 0xC0, 0x1F,
  0x00, 0x67, 0xE0, 0x7C, 0x0F, 0x9F, 0xE1, 0xE0, 0xFE, 0xFF, 0xE7, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3,
  0xF8, 0xFC, 0x0E, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xCF,
  0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFB, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x9F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC,
  0x03, 0xFF, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x38, 0x00, 0x7F, 0x1F, 0xFC, 0x07, 0xF1, 0xFF, 0xF8, 0x3F, 0xBF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F,
  0xF3, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x01,
  0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F,
  0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F,
  0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF,
  0x1F, 0xC0, 0xE0, 0x02, 0x01, 0xFC, 0x3F, 0xE3, 0xFF, 0x3F, 0xF7, 0xFF,
  0x7F, 0xF3, 0xFF, 0x3F, 0xE1, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0,
  0x38, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x7F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xFC, 0x1E, 0x07, 0x80, 0xFF, 0xC3,
  0xE1, 0xF0, 0x3F, 0xFC, 0x3C, 0x3C, 0x0F, 0xFF, 0x87, 0x8F, 0x83, 0xF0,
  0xF0, 0xF1, 0xF0, 0x7C, 0x1E, 0x1F, 0x3C, 0x1F, 0x03, 0xC1, 0xEF, 0x83,
  0xE0, 0xF8, 0x3D, 0xF0, 0xF8, 0x1F, 0x07, 0xBE, 0x1F, 0x03, 0xE0, 0xF7,
  0x83, 0xE0, 0x78, 0x1E, 0xF0, 0x78, 0x0F, 0x03, 0xDE, 0x0F, 0x01, 0xE0,
  0x7B, 0xC3, 0xE0, 0x3C, 0x0F, 0x78, 0x7C, 0x07, 0x83, 0xCF, 0x0F, 0x80,
  0xF0, 0x79, 0xE1, 0xF0, 0x1E, 0x0F, 0x3C, 0x3E, 0x03, 0xC1, 0xE7, 0x87,
  0xC0, 0xF8, 0x78, 0xF0, 0x7C, 0x1F, 0x0F, 0x1F, 0x0F, 0xCF, 0xE3, 0xE3,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7C, 0x1F, 0xFF, 0xFE, 0x07, 0x83, 0xFE, 0x7F,
  0xC0, 0xF8, 0x3F, 0x87, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x04, 0x00, 0x07, 0xFC, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0, 0x01, 0xFF, 0x3F, 0x80, 0x0F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x01,
  0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xE0, 0x00,
  0xFF, 0x87, 0xF0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x81, 0xFC, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0,
  0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x1F,
  0xDF, 0xF0, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xF8, 0x07, 0xFC,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xE1, 0xFC, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80,
  0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xEF,
  0xFF, 0xFE, 0x1F, 0xBF, 0xFF, 0xF8, 0x7E, 0xFF, 0xFB, 0xE1, 0xFB, 0xFF,
  0xEF, 0x8F, 0xCF, 0xFF, 0xBF, 0x3F, 0x3F, 0xFE, 0xFC, 0xFC, 0xFF, 0xF9,
  0xF7, 0xE3, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x9F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xF1, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0x87, 0xF8,
  0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3E, 0x07, 0xFF,
  0xE0, 0x78, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x7E, 0x03, 0xFF,
  0xFD, 0xFC, 0x0F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xCF, 0xE0, 0xFF, 0xFF,
  0x1F, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF8, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0x8F, 0xFF, 0xF0, 0x7F,
  0x3F, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFC, 0x07, 0xEF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0,
  0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xF1, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x7F, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xCF,
  0xE0, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFE, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F,
  0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x03,
  0xFE, 0x1F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF,
  0x07, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0x80, 0x7F, 0x7F, 0x01, 0xF8, 0x07, 0xF7, 0xF0, 0x1F,
  0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F,
  0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F,
  0xE0, 0xFC, 0x3F, 0x87, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F,
  0x87, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x1F, 0x87, 0xFE, 0x1F,
  0xC1, 0xF8, 0xFF, 0xF1, 0xFC, 0x1F, 0x8F, 0xDF, 0x1F, 0x81, 0xF8, 0xF9,
  0xF1, 0xF8, 0x1F, 0xCF, 0x9F, 0x1F, 0x81, 0xFC, 0xF9, 0xF1, 0xF8, 0x1F,
  0xCF, 0x9F, 0x3F, 0x81, 0xFC, 0xF9, 0xFB, 0xF8, 0x0F, 0xDF, 0x8F, 0xBF,
  0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0,
  0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0x1F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xE7, 0xF8, 0x0F, 0xFE,
  0x0F, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0xFF, 0xF0,
  0x1F, 0xCF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF,
  0xEF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF,
  0xF0, 0x7F, 0x3F, 0xFF, 0x03, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xCF, 0xF0,
  0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x83, 0xFC, 0x07, 0xFF,
  0x9F, 0xE0, 0x7F, 0xFE, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xBF,
  0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9,
  0xFF, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xBF, 0x81, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0x0F, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0x83, 0xFE, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xDF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF,
  0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xF3, 0xF8, 0x07,
  0xFE, 0x1F, 0xC0, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x82, 0x00, 0x03, 0xFC, 0x30, 0x00, 0x3F, 0xC3, 0xE0, 0x03, 0xFE,
  0x1F, 0xC0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x7F, 0xF8, 0x1F, 0xC7, 0xFF, 0xF0,
  0xFE, 0x7F, 0xFF, 0xC7, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xE0, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x83,
  0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x80, 0x3F, 0x83, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0xFE,
  0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x9F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x7F,
  0xC7, 0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0xFF,
  0xBF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0xFC, 0xFF, 0x8F, 0xF8, 0xFD, 0xFF,
  0xDF, 0xFC, 0xFD, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0xFF,
  0xF0, 0x3F, 0x8F, 0xFF, 0xE1, 0xFC, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF1, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x07, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xE0, 0xFE, 0x7F,
  0xFE, 0x07, 0xF0, 0xFF, 0xC0, 0x3F, 0x80, 0x60, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x1F,
  0xC0, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF,
  0x8F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xF7, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x03, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x7F,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xF7, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7E, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xF0, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0xDF, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x3F, 0xF7, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0x7F, 0x1F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0x83, 0xF0,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0xFD,
  0xF8, 0x07, 0xE0, 0x3F, 0xBF, 0x00, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x80,
  0xFE, 0xFE, 0x07, 0xF0, 0x1F, 0x9F, 0xC0, 0xFF, 0x03, 0xF1, 0xF8, 0x1F,
  0xE0, 0x7E, 0x3F, 0x07, 0xFC, 0x0F, 0xC7, 0xE0, 0xFF, 0x83, 0xF8, 0xFC,
  0x1F, 0xF8, 0x7E, 0x1F, 0xC3, 0xDF, 0x0F, 0xC1, 0xF8, 0x7B, 0xE1, 0xF8,
  0x3F, 0x1F, 0x7C, 0x3F, 0x07, 0xE3, 0xE7, 0x87, 0xE0, 0xFC, 0x7C, 0xF9,
  0xF8, 0x1F, 0x8F, 0x1F, 0x3F, 0x01, 0xF1, 0xE3, 0xE7, 0xE0, 0x3F, 0x7C,
  0x7C, 0xFC, 0x07, 0xEF, 0x87, 0x9F, 0x80, 0xFD, 0xF0, 0xFB, 0xE0, 0x1F,
  0xBC, 0x1F, 0x7C, 0x03, 0xF7, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x7F,
  0xFE, 0x00, 0x1F, 0x9F, 0xFF, 0xE0, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x7C,
  0xFF, 0xFF, 0xF0, 0x1F, 0x9F, 0xC3, 0xFF, 0x8F, 0xF7, 0xF0, 0x1F, 0xFF,
  0xFE, 0xFC, 0x01, 0xFF, 0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0xE3, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_Medium63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 9, 45, 38, 14, -45 },
  { 52, 17, 15, 38, 10, -47 },
  { 84, 35, 45, 38, 1, -45 },
  { 281, 30, 58, 38, 4, -52 },
  { 499, 36, 46, 38, 1, -45 },
  { 706, 34, 46, 38, 3, -45 },
  { 902, 5, 16, 38, 15, -47 },
  { 912, 16, 64, 38, 11, -50 },
  { 1040, 17, 64, 38, 10, -50 },
  { 1176, 30, 31, 38, 5, -45 },
  { 1293, 31, 33, 38, 3, -37 },
  { 1421, 10, 19, 38, 11, -7 },
  { 1445, 25, 6, 38, 8, -23 },
  { 1464, 11, 11, 38, 14, -10 },
  { 1480, 25, 49, 38, 7, -45 },
  { 1634, 30, 46, 38, 4, -45 },
  { 1807, 19, 45, 38, 6, -45 },
  { 1914, 31, 45, 38, 2, -45 },
  { 2089, 30, 46, 38, 3, -45 },
  { 2262, 33, 45, 38, 2, -45 },
  { 2448, 30, 46, 38, 4, -45 },
  { 2621, 29, 46, 38, 4, -45 },
  { 2788, 31, 45, 38, 3, -45 },
  { 2963, 30, 46, 38, 4, -45 },
  { 3136, 29, 45, 38, 4, -45 },
  { 3300, 11, 37, 38, 15, -36 },
  { 3351, 12, 48, 38, 14, -36 },
  { 3423, 27, 29, 38, 5, -34 },
  { 3521, 28, 19, 38, 5, -29 },
  { 3588, 28, 29, 38, 5, -34 },
  { 3690, 28, 45, 38, 5, -45 },
  { 3848, 35, 45, 38, 1, -45 },
  { 4045, 35, 45, 38, 2, -45 },
  { 4242, 31, 45, 38, 5, -45 },
  { 4417, 32, 46, 38, 3, -45 },
  { 4601, 31, 45, 38, 4, -45 },
  { 4776, 29, 45, 38, 5, -45 },
  { 4940, 29, 45, 38, 5, -45 },
  { 5104, 32, 46, 38, 3, -45 },
  { 5288, 30, 45, 38, 4, -45 },
  { 5457, 26, 45, 38, 6, -45 },
  { 5604, 30, 46, 38, 3, -45 },
  { 5777, 33, 45, 38, 5, -45 },
  { 5963, 29, 45, 38, 5, -45 },
  { 6127, 30, 45, 38, 4, -45 },
  { 6296, 30, 45, 38, 4, -45 },
  { 6465, 32, 46, 38, 3, -45 },
  { 6649, 31, 45, 38, 5, -45 },
  { 6824, 34, 53, 38, 3, -45 },
  { 7050, 31, 45, 38, 5, -45 },
  { 7225, 32, 46, 38, 3, -45 },
  { 7409, 35, 45, 38, 1, -45 },
  { 7606, 30, 46, 38, 4, -45 },
  { 7779, 35, 45, 38, 1, -45 },
  { 7976, 36, 45, 38, 1, -45 },
  { 8179, 35, 45, 38, 2, -45 },
  { 8376, 36, 45, 38, 1, -45 },
  { 8579, 32, 45, 38, 3, -45 },
  { 8759, 13, 62, 38, 13, -52 },
  { 8860, 25, 49, 38, 7, -45 },
  { 9014, 14, 62, 38, 12, -52 },
  { 9123, 25, 24, 38, 7, -45 },
  { 9198, 28, 6, 38, 5, 0 },
  { 9219, 13, 9, 38, 13, -46 },
  { 9234, 30, 35, 38, 4, -34 },
  { 9366, 29, 48, 38, 5, -47 },
  { 9540, 29, 35, 38, 4, -34 },
  { 9667, 29, 48, 38, 4, -47 },
  { 9841, 30, 35, 38, 4, -34 },
  { 9973, 31, 49, 38, 4, -49 },
  { 10163, 29, 47, 38, 4, -34 },
  { 10334, 29, 47, 38, 5, -47 },
  { 10505, 28, 46, 38, 6, -46 },
  { 10666, 20, 59, 38, 7, -46 },
  { 10814, 31, 47, 38, 5, -47 },
  { 10997, 28, 47, 38, 6, -47 },
  { 11162, 32, 34, 38, 3, -34 },
  { 11298, 29, 34, 38, 5, -34 },
  { 11422, 31, 35, 38, 3, -34 },
  { 11558, 29, 47, 38, 5, -34 },
  { 11729, 29, 47, 38, 4, -34 },
  { 11900, 25, 34, 38, 9, -34 },
  { 12007, 30, 35, 38, 4, -34 },
  { 12139, 29, 42, 38, 4, -41 },
  { 12292, 28, 34, 38, 5, -33 },
  { 12411, 32, 33, 38, 3, -33 },
  { 12543, 35, 33, 38, 1, -33 },
  { 12688, 33, 33, 38, 3, -33 },
  { 12825, 35, 46, 38, 2, -33 },
  { 13027, 30, 33, 38, 4, -33 },
  { 13151, 20, 60, 38, 10, -49 },
  { 13301, 6, 57, 38, 16, -45 },
  { 13344, 21, 60, 38, 10, -49 },
  { 13502, 35, 13, 38, 1, -25 },
};

const GFXfont RobotoMono_Medium63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium63pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_MEDIUM63PT7B_H_
