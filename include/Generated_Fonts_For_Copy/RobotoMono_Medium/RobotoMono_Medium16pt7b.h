#ifndef _ROBOTOMONO_MEDIUM16PT7B_H_
#define _ROBOTOMONO_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x09, 0x0D, 0x84, 0xCF, 0xF1,
  0x20, 0x90, 0xD9, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x08, 0x18, 0x7E, 0x66,
  0x43, 0x60, 0x70, 0x3C, 0x06, 0x03, 0xC3, 0x66, 0x3E, 0x18, 0x18, 0x20,
  0x38, 0x36, 0xDB, 0x47, 0x40, 0x20, 0x20, 0x16, 0x16, 0x9A, 0x41, 0x20,
  0xF0, 0x10, 0x3E, 0x1B, 0x08, 0x86, 0xC3, 0xC1, 0xC1, 0xB2, 0xCF, 0x67,
  0xB3, 0x8F, 0x70, 0xF0, 0x13, 0x64, 0xCC, 0xC8, 0x88, 0xCC, 0xC4, 0x63,
  0x10, 0x46, 0x08, 0x63, 0x08, 0x63, 0x18, 0xC6, 0x23, 0x19, 0x88, 0x80,
  0x18, 0x18, 0xEB, 0x7E, 0x18, 0x34, 0x66, 0x04, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0xFF, 0x80, 0xFF, 0xF0, 0xF0, 0x0C, 0x21, 0x86,
  0x10, 0xC3, 0x18, 0x61, 0x0C, 0x30, 0x10, 0x7C, 0x66, 0xC2, 0xC7, 0xCF,
  0xDB, 0xE3, 0xC2, 0xC6, 0x66, 0x3C, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x10, 0xFB, 0x1E, 0x30, 0x61, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0,
  0x10, 0xFB, 0x1E, 0x30, 0x67, 0x8F, 0x03, 0x07, 0x8F, 0xBB, 0xE0, 0x0C,
  0x1C, 0x1C, 0x3C, 0x6C, 0x4C, 0xCC, 0xFF, 0x0C, 0x0C, 0x0C, 0x7E, 0x60,
  0x60, 0x40, 0x7E, 0xC6, 0x03, 0x03, 0xC2, 0x66, 0x3C, 0x3C, 0xE1, 0x86,
  0x4F, 0xF8, 0xF0, 0xE1, 0xC6, 0xDC, 0xF0, 0xFF, 0x06, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x10, 0x7E, 0x66, 0xC6, 0xC6, 0x7E,
  0x7C, 0xC6, 0xC3, 0xC3, 0xE6, 0x7C, 0x10, 0xFB, 0x1E, 0x3C, 0x78, 0xF9,
  0xBF, 0x06, 0x0C, 0xF1, 0xC0, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x06, 0xDB,
  0x40, 0x02, 0x1C, 0xF7, 0x8E, 0x07, 0x83, 0x81, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x81, 0xC1, 0xE0, 0x70, 0xEF, 0xB8, 0x40, 0x18, 0xFF, 0x98, 0x10,
  0x61, 0xC7, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x1F, 0x10, 0x93, 0xAB, 0x55,
  0x2E, 0x97, 0x5A, 0xBE, 0x4A, 0x31, 0x0F, 0x80, 0x0C, 0x0E, 0x07, 0x83,
  0xC1, 0x21, 0x98, 0xCC, 0x7E, 0x61, 0xB0, 0xF0, 0x60, 0xFE, 0xC7, 0xC3,
  0xC3, 0xFE, 0xFE, 0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0x18, 0x7E, 0xE6, 0xC3,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0x66, 0x3C, 0xFC, 0xCE, 0xC6, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0xF8, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE,
  0xFE, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x10, 0x7E, 0xE6, 0xC3, 0xC0, 0xC0, 0xCF,
  0xCF, 0xC3, 0xC3, 0x67, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19,
  0xFF, 0xF8, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xC7, 0xDD, 0xF0,
  0xC7, 0x63, 0x33, 0x1B, 0x0F, 0x87, 0xC3, 0xB1, 0x98, 0xC6, 0x63, 0xB0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xE7, 0xE7, 0xEF, 0xFF, 0xFB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0xE3, 0xF3, 0xD3, 0xDB, 0xCB, 0xCF, 0xCF, 0xC7, 0xC7, 0x10, 0x7C,
  0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x6E, 0x3C, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC3, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0x10, 0x7C, 0xE6,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x6E, 0x3E, 0x07, 0x01, 0xFE,
  0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xCC, 0xC6, 0xC6, 0xC3, 0x08, 0x7E,
  0xC7, 0xC3, 0xC0, 0x70, 0x3E, 0x07, 0x03, 0xC3, 0xE7, 0x3E, 0xFF, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x6E, 0x3C, 0xE1, 0xB0,
  0xD8, 0xC4, 0x63, 0x31, 0x90, 0xD8, 0x3C, 0x1C, 0x0E, 0x03, 0x00, 0xCC,
  0xA6, 0xD3, 0x6F, 0xB7, 0xDB, 0xFD, 0xDC, 0xEE, 0x33, 0x19, 0x8C, 0xC0,
  0x61, 0x99, 0x8C, 0xC3, 0xC1, 0xC0, 0x60, 0x78, 0x6C, 0x33, 0x31, 0xF8,
  0x60, 0xE1, 0xB1, 0x8C, 0xC6, 0x41, 0xE0, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xFF, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xFF,
  0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x06, 0x18,
  0x20, 0xC3, 0x04, 0x18, 0x60, 0xC3, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x7F,
  0x31, 0xC7, 0x92, 0xCE, 0x30, 0xFE, 0xC6, 0x30, 0x18, 0x7E, 0xC6, 0x06,
  0x7E, 0xC6, 0xC6, 0xEE, 0x7F, 0xC0, 0xC0, 0xC0, 0xD8, 0xFE, 0xC6, 0xC3,
  0xC3, 0xC3, 0xC2, 0xE6, 0xFC, 0x18, 0xFF, 0x1E, 0x1C, 0x18, 0x30, 0xB3,
  0x3C, 0x06, 0x0C, 0x19, 0xB7, 0xF8, 0xF1, 0xE3, 0xC7, 0x8D, 0xBB, 0xD0,
  0x18, 0x7E, 0xE6, 0xC3, 0xFF, 0xC0, 0xC0, 0x67, 0x3E, 0x1F, 0x18, 0x30,
  0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0xFF, 0x9E,
  0x1C, 0x38, 0x70, 0xB3, 0x7A, 0x0F, 0x1B, 0xE0, 0xC0, 0xC0, 0xC0, 0xC8,
  0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x10, 0x60, 0x00, 0x0F,
  0x06, 0x0C, 0x18, 0x30, 0x63, 0xFF, 0xF0, 0x10, 0xC0, 0x0F, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x9B, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0xCE, 0xCC, 0xD8,
  0xF8, 0xF8, 0xCC, 0xC6, 0xC7, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x63, 0xFF, 0xF0, 0x36, 0xFF, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B,
  0x9B, 0x0C, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x18, 0x7E,
  0xC6, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0x18, 0xFE, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC6, 0xE6, 0xFC, 0xC0, 0xC0, 0xC0, 0x30, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xB3, 0x7E, 0x0C, 0x18, 0x30, 0x0F, 0xBB, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0x18, 0x7E, 0xC7, 0xE0, 0x7C, 0x0E, 0xC3, 0xE6, 0x7C, 0x30,
  0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x74, 0x78, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x5B, 0xBD, 0xC3, 0xC6, 0x66, 0x64, 0x2C, 0x3C, 0x38, 0x18,
  0xCD, 0xA6, 0xD3, 0x6F, 0xB7, 0x53, 0xB8, 0xCC, 0x66, 0xE7, 0x66, 0x3C,
  0x18, 0x3C, 0x3C, 0x66, 0xC3, 0xE1, 0xB0, 0xCC, 0xC6, 0x61, 0xE0, 0xF0,
  0x30, 0x18, 0x08, 0x0C, 0x1C, 0x00, 0xFE, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xFF, 0x1C, 0x41, 0x04, 0x10, 0xCF, 0x38, 0x30, 0xC1, 0x04, 0x10,
  0x60, 0xC0, 0xFF, 0xFC, 0xC2, 0x18, 0xC6, 0x30, 0xE7, 0x63, 0x18, 0xC6,
  0x62, 0x00, 0x78, 0xE7, 0xD1, 0xC0,
};

const GFXglyph RobotoMono_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 5, 4, 10, 2, -12 },
  { 7, 9, 11, 10, 0, -11 },
  { 20, 8, 15, 10, 1, -13 },
  { 35, 9, 12, 10, 0, -12 },
  { 49, 9, 12, 10, 1, -12 },
  { 63, 1, 4, 10, 4, -12 },
  { 64, 4, 17, 10, 3, -13 },
  { 73, 5, 17, 10, 2, -13 },
  { 84, 8, 8, 10, 1, -11 },
  { 92, 8, 8, 10, 1, -9 },
  { 100, 2, 5, 10, 3, -2 },
  { 102, 6, 2, 10, 2, -6 },
  { 104, 2, 2, 10, 4, -2 },
  { 105, 6, 12, 10, 2, -11 },
  { 114, 8, 12, 10, 1, -12 },
  { 126, 5, 11, 10, 1, -11 },
  { 133, 7, 12, 10, 1, -12 },
  { 144, 7, 12, 10, 1, -12 },
  { 155, 8, 11, 10, 1, -11 },
  { 166, 8, 11, 10, 1, -11 },
  { 177, 7, 11, 10, 1, -11 },
  { 187, 8, 11, 10, 1, -11 },
  { 198, 8, 12, 10, 1, -12 },
  { 210, 7, 12, 10, 1, -12 },
  { 221, 2, 9, 10, 4, -9 },
  { 224, 3, 12, 10, 4, -9 },
  { 229, 7, 8, 10, 1, -9 },
  { 236, 8, 5, 10, 1, -7 },
  { 241, 7, 8, 10, 1, -9 },
  { 248, 7, 12, 10, 1, -12 },
  { 259, 9, 11, 10, 0, -11 },
  { 272, 9, 11, 10, 0, -11 },
  { 285, 8, 11, 10, 1, -11 },
  { 296, 8, 12, 10, 1, -12 },
  { 308, 8, 11, 10, 1, -11 },
  { 319, 8, 11, 10, 1, -11 },
  { 330, 8, 11, 10, 1, -11 },
  { 341, 8, 12, 10, 1, -12 },
  { 353, 8, 11, 10, 1, -11 },
  { 364, 7, 11, 10, 1, -11 },
  { 374, 7, 11, 10, 1, -11 },
  { 384, 9, 11, 10, 1, -11 },
  { 397, 8, 11, 10, 1, -11 },
  { 408, 8, 11, 10, 1, -11 },
  { 419, 8, 11, 10, 1, -11 },
  { 430, 8, 12, 10, 1, -12 },
  { 442, 8, 11, 10, 1, -11 },
  { 453, 8, 14, 10, 1, -12 },
  { 467, 8, 11, 10, 1, -11 },
  { 478, 8, 12, 10, 1, -12 },
  { 490, 9, 11, 10, 0, -11 },
  { 503, 8, 11, 10, 1, -11 },
  { 514, 9, 11, 10, 0, -11 },
  { 527, 9, 11, 10, 0, -11 },
  { 540, 9, 11, 10, 0, -11 },
  { 553, 9, 11, 10, 0, -11 },
  { 566, 8, 11, 10, 1, -11 },
  { 577, 4, 16, 10, 3, -13 },
  { 585, 6, 12, 10, 2, -11 },
  { 594, 3, 16, 10, 3, -13 },
  { 600, 6, 6, 10, 2, -11 },
  { 605, 7, 1, 10, 1, 0 },
  { 606, 4, 3, 10, 3, -12 },
  { 608, 8, 9, 10, 1, -9 },
  { 617, 8, 12, 10, 1, -12 },
  { 629, 7, 9, 10, 1, -9 },
  { 637, 7, 12, 10, 1, -12 },
  { 648, 8, 9, 10, 1, -9 },
  { 657, 8, 12, 10, 1, -12 },
  { 669, 7, 12, 10, 1, -9 },
  { 680, 8, 12, 10, 1, -12 },
  { 692, 7, 12, 10, 2, -12 },
  { 703, 5, 15, 10, 2, -12 },
  { 713, 8, 12, 10, 1, -12 },
  { 725, 7, 12, 10, 2, -12 },
  { 736, 8, 9, 10, 1, -9 },
  { 745, 8, 9, 10, 1, -9 },
  { 754, 8, 9, 10, 1, -9 },
  { 763, 8, 12, 10, 1, -9 },
  { 775, 7, 12, 10, 1, -9 },
  { 786, 7, 9, 10, 2, -9 },
  { 794, 8, 9, 10, 1, -9 },
  { 803, 7, 11, 10, 1, -11 },
  { 813, 7, 8, 10, 1, -8 },
  { 820, 8, 8, 10, 1, -8 },
  { 828, 9, 8, 10, 0, -8 },
  { 837, 8, 8, 10, 1, -8 },
  { 845, 9, 11, 10, 0, -8 },
  { 858, 8, 8, 10, 1, -8 },
  { 866, 6, 15, 10, 2, -12 },
  { 878, 1, 14, 10, 4, -11 },
  { 880, 5, 15, 10, 3, -12 },
  { 890, 9, 3, 10, 0, -6 },
};

const GFXfont RobotoMono_Medium16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium16pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_MEDIUM16PT7B_H_
