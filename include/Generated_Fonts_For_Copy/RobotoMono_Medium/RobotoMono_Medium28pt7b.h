#ifndef _ROBOTOMONO_MEDIUM28PT7B_H_
#define _ROBOTOMONO_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x27, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x70, 0x18,
  0xC0, 0x31, 0x80, 0xE3, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x0C, 0x60,
  0x38, 0xC0, 0x71, 0x80, 0xC7, 0x01, 0x8E, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x1F, 0x83, 0xFF, 0x3F, 0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0xF7, 0xDF, 0x9F, 0xF8, 0x7F, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0x18, 0x86, 0x31, 0x8C, 0x67,
  0x18, 0xCC, 0x3B, 0xB8, 0x3E, 0x60, 0x11, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x67, 0xC1, 0xDF, 0xC3, 0x31, 0x8E, 0x63, 0x18, 0xC6, 0x01,
  0x8C, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x38,
  0x70, 0x38, 0x70, 0x38, 0x60, 0x3C, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0x00, 0x3F, 0x00, 0x7F, 0x8E, 0x73, 0xCE, 0xF1, 0xEE, 0xF0, 0xFC, 0xF0,
  0xFC, 0xF0, 0x78, 0x7D, 0xFC, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xFF, 0xF8,
  0x06, 0x1C, 0x70, 0xC3, 0x86, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x30, 0x40, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x70, 0xE0, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x63, 0x1B, 0xED, 0xE7, 0xFF, 0xC1, 0xF0, 0x07, 0x80, 0x37, 0x01, 0xCE,
  0x0E, 0x38, 0x38, 0x70, 0x41, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x77, 0x77, 0x77, 0xEC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0x7C, 0xE0, 0xEF, 0x07, 0x70, 0x3F,
  0x81, 0xFC, 0x1F, 0xE1, 0xFF, 0x1D, 0xFB, 0xCF, 0xF8, 0x7F, 0x83, 0xF8,
  0x1F, 0x81, 0xFE, 0x0F, 0x70, 0x73, 0xEF, 0x8F, 0xF8, 0x3F, 0x80, 0x01,
  0x0F, 0x7F, 0xFF, 0xF7, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x1C, 0x1E, 0xF0, 0x3B, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1C,
  0x1E, 0x70, 0x3A, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xF0, 0x1F, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFC, 0x0E, 0x70, 0x39,
  0xF3, 0xE3, 0xFF, 0x07, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0xE1, 0xC3, 0x87,
  0x1C, 0x1C, 0x70, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8C, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xFC, 0x0F, 0xF0, 0x7B, 0xEF, 0x8F, 0xF8, 0x3F,
  0x80, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0xF8, 0xFF, 0xE7, 0xFF, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xF0, 0x73, 0xEF, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1F, 0xC1, 0xFF,
  0x1F, 0x7C, 0xE0, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xCE, 0x0E, 0x7F, 0xE0,
  0xFE, 0x0F, 0xF8, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x7B, 0xEF, 0x9F, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xE1,
  0xEE, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x3E,
  0xFF, 0xE3, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0xFE, 0x07,
  0xE0, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x79,
  0xF7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x9E, 0x79,
  0xC7, 0x18, 0xE0, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFE, 0x7F, 0x8F, 0xC0,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xE0, 0x7F, 0x1F, 0xC7, 0xF8, 0x3F, 0x01, 0xC0, 0x08, 0x00, 0x00,
  0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xFF, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x1F,
  0xE0, 0x70, 0xE1, 0x80, 0x67, 0x08, 0xCC, 0x7C, 0xF9, 0xD9, 0xE7, 0x33,
  0xCC, 0x67, 0x98, 0xCF, 0x31, 0x9E, 0x63, 0x3C, 0xC4, 0x59, 0x9D, 0xB3,
  0xFE, 0x71, 0x18, 0x60, 0x00, 0xE0, 0x40, 0xFF, 0x80, 0x7E, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE1, 0xC3, 0x83, 0x87,
  0xFF, 0x1F, 0xFF, 0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x00,
  0x70, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0xB8, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x1D, 0xC0, 0x7F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x01, 0xDC, 0x07, 0x78, 0x3C, 0xFB, 0xE1, 0xFF, 0x03, 0xF8, 0xFF,
  0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xEE,
  0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F, 0x78,
  0x1D, 0xC0, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x78, 0x1C, 0xF9, 0xF1,
  0xFF, 0x83, 0xFC, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x03, 0xDC, 0x0F, 0x70, 0x39, 0xFF, 0xE3,
  0xFF, 0x07, 0xF0, 0xE0, 0x3D, 0xC0, 0xF3, 0x81, 0xE7, 0x07, 0x8E, 0x1E,
  0x1C, 0x78, 0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xDC, 0x0F, 0x3C, 0x1E, 0x3C, 0x38, 0x78, 0x70, 0x78, 0xE0, 0x79, 0xC0,
  0xF3, 0x80, 0xF7, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0xFF,
  0xF7, 0xFD, 0xB7, 0xEF, 0xBF, 0x7D, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFD, 0xC7,
  0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xDF, 0x87, 0xFC,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xC7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0x9C, 0x07,
  0x38, 0x1E, 0x78, 0x38, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x3B, 0xC3, 0xEF, 0xFF, 0x3F, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xC1, 0xC7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x1E,
  0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x87, 0xCF, 0xFE,
  0x3F, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81,
  0xEE, 0x03, 0xB8, 0x0F, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7,
  0x01, 0xEE, 0x03, 0xDE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x1C,
  0x7C, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x73,
  0xEF, 0x8F, 0xF8, 0x3F, 0x80, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0x80,
  0xE7, 0x03, 0xCF, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x3C, 0x78, 0x38, 0xE0,
  0x71, 0xC0, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E,
  0x3F, 0x1C, 0x7E, 0x78, 0xFC, 0xF9, 0xF9, 0xF3, 0xBB, 0x6E, 0x76, 0xDC,
  0xED, 0xB9, 0xDB, 0x73, 0xF7, 0xE7, 0xEF, 0xCF, 0x8F, 0x9F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xC1, 0xC0, 0xF0, 0x1E, 0xE0,
  0x39, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDE, 0x07,
  0x9C, 0x1E, 0x3C, 0x38, 0x38, 0xF0, 0x79, 0xC0, 0x7F, 0x80, 0xF0, 0xE0,
  0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x07, 0x1C,
  0x0F, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xFE, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0E, 0x01, 0xC0,
  0x7C, 0x0D, 0x81, 0xB8, 0x77, 0x0C, 0x63, 0x8E, 0x71, 0xDC, 0x1F, 0x83,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xC3, 0x87, 0x1F, 0x81, 0xFF,
  0x1F, 0xFD, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xCF, 0xFE, 0xF0, 0x77,
  0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x9F, 0x3F, 0xFC, 0xFD, 0xE0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x1D, 0xFC, 0xFF,
  0xF7, 0x83, 0xB8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7F, 0x83, 0xFF, 0x7D, 0xFF, 0xCE, 0xFC, 0x00, 0x0F, 0x81, 0xFF,
  0x1F, 0xFC, 0xE0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x0F, 0xE0, 0xF7, 0xCF, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x7D, 0xE7, 0xFF, 0x7F,
  0xFF, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xDF, 0x7E, 0x7F, 0xF1, 0xF3, 0x80, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xE0, 0xEF, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x01, 0xE0, 0x27, 0xCF, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x70,
  0x0F, 0xF0, 0x7F, 0x83, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xF7, 0xDF, 0x9F, 0xFC,
  0x7D, 0xE0, 0x0F, 0x20, 0x73, 0x07, 0x9F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x1D,
  0xFE, 0xFF, 0xF7, 0x83, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0x0F,
  0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x03, 0xFD,
  0xFE, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1D, 0xFE, 0xFE, 0x7C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xB8,
  0x3C, 0xE1, 0xE3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x3C, 0xF0, 0xE1, 0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x3C,
  0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x79, 0xFF, 0xFB,
  0xFF, 0xF7, 0x1C, 0xFE, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3,
  0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3,
  0x80, 0xE7, 0xC7, 0x7F, 0xBF, 0xFD, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xE0, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xE0, 0xEE, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE0, 0xE7, 0xDF, 0x1F,
  0xF0, 0x7F, 0x00, 0xE7, 0xC7, 0xFF, 0x3F, 0xFD, 0xE0, 0xEE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE0, 0xEF, 0x9F,
  0x7F, 0xF3, 0xBF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xF7, 0xDF, 0x9F,
  0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0xE3, 0xFD, 0xFF, 0xFF, 0xFE, 0x1F, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0xC1,
  0xFF, 0x1F, 0x7C, 0xE0, 0xFF, 0x03, 0xB8, 0x01, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x77, 0x87, 0xBF, 0xF8, 0x7F, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0x81, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xF7, 0x0F, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xF7, 0xDF, 0xBF, 0xDC, 0xFC, 0xE0, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xF3,
  0xC1, 0xC3, 0x83, 0x87, 0x0F, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF1,
  0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x73, 0xC6, 0x33, 0xEE, 0x33,
  0x6E, 0x3B, 0x6E, 0x3B, 0x6E, 0x3E, 0x6C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x70, 0x1E, 0xF0, 0x78, 0xF0, 0xE0, 0xE3,
  0x80, 0xEF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x3B, 0xC0, 0xE3, 0x83, 0xC3, 0x8F, 0x07, 0xBC, 0x07, 0x80, 0xF0, 0x0F,
  0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x07, 0x1E, 0x0E,
  0x38, 0x1E, 0x70, 0x1D, 0xC0, 0x3B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0x8F, 0xC7, 0x83, 0xE0, 0x38, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x1C, 0x0B, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0F,
  0xC0, 0xF0, 0x7C, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x3C, 0x06, 0x00, 0x3E, 0x00, 0x7F, 0x87, 0x7F, 0xC7,
  0x61, 0xFE, 0xE0, 0xFC, 0x00, 0x38,
};

const GFXglyph RobotoMono_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 6, -20 },
  { 11, 8, 7, 17, 4, -21 },
  { 18, 15, 20, 17, 1, -20 },
  { 56, 13, 26, 17, 2, -23 },
  { 99, 15, 20, 17, 1, -20 },
  { 137, 16, 20, 17, 1, -20 },
  { 177, 3, 7, 17, 6, -21 },
  { 180, 7, 28, 17, 5, -22 },
  { 205, 8, 28, 17, 4, -22 },
  { 233, 14, 14, 17, 2, -20 },
  { 258, 14, 14, 17, 1, -16 },
  { 283, 4, 8, 17, 5, -3 },
  { 287, 12, 3, 17, 3, -10 },
  { 292, 5, 4, 17, 6, -4 },
  { 295, 11, 22, 17, 3, -20 },
  { 326, 13, 20, 17, 2, -20 },
  { 359, 8, 20, 17, 3, -20 },
  { 379, 14, 20, 17, 1, -20 },
  { 414, 14, 20, 17, 1, -20 },
  { 449, 14, 20, 17, 1, -20 },
  { 484, 13, 20, 17, 2, -20 },
  { 517, 13, 20, 17, 2, -20 },
  { 550, 14, 20, 17, 1, -20 },
  { 585, 13, 20, 17, 2, -20 },
  { 618, 13, 20, 17, 2, -20 },
  { 651, 4, 16, 17, 7, -16 },
  { 659, 6, 21, 17, 6, -16 },
  { 675, 12, 13, 17, 2, -15 },
  { 695, 13, 9, 17, 2, -13 },
  { 710, 13, 13, 17, 2, -15 },
  { 732, 13, 20, 17, 2, -20 },
  { 765, 15, 20, 17, 1, -20 },
  { 803, 15, 20, 17, 1, -20 },
  { 841, 14, 20, 17, 2, -20 },
  { 876, 14, 20, 17, 1, -20 },
  { 911, 14, 20, 17, 2, -20 },
  { 946, 13, 20, 17, 2, -20 },
  { 979, 13, 20, 17, 2, -20 },
  { 1012, 14, 20, 17, 1, -20 },
  { 1047, 13, 20, 17, 2, -20 },
  { 1080, 11, 20, 17, 3, -20 },
  { 1108, 14, 20, 17, 1, -20 },
  { 1143, 15, 20, 17, 2, -20 },
  { 1181, 13, 20, 17, 2, -20 },
  { 1214, 13, 20, 17, 2, -20 },
  { 1247, 13, 20, 17, 2, -20 },
  { 1280, 15, 20, 17, 1, -20 },
  { 1318, 14, 20, 17, 2, -20 },
  { 1353, 15, 23, 17, 1, -20 },
  { 1397, 14, 20, 17, 2, -20 },
  { 1432, 15, 20, 17, 1, -20 },
  { 1470, 15, 20, 17, 1, -20 },
  { 1508, 13, 20, 17, 2, -20 },
  { 1541, 15, 20, 17, 1, -20 },
  { 1579, 15, 20, 17, 1, -20 },
  { 1617, 15, 20, 17, 1, -20 },
  { 1655, 15, 20, 17, 1, -20 },
  { 1693, 14, 20, 17, 1, -20 },
  { 1728, 5, 27, 17, 6, -23 },
  { 1745, 11, 22, 17, 3, -20 },
  { 1776, 6, 27, 17, 5, -23 },
  { 1797, 11, 11, 17, 3, -20 },
  { 1813, 13, 3, 17, 2, 0 },
  { 1818, 6, 4, 17, 6, -20 },
  { 1821, 13, 15, 17, 2, -15 },
  { 1846, 13, 21, 17, 2, -21 },
  { 1881, 13, 15, 17, 2, -15 },
  { 1906, 13, 21, 17, 2, -21 },
  { 1941, 13, 15, 17, 2, -15 },
  { 1966, 14, 22, 17, 2, -22 },
  { 2005, 13, 21, 17, 2, -15 },
  { 2040, 13, 21, 17, 2, -21 },
  { 2075, 12, 20, 17, 3, -20 },
  { 2105, 9, 26, 17, 3, -20 },
  { 2135, 14, 21, 17, 2, -21 },
  { 2172, 12, 21, 17, 3, -21 },
  { 2204, 15, 15, 17, 1, -15 },
  { 2233, 13, 15, 17, 2, -15 },
  { 2258, 13, 15, 17, 2, -15 },
  { 2283, 13, 21, 17, 2, -15 },
  { 2318, 13, 21, 17, 2, -15 },
  { 2353, 11, 15, 17, 4, -15 },
  { 2374, 13, 15, 17, 2, -15 },
  { 2399, 13, 18, 17, 2, -18 },
  { 2429, 13, 15, 17, 2, -15 },
  { 2454, 15, 15, 17, 1, -15 },
  { 2483, 16, 15, 17, 0, -15 },
  { 2513, 15, 15, 17, 1, -15 },
  { 2542, 15, 21, 17, 1, -15 },
  { 2582, 13, 15, 17, 2, -15 },
  { 2607, 9, 27, 17, 4, -22 },
  { 2638, 3, 26, 17, 7, -20 },
  { 2648, 10, 27, 17, 4, -22 },
  { 2682, 16, 6, 17, 0, -11 },
};

const GFXfont RobotoMono_Medium28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium28pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_MEDIUM28PT7B_H_
