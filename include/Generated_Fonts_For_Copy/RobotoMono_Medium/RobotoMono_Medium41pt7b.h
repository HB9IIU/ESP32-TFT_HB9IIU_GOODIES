#ifndef _ROBOTOMONO_MEDIUM41PT7B_H_
#define _ROBOTOMONO_MEDIUM41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0x78, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0,
  0xEE, 0x0E, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x70,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xF0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xC0, 0xFD, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xDE, 0x00, 0x0E, 0x1E, 0x08, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x71, 0xC0, 0xE1, 0xE3, 0x81, 0xE3, 0xCE, 0x03, 0xFF, 0x3C,
  0x03, 0xFE, 0x70, 0x03, 0xF1, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x8F, 0xC0,
  0x07, 0x3F, 0xE0, 0x1C, 0xFF, 0xC0, 0x79, 0xC3, 0xC0, 0xE3, 0x87, 0x83,
  0xC7, 0x0F, 0x07, 0x0E, 0x1E, 0x06, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x3C,
  0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x7C, 0xFF, 0xE1, 0xF7, 0xCF, 0xC7,
  0xBE, 0x1F, 0x1E, 0xF8, 0x3E, 0x7B, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E,
  0x03, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x87, 0xF7, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFE, 0xF8, 0x3F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x40, 0x18, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x08, 0x40,
  0x0C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04, 0x07, 0x02,
  0x70, 0x70, 0xE7, 0xE7, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0xC0, 0x07, 0x9E, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x0E, 0x07, 0x00, 0x40, 0x20, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C,
  0xF3, 0xE3, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xF3, 0xF8, 0xF8, 0x1F,
  0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x3E, 0xFF, 0xCF, 0x9F,
  0xFB, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF8,
  0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x30,
  0x1F, 0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xBF, 0x87, 0xC0, 0xFC, 0xF8, 0x07, 0xCF,
  0x80, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xFE,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F,
  0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0x80,
  0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF7, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0xFE, 0x07, 0xBF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7,
  0xE0, 0x3E, 0x3E, 0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xF3, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x7F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xC1, 0xF1, 0xF0,
  0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xF9, 0xFE, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFB, 0xF8, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x78,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x3F, 0x3F, 0x9F, 0xE7, 0xFF, 0xFC, 0x7F,
  0xF7, 0x83, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0x80, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xFF, 0x9F,
  0x00, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0xF8, 0x70, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x38, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFB, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xE0, 0x7C, 0x0E, 0x00, 0x70, 0x70, 0x00, 0xE3, 0xC1, 0xE1,
  0x8E, 0x1F, 0xE7, 0x70, 0xFF, 0x9D, 0xC7, 0x8E, 0x77, 0x1C, 0x30, 0xD8,
  0xF0, 0xC3, 0xE3, 0x83, 0x0F, 0x8E, 0x1C, 0x3E, 0x38, 0x70, 0xF8, 0xE1,
  0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xB8, 0xF3, 0xCE,
  0xF3, 0xFF, 0xF1, 0xC7, 0xEF, 0xC7, 0x06, 0x1C, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x04, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFD, 0xFE, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8,
  0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x8F, 0x80, 0xFC,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x3F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0x81, 0xF1, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xF9, 0xF8, 0x0F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xF8,
  0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03,
  0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF9, 0xF0,
  0x0F, 0xC7, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xF7,
  0x1D, 0xFE, 0xE7, 0xBF, 0xDE, 0xF7, 0xFB, 0xDC, 0xFF, 0x3F, 0x9F, 0xE7,
  0xF3, 0xFC, 0xFC, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3C, 0x3F, 0xC3,
  0x87, 0xF8, 0x70, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFE, 0xF0,
  0x7F, 0xDF, 0x0F, 0xF9, 0xE1, 0xFF, 0x3C, 0x3F, 0xE3, 0xC7, 0xFC, 0x78,
  0xFF, 0x87, 0x9F, 0xF0, 0xF3, 0xFE, 0x0F, 0x7F, 0xC1, 0xEF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xF8, 0x1F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x80,
  0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFC,
  0xFE, 0x1F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x3F, 0xF0, 0xF0, 0x7F, 0xE1, 0xF0,
  0xFF, 0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3F, 0x0F,
  0x3C, 0x7E, 0x1E, 0x78, 0xFE, 0x7C, 0xF1, 0xFC, 0xF9, 0xF3, 0xB9, 0xF3,
  0xE7, 0x73, 0xC3, 0xCE, 0xE7, 0x87, 0xBD, 0xCF, 0x0F, 0x7B, 0xDE, 0x1E,
  0xE7, 0xBC, 0x3D, 0xCF, 0x78, 0x7B, 0x8F, 0xF0, 0xF7, 0x1F, 0xE1, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF0, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xF8, 0x03,
  0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xF3, 0xF0, 0x03,
  0xEF, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0,
  0x7B, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0xDF,
  0x01, 0xFB, 0xFD, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xC7, 0xC0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x83,
  0xEF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x1F, 0xBF, 0x01, 0xF7,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xF0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF7, 0xFE, 0x3E,
  0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xCF, 0x80, 0xF8, 0xFE, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7E, 0x3C, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE,
  0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFB, 0xC1, 0xFE, 0x78, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x00, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x43, 0xF0, 0x1E, 0x1F, 0xEF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFC, 0x30, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xF1, 0xF0, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x07,
  0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x10, 0x03, 0xE1, 0xC0, 0x7E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x1F, 0xC3, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0,
  0xFC, 0xFF, 0xEF, 0xFE, 0x7F, 0xE1, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x0F, 0xCF,
  0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80,
  0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x03, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF3, 0xE3, 0xC7, 0xBF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x8F,
  0x8F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF,
  0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78,
  0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC,
  0x3C, 0x3F, 0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7C, 0xF0, 0xFE,
  0x1F, 0x3F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0xFD, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE3, 0xE0, 0x7E,
  0x3F, 0xDF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xF9, 0xFC,
  0x1F, 0x7F, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F,
  0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xFE, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xF3, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF1,
  0xE1, 0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xF0, 0x7E, 0xFC, 0x07,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0x7E, 0x03, 0xE7, 0xC0, 0xFC, 0xFF, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xDE,
  0x0F, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x7F,
  0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE7, 0xC0, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7D, 0xF8, 0x3F, 0x1F, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0x81, 0xFD, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xBE, 0x1F, 0xC7, 0xC0, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x3C, 0x03,
  0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x38, 0x3F, 0xE0, 0xF0,
  0x7F, 0xC1, 0xE0, 0xF7, 0xC3, 0xC1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x87,
  0x9E, 0x3F, 0x0F, 0x3C, 0x7E, 0x3C, 0x78, 0xFE, 0x78, 0xF1, 0xDC, 0xF0,
  0xF7, 0xB9, 0xE1, 0xEE, 0x73, 0xC3, 0xDC, 0xE7, 0x07, 0xB8, 0xFE, 0x0F,
  0x71, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0xFC, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x00, 0xFC,
  0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x07, 0xC1, 0xF0, 0x7C,
  0x07, 0xC7, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87,
  0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x7C,
  0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFE, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x80, 0x77, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xEE, 0x01, 0xFF, 0x00, 0x01, 0xF8,
};

const GFXglyph RobotoMono_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 29, 25, 9, -29 },
  { 23, 12, 10, 25, 6, -31 },
  { 38, 22, 29, 25, 1, -29 },
  { 118, 19, 38, 25, 3, -34 },
  { 209, 23, 30, 25, 1, -30 },
  { 296, 22, 30, 25, 2, -30 },
  { 379, 4, 11, 25, 9, -31 },
  { 385, 11, 42, 25, 7, -33 },
  { 443, 11, 42, 25, 6, -33 },
  { 501, 20, 20, 25, 3, -29 },
  { 551, 20, 21, 25, 2, -24 },
  { 604, 7, 13, 25, 7, -5 },
  { 616, 16, 4, 25, 5, -15 },
  { 624, 7, 6, 25, 9, -6 },
  { 630, 16, 32, 25, 5, -29 },
  { 694, 19, 30, 25, 3, -30 },
  { 766, 12, 29, 25, 4, -29 },
  { 810, 20, 30, 25, 2, -30 },
  { 885, 19, 30, 25, 2, -30 },
  { 957, 22, 29, 25, 1, -29 },
  { 1037, 19, 29, 25, 3, -29 },
  { 1106, 20, 29, 25, 2, -29 },
  { 1179, 20, 29, 25, 2, -29 },
  { 1252, 19, 30, 25, 3, -30 },
  { 1324, 19, 30, 25, 2, -30 },
  { 1396, 7, 23, 25, 10, -23 },
  { 1417, 8, 31, 25, 9, -23 },
  { 1448, 18, 19, 25, 3, -22 },
  { 1491, 19, 13, 25, 3, -19 },
  { 1522, 18, 19, 25, 3, -22 },
  { 1565, 19, 30, 25, 3, -30 },
  { 1637, 22, 29, 25, 1, -29 },
  { 1717, 23, 29, 25, 1, -29 },
  { 1801, 20, 29, 25, 3, -29 },
  { 1874, 21, 30, 25, 2, -30 },
  { 1953, 20, 29, 25, 3, -29 },
  { 2026, 19, 29, 25, 3, -29 },
  { 2095, 19, 29, 25, 3, -29 },
  { 2164, 21, 30, 25, 2, -30 },
  { 2243, 19, 29, 25, 3, -29 },
  { 2312, 17, 29, 25, 4, -29 },
  { 2374, 20, 29, 25, 2, -29 },
  { 2447, 22, 29, 25, 3, -29 },
  { 2527, 19, 29, 25, 3, -29 },
  { 2596, 19, 29, 25, 3, -29 },
  { 2665, 19, 29, 25, 3, -29 },
  { 2734, 21, 30, 25, 2, -30 },
  { 2813, 20, 29, 25, 3, -29 },
  { 2886, 22, 35, 25, 2, -30 },
  { 2983, 21, 29, 25, 3, -29 },
  { 3060, 21, 30, 25, 2, -30 },
  { 3139, 23, 29, 25, 1, -29 },
  { 3223, 19, 29, 25, 3, -29 },
  { 3292, 23, 29, 25, 1, -29 },
  { 3376, 23, 29, 25, 1, -29 },
  { 3460, 23, 29, 25, 1, -29 },
  { 3544, 23, 29, 25, 1, -29 },
  { 3628, 20, 29, 25, 2, -29 },
  { 3701, 9, 41, 25, 8, -34 },
  { 3748, 16, 32, 25, 5, -29 },
  { 3812, 9, 41, 25, 8, -34 },
  { 3859, 17, 15, 25, 4, -29 },
  { 3891, 18, 4, 25, 3, 0 },
  { 3900, 9, 6, 25, 8, -30 },
  { 3907, 19, 22, 25, 3, -22 },
  { 3960, 19, 31, 25, 3, -31 },
  { 4034, 19, 22, 25, 3, -22 },
  { 4087, 19, 31, 25, 2, -31 },
  { 4161, 20, 22, 25, 2, -22 },
  { 4216, 20, 32, 25, 3, -32 },
  { 4296, 20, 31, 25, 2, -22 },
  { 4374, 19, 31, 25, 3, -31 },
  { 4448, 18, 30, 25, 4, -30 },
  { 4516, 13, 39, 25, 4, -30 },
  { 4580, 20, 31, 25, 3, -31 },
  { 4658, 18, 31, 25, 4, -31 },
  { 4728, 21, 22, 25, 2, -22 },
  { 4786, 19, 22, 25, 3, -22 },
  { 4839, 20, 22, 25, 2, -22 },
  { 4894, 19, 30, 25, 3, -22 },
  { 4966, 19, 30, 25, 2, -22 },
  { 5038, 16, 22, 25, 6, -22 },
  { 5082, 19, 22, 25, 3, -22 },
  { 5135, 19, 27, 25, 3, -27 },
  { 5200, 19, 22, 25, 3, -22 },
  { 5253, 21, 22, 25, 2, -22 },
  { 5311, 23, 22, 25, 1, -22 },
  { 5375, 21, 22, 25, 2, -22 },
  { 5433, 23, 31, 25, 1, -22 },
  { 5523, 19, 22, 25, 3, -22 },
  { 5576, 14, 39, 25, 6, -32 },
  { 5645, 3, 37, 25, 11, -29 },
  { 5659, 13, 39, 25, 7, -32 },
  { 5723, 22, 8, 25, 1, -16 },
};

const GFXfont RobotoMono_Medium41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium41pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_MEDIUM41PT7B_H_
