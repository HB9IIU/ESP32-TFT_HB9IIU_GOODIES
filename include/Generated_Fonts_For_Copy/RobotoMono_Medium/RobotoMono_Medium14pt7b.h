#ifndef _ROBOTOMONO_MEDIUM14PT7B_H_
#define _ROBOTOMONO_MEDIUM14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0x99, 0x99, 0x12, 0x12, 0x16, 0x7F, 0x34, 0x24,
  0xFE, 0x24, 0x28, 0x68, 0x10, 0x21, 0xE3, 0x6C, 0x78, 0x1C, 0x0E, 0x07,
  0x8F, 0x33, 0xE1, 0x00, 0x70, 0x96, 0x94, 0x74, 0x08, 0x18, 0x17, 0x29,
  0x29, 0x07, 0x78, 0x93, 0x22, 0xC7, 0x1E, 0x67, 0xC7, 0xCC, 0xFC, 0xFA,
  0x12, 0x64, 0x4C, 0xCC, 0xC4, 0x46, 0x21, 0x84, 0x62, 0x33, 0x33, 0x33,
  0x22, 0x48, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x91, 0x00, 0x30, 0x60, 0xC7,
  0xF3, 0x06, 0x0C, 0x00, 0x6D, 0xAC, 0xF8, 0xF0, 0x18, 0x84, 0x62, 0x11,
  0x88, 0xC6, 0x20, 0x7B, 0x3C, 0x73, 0xDF, 0x9C, 0x71, 0xCD, 0xE0, 0x1F,
  0xD1, 0x11, 0x11, 0x11, 0x7B, 0x38, 0xC3, 0x08, 0x63, 0x18, 0xC3, 0xF0,
  0x7B, 0x38, 0xC3, 0x38, 0xF0, 0x61, 0xCD, 0xE0, 0x0C, 0x0C, 0x1C, 0x14,
  0x24, 0x64, 0x7F, 0xFF, 0x04, 0x04, 0x7C, 0xF9, 0x06, 0x8F, 0xC0, 0x81,
  0xE2, 0xCC, 0xF0, 0x39, 0xCC, 0x34, 0xFF, 0x38, 0x71, 0xCD, 0xE0, 0xFC,
  0x10, 0xC2, 0x18, 0x43, 0x0C, 0x61, 0x80, 0x7B, 0x3C, 0x73, 0x79, 0xFC,
  0x71, 0xCD, 0xE0, 0x7B, 0x3C, 0x61, 0xC7, 0xF3, 0x43, 0x19, 0xC0, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x12, 0x59, 0x00, 0x04, 0x37, 0xB0, 0x70, 0x70,
  0x40, 0xFC, 0x0F, 0xFF, 0x83, 0x87, 0x83, 0x3F, 0x88, 0x00, 0x7B, 0x3C,
  0x43, 0x0C, 0x63, 0x00, 0x30, 0xC0, 0x1C, 0x22, 0x4D, 0x55, 0xA5, 0xA5,
  0xA5, 0x5E, 0x40, 0x3C, 0x18, 0x18, 0x1C, 0x34, 0x34, 0x26, 0x7E, 0x7E,
  0x43, 0xC3, 0xF9, 0x9B, 0x1E, 0x3F, 0xDF, 0xB1, 0xE3, 0xCF, 0xF8, 0x79,
  0x9B, 0x1C, 0x08, 0x10, 0x20, 0x63, 0xCC, 0xF0, 0xF1, 0xBB, 0x16, 0x3C,
  0x78, 0xF1, 0xE2, 0xDD, 0xF0, 0xFF, 0x83, 0x06, 0x0F, 0xDF, 0xB0, 0x60,
  0xC1, 0xFC, 0xFF, 0x83, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0x80, 0x79,
  0x9B, 0x1C, 0x08, 0x13, 0xE1, 0xE3, 0xC6, 0xF8, 0xC7, 0x1C, 0x71, 0xFF,
  0xFC, 0x71, 0xC7, 0x10, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x61, 0xCD, 0xE0, 0xC7, 0x9B, 0x66, 0xCF,
  0x1F, 0x36, 0x66, 0xCD, 0x8C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0xFC, 0xCF, 0x9F, 0xBD, 0xFB, 0x76, 0xE5, 0xC3, 0x87, 0x0C, 0xC7,
  0x1E, 0x79, 0xF7, 0x5D, 0xF3, 0xCF, 0x10, 0x79, 0x9B, 0x14, 0x38, 0x70,
  0xE1, 0xE2, 0xCC, 0xF0, 0xF9, 0x9B, 0x1E, 0x3C, 0x7F, 0xB0, 0x60, 0xC1,
  0x80, 0x79, 0x9B, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xCC, 0xF8, 0x18, 0x10,
  0xF9, 0x9B, 0x1E, 0x3C, 0xDF, 0x32, 0x66, 0xC5, 0x8C, 0x79, 0x9B, 0x1E,
  0x07, 0x03, 0x81, 0xC3, 0xC6, 0xF8, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE2, 0xCC,
  0xF0, 0xC3, 0x63, 0x62, 0x66, 0x26, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0xC9,
  0x5B, 0x5B, 0x5B, 0x5F, 0x56, 0x76, 0x76, 0x66, 0x26, 0xE3, 0x66, 0x36,
  0x3C, 0x1C, 0x1C, 0x3C, 0x36, 0x66, 0xE3, 0xC3, 0x62, 0x26, 0x34, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x08, 0x30, 0xC1, 0x06, 0x18, 0x20,
  0xC1, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0x86, 0x30, 0x86, 0x10, 0x86,
  0x10, 0xC6, 0xED, 0xB6, 0xDB, 0x6D, 0xBE, 0x23, 0x15, 0xA9, 0x80, 0xFC,
  0xCC, 0x11, 0xFC, 0xC7, 0xFF, 0x1C, 0xDD, 0xC1, 0x83, 0x06, 0x8F, 0xD8,
  0xB1, 0xE3, 0xC5, 0x9B, 0xE0, 0x11, 0xFC, 0x70, 0xC3, 0x0C, 0xDE, 0x04,
  0x10, 0x49, 0x7F, 0x1C, 0x61, 0xC7, 0x37, 0x40, 0x10, 0xFB, 0x16, 0x3F,
  0xF8, 0x31, 0x3E, 0x1E, 0x7C, 0xC1, 0x8F, 0xC6, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x21, 0xFC, 0x71, 0x87, 0x1C, 0xDF, 0x07, 0x37, 0x80, 0xC3, 0x0C,
  0x34, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x40, 0x10, 0x00, 0x07, 0x81, 0x02,
  0x04, 0x08, 0x11, 0xFC, 0x18, 0x80, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x7F,
  0x00, 0xC1, 0x83, 0x06, 0x1C, 0xDB, 0x3C, 0x78, 0xD9, 0x9B, 0x18, 0xF1,
  0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x25, 0xFE, 0xDD,
  0xBB, 0x76, 0xED, 0xDB, 0x13, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0x10, 0xFB,
  0x14, 0x38, 0x78, 0xF3, 0x3C, 0x11, 0xFB, 0x36, 0x2C, 0x78, 0xB3, 0x7C,
  0xC1, 0x83, 0x00, 0x21, 0xFC, 0x71, 0x87, 0x1C, 0xDF, 0x04, 0x10, 0x40,
  0x0F, 0xEC, 0x30, 0xC3, 0x0C, 0x30, 0x10, 0xFB, 0x17, 0x03, 0xC0, 0xF1,
  0x3E, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x0C, 0x3C, 0xC7, 0x1C, 0x71, 0xC7,
  0x37, 0x40, 0xC7, 0x99, 0x33, 0x47, 0x87, 0x0C, 0x00, 0xDB, 0x5B, 0x5B,
  0x5E, 0x56, 0x66, 0x26, 0xCE, 0xD8, 0xE1, 0x87, 0x8D, 0xB1, 0x80, 0xE3,
  0x62, 0x26, 0x34, 0x1C, 0x1C, 0x18, 0x18, 0x30, 0x60, 0xFC, 0x18, 0x61,
  0x86, 0x18, 0x3F, 0x80, 0x19, 0x8C, 0x42, 0x13, 0x0C, 0x21, 0x08, 0x61,
  0x80, 0xFF, 0xF8, 0xC3, 0x18, 0xC2, 0x10, 0x66, 0x23, 0x18, 0xCC, 0x00,
  0x20, 0x79, 0x8E,
};

const GFXglyph RobotoMono_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 13, 8, 1, -12 },
  { 28, 8, 10, 8, 0, -10 },
  { 38, 7, 10, 8, 1, -10 },
  { 47, 2, 4, 8, 3, -11 },
  { 48, 4, 14, 8, 2, -11 },
  { 55, 4, 14, 8, 2, -11 },
  { 62, 7, 7, 8, 1, -10 },
  { 69, 7, 7, 8, 1, -8 },
  { 76, 3, 5, 8, 2, -2 },
  { 78, 5, 1, 8, 2, -5 },
  { 79, 2, 2, 8, 3, -2 },
  { 80, 5, 11, 8, 2, -10 },
  { 87, 6, 10, 8, 1, -10 },
  { 95, 4, 10, 8, 1, -10 },
  { 100, 6, 10, 8, 1, -10 },
  { 108, 6, 10, 8, 1, -10 },
  { 116, 8, 10, 8, 0, -10 },
  { 126, 7, 10, 8, 1, -10 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 6, 10, 8, 1, -10 },
  { 151, 6, 10, 8, 1, -10 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 3, 8, 8, 3, -8 },
  { 170, 3, 11, 8, 3, -8 },
  { 175, 6, 7, 8, 1, -8 },
  { 181, 6, 4, 8, 1, -6 },
  { 184, 6, 7, 8, 1, -8 },
  { 190, 6, 10, 8, 1, -10 },
  { 198, 8, 10, 8, 0, -10 },
  { 208, 8, 10, 8, 0, -10 },
  { 218, 7, 10, 8, 1, -10 },
  { 227, 7, 10, 8, 1, -10 },
  { 236, 7, 10, 8, 1, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 7, 10, 8, 1, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 6, 10, 8, 1, -10 },
  { 280, 6, 10, 8, 1, -10 },
  { 288, 6, 10, 8, 1, -10 },
  { 296, 7, 10, 8, 1, -10 },
  { 305, 7, 10, 8, 1, -10 },
  { 314, 7, 10, 8, 1, -10 },
  { 323, 6, 10, 8, 1, -10 },
  { 331, 7, 10, 8, 1, -10 },
  { 340, 7, 10, 8, 1, -10 },
  { 349, 7, 12, 8, 1, -10 },
  { 360, 7, 10, 8, 1, -10 },
  { 369, 7, 10, 8, 1, -10 },
  { 378, 8, 10, 8, 0, -10 },
  { 388, 7, 10, 8, 1, -10 },
  { 397, 8, 10, 8, 0, -10 },
  { 407, 8, 10, 8, 0, -10 },
  { 417, 8, 10, 8, 0, -10 },
  { 427, 8, 10, 8, 0, -10 },
  { 437, 7, 10, 8, 1, -10 },
  { 446, 3, 13, 8, 3, -11 },
  { 451, 5, 11, 8, 2, -10 },
  { 458, 3, 13, 8, 3, -11 },
  { 463, 5, 5, 8, 2, -10 },
  { 467, 6, 1, 8, 1, 0 },
  { 468, 3, 2, 8, 3, -10 },
  { 469, 6, 8, 8, 1, -8 },
  { 475, 7, 11, 8, 1, -11 },
  { 485, 6, 8, 8, 1, -8 },
  { 491, 6, 11, 8, 1, -11 },
  { 500, 7, 8, 8, 1, -8 },
  { 507, 7, 11, 8, 1, -11 },
  { 517, 6, 11, 8, 1, -8 },
  { 526, 6, 11, 8, 1, -11 },
  { 535, 7, 10, 8, 1, -10 },
  { 544, 5, 13, 8, 1, -10 },
  { 553, 7, 11, 8, 1, -11 },
  { 563, 7, 11, 8, 1, -11 },
  { 573, 7, 8, 8, 1, -8 },
  { 580, 6, 8, 8, 1, -8 },
  { 586, 7, 8, 8, 1, -8 },
  { 593, 7, 11, 8, 1, -8 },
  { 603, 6, 11, 8, 1, -8 },
  { 612, 6, 8, 8, 2, -8 },
  { 618, 7, 8, 8, 1, -8 },
  { 625, 6, 9, 8, 1, -9 },
  { 632, 6, 7, 8, 1, -7 },
  { 638, 7, 7, 8, 1, -7 },
  { 645, 8, 7, 8, 0, -7 },
  { 652, 7, 7, 8, 1, -7 },
  { 659, 8, 10, 8, 0, -7 },
  { 669, 7, 7, 8, 1, -7 },
  { 676, 5, 13, 8, 2, -11 },
  { 685, 1, 13, 8, 4, -10 },
  { 687, 5, 13, 8, 2, -11 },
  { 696, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_Medium14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium14pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_MEDIUM14PT7B_H_
