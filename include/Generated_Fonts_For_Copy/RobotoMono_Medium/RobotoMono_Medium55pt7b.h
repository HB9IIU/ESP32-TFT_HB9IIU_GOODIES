#ifndef _ROBOTOMONO_MEDIUM55PT7B_H_
#define _ROBOTOMONO_MEDIUM55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFD,
  0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x80, 0x3E, 0x0F, 0x81, 0xC0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x01, 0xF0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x78, 0x07, 0xC1, 0xF1,
  0xF0, 0x0F, 0x83, 0xE3, 0xC0, 0x0F, 0xDF, 0x8F, 0x80, 0x1F, 0xFF, 0x1E,
  0x00, 0x1F, 0xFC, 0x78, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x02, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x3C, 0x7F, 0xF0, 0x00, 0xF1, 0xFF, 0xF0,
  0x01, 0xE3, 0xE7, 0xE0, 0x07, 0x8F, 0x83, 0xE0, 0x0F, 0x1F, 0x07, 0xC0,
  0x3C, 0x3C, 0x0F, 0x80, 0xF8, 0x78, 0x1F, 0x01, 0xE0, 0xF0, 0x3E, 0x03,
  0xC1, 0xE0, 0x7C, 0x01, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x87, 0xFF, 0xE0, 0x3F, 0x0F,
  0xEF, 0xE0, 0x7E, 0x3F, 0x9F, 0xE0, 0xFC, 0xFE, 0x1F, 0xC1, 0xF1, 0xFC,
  0x1F, 0xC7, 0xE3, 0xF0, 0x1F, 0xCF, 0xCF, 0xE0, 0x3F, 0xFF, 0x9F, 0xC0,
  0x3F, 0xFE, 0x3F, 0x80, 0x3F, 0xFC, 0x7F, 0x00, 0x3F, 0xF0, 0x7E, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0x00, 0x06, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0x00, 0xF8, 0x02, 0x78, 0x0F, 0x01, 0xCF,
  0xC1, 0xE1, 0xF9, 0xFF, 0x3C, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x60, 0x07, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E,
  0xFC, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xF3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE7, 0xF0, 0xFF, 0xF7, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x3F, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF,
  0xC0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x78, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xE0, 0x60, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE3, 0xFF,
  0x01, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0x1F, 0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF7,
  0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC,
  0x3F, 0x80, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xE7, 0xE0, 0x1F, 0xE1, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFD, 0xFC, 0x10, 0x1F, 0x87, 0xF8, 0xFF, 0x9F, 0xF7, 0xFE,
  0x7F, 0xCF, 0xF0, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0x81,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x01,
  0xF0, 0x78, 0x78, 0x1F, 0xF1, 0xE1, 0xE0, 0xFF, 0xE3, 0xCF, 0x07, 0xFF,
  0x8F, 0x3C, 0x3F, 0x1E, 0x3C, 0xF0, 0xF0, 0x70, 0x77, 0x87, 0xC1, 0xC1,
  0xDE, 0x1E, 0x07, 0x07, 0x78, 0x78, 0x1C, 0x1D, 0xE3, 0xE0, 0xF0, 0x77,
  0x8F, 0x03, 0xC1, 0xFC, 0x3C, 0x0F, 0x07, 0xF0, 0xF0, 0x3C, 0x1F, 0xC3,
  0xC0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3, 0xFC, 0x3C, 0x0F, 0x0E, 0x78, 0xF0,
  0x3C, 0x39, 0xE3, 0xE1, 0xF1, 0xE7, 0x8F, 0xDF, 0xCF, 0x1E, 0x1F, 0xFF,
  0xFC, 0x78, 0x7F, 0xDF, 0xE1, 0xF0, 0xFE, 0x3F, 0x03, 0xC0, 0x60, 0x20,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x3F,
  0x00, 0x1F, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0x3F, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x3F, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0x3F,
  0x00, 0x7F, 0x87, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x07, 0xF8, 0xFC, 0x01, 0xFE, 0x1F, 0x81, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0xC0, 0x03,
  0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x9F,
  0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00,
  0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x7F,
  0x8F, 0xC0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x07, 0xF8, 0x1F,
  0x80, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x03,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x1F, 0xE0,
  0x03, 0xF1, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0x00, 0x1F, 0xF1, 0xFC,
  0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x03, 0xF0,
  0x03, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0xF0, 0x7F, 0xFF, 0xBE, 0x3E, 0xFF, 0xEF, 0x8F,
  0xBF, 0xFB, 0xE3, 0xEF, 0xFE, 0x7D, 0xF3, 0xFF, 0x9F, 0x7C, 0xFF, 0xE7,
  0xDF, 0x3F, 0xFC, 0xF7, 0xCF, 0xFF, 0x3F, 0xE3, 0xFF, 0xCF, 0xF8, 0xFF,
  0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xFF, 0x1F, 0xC3, 0xFF, 0xC7, 0xF0,
  0xFF, 0xF0, 0xF8, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0xC1,
  0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0x80,
  0xFF, 0xF7, 0xE0, 0x7F, 0xF9, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F, 0xFE, 0x3E,
  0x0F, 0xFF, 0x1F, 0x87, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xF1, 0xFF, 0xE1,
  0xF8, 0xFF, 0xF0, 0x7E, 0x7F, 0xF8, 0x3F, 0x3F, 0xFC, 0x0F, 0xDF, 0xFE,
  0x07, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xFB, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFD, 0xF8, 0x1F, 0x01, 0xFB, 0xF0,
  0x3F, 0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xEF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83,
  0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC, 0xFC, 0x1F,
  0xE1, 0xF8, 0xF8, 0x7F, 0xC3, 0xF1, 0xF8, 0xFF, 0x87, 0xE3, 0xF1, 0xFF,
  0x0F, 0x87, 0xE3, 0xFE, 0x1F, 0x0F, 0xC7, 0xBC, 0x7E, 0x1F, 0x8F, 0x7C,
  0xFC, 0x3F, 0x1E, 0xF9, 0xF8, 0x3E, 0x7D, 0xF3, 0xF0, 0x7C, 0xFB, 0xE7,
  0xE0, 0xF9, 0xF3, 0xCF, 0xC1, 0xFB, 0xC7, 0x9F, 0x03, 0xF7, 0x8F, 0xBE,
  0x07, 0xEF, 0x1F, 0x7C, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xF1, 0xFC, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0x3F, 0x80, 0x1F, 0xBF,
  0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF3, 0xF8, 0x3F, 0xF1,
  0xFC, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1C, 0x00, 0xFE, 0x7F, 0xE0, 0x3F, 0xBF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x07, 0xF3, 0xFE, 0x03,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xC3, 0xF3,
  0xFF, 0xE0, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x60, 0x7F, 0x01, 0xFF, 0x9F, 0xC1, 0xFF, 0xF7, 0xF0,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F,
  0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x3F,
  0x01, 0xFF, 0x0F, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xC1, 0xFE, 0x00, 0x3C, 0x1F, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x40, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x07,
  0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0,
  0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xDF,
  0xC0, 0x7F, 0xE7, 0xF0, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC3, 0x00, 0x0F, 0xE0, 0xE0, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x60, 0x0F, 0xE3, 0xFF, 0x07, 0xF3, 0xFF, 0xE3,
  0xFB, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFD,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF,
  0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x02, 0x07,
  0xE7, 0xF0, 0xFE, 0x3F, 0x7F, 0xDF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xF8, 0x7F, 0x0F, 0xDF, 0x83, 0xF0,
  0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F,
  0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0,
  0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C,
  0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC,
  0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F,
  0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0x00,
  0x7E, 0x1F, 0xF8, 0x3F, 0x1F, 0xFF, 0x1F, 0x9F, 0xFF, 0xCF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3F, 0x1F, 0xF8, 0x0F, 0xCF,
  0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x80,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFE,
  0xFF, 0xF8, 0x3F, 0x9F, 0xF8, 0x0F, 0xE0, 0x20, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xE3,
  0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFC, 0x07, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xDF, 0xC0, 0x7F, 0xE7, 0xF0, 0x01, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xC3, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xBF, 0x3F, 0xFE, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0xBF, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x02, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01,
  0xFD, 0xFC, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xEF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFF, 0xE3, 0xF0, 0x3F, 0xE1, 0xF8, 0x01,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0x1F, 0x9F,
  0x83, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7C, 0x3E, 0x1F, 0xE0, 0xF8, 0x7C,
  0x3F, 0xE1, 0xF0, 0xF8, 0x7B, 0xC7, 0xE1, 0xF8, 0xF7, 0x8F, 0xC3, 0xF1,
  0xEF, 0x1F, 0x03, 0xE7, 0x9E, 0x3E, 0x07, 0xCF, 0x3E, 0x7C, 0x0F, 0x9E,
  0x3C, 0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF7, 0xC0, 0x3F, 0xE1,
  0xEF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x83,
  0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0x80, 0x7D, 0xFF,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xFF, 0xBE, 0x01, 0xFF, 0xFE, 0xF8, 0x03,
  0xFF, 0xF3, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0x80,
};

const GFXglyph RobotoMono_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 7, 39, 33, 13, -39 },
  { 36, 16, 13, 33, 8, -41 },
  { 62, 30, 39, 33, 1, -39 },
  { 209, 26, 51, 33, 4, -45 },
  { 375, 31, 41, 33, 1, -40 },
  { 534, 31, 41, 33, 2, -40 },
  { 693, 5, 14, 33, 13, -41 },
  { 702, 15, 56, 33, 9, -44 },
  { 807, 14, 56, 33, 9, -44 },
  { 905, 27, 27, 33, 4, -39 },
  { 997, 27, 28, 33, 3, -32 },
  { 1092, 8, 16, 33, 10, -6 },
  { 1108, 21, 5, 33, 7, -20 },
  { 1122, 9, 9, 33, 12, -8 },
  { 1133, 22, 42, 33, 6, -39 },
  { 1249, 25, 41, 33, 4, -40 },
  { 1378, 17, 39, 33, 5, -39 },
  { 1461, 27, 40, 33, 2, -40 },
  { 1596, 26, 41, 33, 3, -40 },
  { 1730, 28, 39, 33, 2, -39 },
  { 1867, 25, 40, 33, 4, -39 },
  { 1992, 26, 40, 33, 3, -39 },
  { 2122, 27, 39, 33, 2, -39 },
  { 2254, 25, 41, 33, 4, -40 },
  { 2383, 26, 40, 33, 3, -40 },
  { 2513, 9, 32, 33, 13, -31 },
  { 2549, 11, 41, 33, 12, -31 },
  { 2606, 24, 26, 33, 4, -30 },
  { 2684, 25, 16, 33, 4, -25 },
  { 2734, 24, 26, 33, 5, -30 },
  { 2812, 24, 40, 33, 5, -40 },
  { 2932, 30, 39, 33, 1, -39 },
  { 3079, 31, 39, 33, 1, -39 },
  { 3231, 27, 39, 33, 4, -39 },
  { 3363, 28, 41, 33, 2, -40 },
  { 3507, 27, 39, 33, 4, -39 },
  { 3639, 26, 39, 33, 4, -39 },
  { 3766, 26, 39, 33, 4, -39 },
  { 3893, 28, 41, 33, 2, -40 },
  { 4037, 25, 39, 33, 4, -39 },
  { 4159, 23, 39, 33, 5, -39 },
  { 4272, 26, 40, 33, 3, -39 },
  { 4402, 29, 39, 33, 4, -39 },
  { 4544, 25, 39, 33, 5, -39 },
  { 4666, 26, 39, 33, 4, -39 },
  { 4793, 25, 39, 33, 4, -39 },
  { 4915, 29, 41, 33, 2, -40 },
  { 5064, 27, 39, 33, 4, -39 },
  { 5196, 30, 47, 33, 2, -40 },
  { 5373, 28, 39, 33, 4, -39 },
  { 5510, 28, 41, 33, 3, -40 },
  { 5654, 31, 39, 33, 1, -39 },
  { 5806, 25, 40, 33, 4, -39 },
  { 5931, 31, 39, 33, 1, -39 },
  { 6083, 31, 39, 33, 1, -39 },
  { 6235, 31, 39, 33, 1, -39 },
  { 6387, 31, 39, 33, 1, -39 },
  { 6539, 27, 39, 33, 3, -39 },
  { 6671, 11, 54, 33, 11, -45 },
  { 6746, 22, 42, 33, 6, -39 },
  { 6862, 11, 54, 33, 11, -45 },
  { 6937, 22, 21, 33, 6, -39 },
  { 6995, 25, 5, 33, 4, 0 },
  { 7011, 12, 8, 33, 11, -40 },
  { 7023, 25, 31, 33, 4, -30 },
  { 7120, 26, 42, 33, 4, -41 },
  { 7257, 26, 31, 33, 3, -30 },
  { 7358, 26, 42, 33, 3, -41 },
  { 7495, 27, 31, 33, 3, -30 },
  { 7600, 27, 42, 33, 4, -42 },
  { 7742, 26, 41, 33, 3, -30 },
  { 7876, 25, 41, 33, 4, -41 },
  { 8005, 24, 40, 33, 6, -40 },
  { 8125, 17, 52, 33, 6, -40 },
  { 8236, 27, 41, 33, 4, -41 },
  { 8375, 25, 41, 33, 5, -41 },
  { 8504, 29, 30, 33, 2, -30 },
  { 8613, 25, 30, 33, 4, -30 },
  { 8707, 27, 31, 33, 3, -30 },
  { 8812, 26, 41, 33, 4, -30 },
  { 8946, 26, 41, 33, 3, -30 },
  { 9080, 22, 30, 33, 8, -30 },
  { 9163, 25, 31, 33, 4, -30 },
  { 9260, 25, 37, 33, 4, -36 },
  { 9376, 25, 30, 33, 4, -29 },
  { 9470, 29, 29, 33, 2, -29 },
  { 9576, 31, 29, 33, 1, -29 },
  { 9689, 28, 29, 33, 3, -29 },
  { 9791, 30, 41, 33, 2, -29 },
  { 9945, 26, 29, 33, 4, -29 },
  { 10040, 18, 53, 33, 8, -43 },
  { 10160, 5, 50, 33, 14, -39 },
  { 10192, 18, 53, 33, 9, -43 },
  { 10312, 30, 12, 33, 1, -22 },
};

const GFXfont RobotoMono_Medium55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium55pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_MEDIUM55PT7B_H_
