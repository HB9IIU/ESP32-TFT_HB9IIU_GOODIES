#ifndef _ROBOTOMONO_MEDIUM9PT7B_H_
#define _ROBOTOMONO_MEDIUM9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x3B, 0xD5, 0xF5, 0x28, 0x4B, 0x9C, 0x39, 0xE4, 0xF5,
  0x98, 0x75, 0x8C, 0x72, 0x98, 0xD9, 0xBC, 0xE0, 0x6A, 0xAA, 0x40, 0x88,
  0x92, 0x4A, 0x80, 0x4F, 0x6B, 0x27, 0xC8, 0x40, 0xE0, 0xF0, 0xC0, 0x32,
  0x44, 0x48, 0x80, 0xE9, 0xF9, 0x9E, 0xFD, 0xB6, 0xC0, 0x74, 0xC4, 0x44,
  0x7C, 0x74, 0x4C, 0x38, 0xB8, 0x31, 0x94, 0xAF, 0x88, 0xF8, 0xE1, 0x9E,
  0xE8, 0xE9, 0x9E, 0xF8, 0x84, 0x42, 0x20, 0xE9, 0xE9, 0x9E, 0xE9, 0x9F,
  0x2C, 0xC0, 0xC0, 0xC0, 0xA8, 0x1E, 0xC3, 0xF0, 0xF0, 0x86, 0x3C, 0xF1,
  0x24, 0x04, 0x7D, 0xF7, 0xBB, 0x38, 0x31, 0x94, 0xA7, 0xC4, 0xF9, 0xE9,
  0x9E, 0x7E, 0x61, 0x04, 0xB8, 0xE9, 0x99, 0x9E, 0xF8, 0xE8, 0x8F, 0xF8,
  0xF8, 0x88, 0x7E, 0x21, 0x34, 0xBC, 0x99, 0xF9, 0x99, 0xF4, 0x44, 0x4F,
  0x08, 0x42, 0x1C, 0xB8, 0xBA, 0xCA, 0xA9, 0x88, 0x88, 0x8F, 0xBB, 0xDD,
  0x99, 0x9D, 0xDB, 0xBB, 0x76, 0x63, 0x14, 0xB8, 0xF9, 0x9E, 0x88, 0x7E,
  0x63, 0x14, 0xB8, 0x20, 0xF9, 0xBE, 0xA9, 0x7A, 0x1C, 0x3C, 0xBC, 0xF9,
  0x08, 0x42, 0x10, 0x99, 0x99, 0x9E, 0xCA, 0x54, 0xA3, 0x10, 0xAD, 0x5E,
  0xB5, 0xA8, 0xCB, 0x8C, 0x65, 0x64, 0xCA, 0x8C, 0x42, 0x10, 0xF8, 0x88,
  0x44, 0x7C, 0xEA, 0xAB, 0x84, 0x44, 0x22, 0x10, 0xD5, 0x57, 0x46, 0xB0,
  0xF0, 0x90, 0xE9, 0xF9, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0x69, 0x89, 0xE0,
  0x11, 0xF9, 0x99, 0xF0, 0x69, 0xF8, 0xF0, 0x74, 0xF4, 0x44, 0x40, 0xF9,
  0x99, 0xF9, 0xE0, 0x88, 0xE9, 0x99, 0x90, 0x44, 0xC4, 0x44, 0xF0, 0x27,
  0x92, 0x49, 0xC0, 0x88, 0xBE, 0xCA, 0xB0, 0xC4, 0x44, 0x44, 0xF0, 0xFD,
  0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0x72, 0x72, 0x97, 0x00, 0xE9, 0x99,
  0xE8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xBC, 0x88, 0x80, 0xE9, 0xE1, 0xE0,
  0x4F, 0x44, 0x47, 0x99, 0x99, 0xF0, 0xCA, 0x54, 0x62, 0x00, 0xAD, 0x5E,
  0xB5, 0x00, 0xCB, 0x88, 0x6C, 0x80, 0xCA, 0x54, 0x62, 0x11, 0x00, 0xF2,
  0x4C, 0xF0, 0x24, 0xAC, 0x89, 0x20, 0xFF, 0xC9, 0x22, 0x92, 0x80, 0x45,
  0xC0,
};

const GFXglyph RobotoMono_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 2, 5, 1, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -7 },
  { 20, 2, 9, 5, 2, -7 },
  { 23, 3, 9, 5, 1, -7 },
  { 27, 4, 4, 5, 1, -6 },
  { 29, 5, 4, 5, 0, -5 },
  { 32, 1, 3, 5, 2, -1 },
  { 33, 4, 1, 5, 1, -3 },
  { 34, 2, 1, 5, 2, -1 },
  { 35, 4, 7, 5, 1, -6 },
  { 39, 4, 6, 5, 1, -6 },
  { 42, 3, 6, 5, 1, -6 },
  { 45, 5, 6, 5, 0, -6 },
  { 49, 5, 6, 5, 0, -6 },
  { 53, 5, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 1, -6 },
  { 60, 4, 6, 5, 1, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 4, 6, 5, 1, -6 },
  { 73, 2, 5, 5, 2, -5 },
  { 75, 2, 7, 5, 2, -5 },
  { 77, 4, 4, 5, 1, -5 },
  { 79, 4, 3, 5, 1, -4 },
  { 81, 4, 4, 5, 1, -5 },
  { 83, 4, 6, 5, 1, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 5, 6, 5, 0, -6 },
  { 94, 4, 6, 5, 1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 5, 6, 5, 0, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 5, 7, 5, 0, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 6, 5, 1, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 2, 8, 5, 2, -7 },
  { 184, 4, 7, 5, 1, -6 },
  { 188, 2, 8, 5, 2, -7 },
  { 190, 4, 3, 5, 1, -6 },
  { 192, 4, 1, 5, 1, 0 },
  { 193, 2, 2, 5, 2, -7 },
  { 194, 4, 5, 5, 1, -5 },
  { 197, 4, 7, 5, 1, -7 },
  { 201, 4, 5, 5, 1, -5 },
  { 204, 4, 7, 5, 1, -7 },
  { 208, 4, 5, 5, 1, -5 },
  { 211, 4, 7, 5, 1, -7 },
  { 215, 4, 7, 5, 1, -5 },
  { 219, 4, 7, 5, 1, -7 },
  { 223, 4, 7, 5, 1, -7 },
  { 227, 3, 9, 5, 1, -7 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 4, 7, 5, 1, -7 },
  { 239, 5, 5, 5, 0, -5 },
  { 243, 4, 5, 5, 1, -5 },
  { 246, 5, 5, 5, 0, -5 },
  { 250, 4, 7, 5, 1, -5 },
  { 254, 4, 7, 5, 1, -5 },
  { 258, 4, 5, 5, 1, -5 },
  { 261, 4, 5, 5, 1, -5 },
  { 264, 4, 6, 5, 1, -6 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 5, 5, 5, 0, -5 },
  { 274, 5, 5, 5, 0, -5 },
  { 278, 5, 5, 5, 0, -5 },
  { 282, 5, 7, 5, 0, -5 },
  { 287, 4, 5, 5, 1, -5 },
  { 290, 3, 9, 5, 1, -7 },
  { 294, 1, 8, 5, 2, -6 },
  { 295, 3, 9, 5, 1, -7 },
  { 299, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_Medium9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium9pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_MEDIUM9PT7B_H_
