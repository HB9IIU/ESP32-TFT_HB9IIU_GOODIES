#ifndef _ROBOTOMONO_MEDIUM13PT7B_H_
#define _ROBOTOMONO_MEDIUM13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF2, 0xC0, 0xBB, 0xB0, 0x16, 0x29, 0xF9, 0x22, 0x5F, 0xCA,
  0x14, 0x48, 0x10, 0x47, 0xB3, 0xC5, 0x83, 0x83, 0x87, 0x37, 0x84, 0xF0,
  0x94, 0x98, 0x68, 0x10, 0x16, 0x2B, 0x2B, 0x0E, 0x71, 0x93, 0x63, 0x86,
  0x36, 0xA7, 0x46, 0xF6, 0xF0, 0x32, 0x44, 0xCC, 0xCC, 0xC4, 0x42, 0x10,
  0x84, 0x62, 0x22, 0x32, 0x22, 0x64, 0x80, 0x12, 0x4F, 0xCC, 0x69, 0x30,
  0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x5C, 0xFF, 0xC0, 0xF0, 0x0C, 0x61,
  0x84, 0x30, 0x82, 0x18, 0x43, 0x00, 0x7B, 0x38, 0xE7, 0xBF, 0x38, 0xF3,
  0x78, 0x3F, 0x91, 0x11, 0x11, 0x10, 0x7C, 0x8B, 0x18, 0x20, 0xC3, 0x0C,
  0x30, 0x7E, 0xFA, 0x30, 0xC6, 0x38, 0x30, 0xF3, 0x78, 0x0C, 0x38, 0x71,
  0x66, 0xC9, 0xBF, 0x86, 0x0C, 0x7D, 0x0C, 0x3E, 0x4C, 0x38, 0xF3, 0x78,
  0x39, 0x8C, 0x2E, 0xCE, 0x38, 0xF3, 0x78, 0xFC, 0x30, 0x86, 0x10, 0xC2,
  0x18, 0x40, 0x7B, 0x3C, 0xF2, 0x7B, 0x38, 0xF3, 0x78, 0x7B, 0x28, 0xE3,
  0xCD, 0xF0, 0x86, 0x70, 0xF0, 0x3C, 0xF0, 0x0F, 0x80, 0x0C, 0xFE, 0x38,
  0x3C, 0x30, 0xFC, 0x00, 0x3F, 0x83, 0xC1, 0xC7, 0xF2, 0x00, 0x7B, 0x30,
  0xC2, 0x18, 0xC0, 0x08, 0x30, 0x3C, 0x85, 0x7D, 0x3A, 0xB5, 0x6D, 0xA0,
  0x3C, 0x18, 0x18, 0x3C, 0x3C, 0x24, 0x66, 0x7E, 0x42, 0xC3, 0xFA, 0x38,
  0x63, 0xFA, 0x18, 0x63, 0xF8, 0x7B, 0x38, 0x60, 0x82, 0x08, 0x73, 0x78,
  0xFA, 0x38, 0xE1, 0x86, 0x18, 0xE6, 0xF0, 0xFF, 0x0C, 0x30, 0xFB, 0x0C,
  0x30, 0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC0, 0x7B, 0x38, 0x20,
  0x9E, 0x78, 0x73, 0x78, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0xF3,
  0x78, 0x8F, 0x32, 0x65, 0x8F, 0x1B, 0x26, 0x46, 0x86, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x3F, 0x6D, 0xB6, 0xD8, 0x61, 0x84, 0xCF,
  0x3E, 0xEB, 0xBE, 0x79, 0xE3, 0x8C, 0x7B, 0x38, 0x61, 0x86, 0x18, 0xF3,
  0x78, 0xFB, 0x3C, 0x71, 0xFF, 0x0C, 0x30, 0xC0, 0x79, 0x9A, 0x14, 0x28,
  0x50, 0xA1, 0x66, 0x78, 0x1C, 0x10, 0xFA, 0x38, 0x63, 0xFA, 0x68, 0xA3,
  0x84, 0x7B, 0x38, 0x38, 0x38, 0x38, 0x73, 0x78, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0x78,
  0xC2, 0x8D, 0x9B, 0x22, 0x47, 0x8E, 0x0C, 0x18, 0xDB, 0x5A, 0x5A, 0x5A,
  0x5A, 0x7A, 0x66, 0x66, 0x64, 0xE7, 0x66, 0x3C, 0x18, 0x18, 0x3C, 0x24,
  0x66, 0xC3, 0xC3, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC,
  0x21, 0x84, 0x31, 0x84, 0x30, 0xFC, 0xFA, 0xAA, 0xAA, 0xC0, 0xC1, 0x86,
  0x08, 0x30, 0x41, 0x06, 0x08, 0x30, 0xF5, 0x55, 0x55, 0xC0, 0x30, 0xC7,
  0x92, 0xCC, 0xFC, 0xC0, 0x7B, 0x30, 0xDF, 0x8F, 0x3F, 0xC0, 0xC3, 0x0C,
  0x3E, 0xCF, 0x3C, 0xF3, 0xCE, 0xE0, 0x7B, 0x38, 0xE0, 0x83, 0x37, 0x80,
  0x0C, 0x30, 0xDF, 0xCE, 0x38, 0xE3, 0xCD, 0xF0, 0x7B, 0x38, 0x7F, 0x83,
  0x17, 0x80, 0x1C, 0xC2, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80, 0x7F, 0x38,
  0xE3, 0x8F, 0x37, 0xC3, 0xF8, 0xC0, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x30, 0x0F, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x18, 0x1C, 0x21,
  0x08, 0x42, 0x10, 0xBD, 0xC0, 0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x36, 0xDB,
  0x30, 0xF3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0xEE, 0xDB, 0x6D,
  0xB6, 0xDB, 0x40, 0xBB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x38, 0xE1,
  0x8F, 0x37, 0x80, 0xBB, 0x3C, 0xF3, 0xCF, 0x3F, 0xB0, 0xC3, 0x00, 0x7F,
  0x38, 0xE3, 0x8F, 0x37, 0xC3, 0x0C, 0x30, 0xBF, 0xF1, 0x08, 0x42, 0x00,
  0x7B, 0x3C, 0x1E, 0x0F, 0x37, 0x80, 0x61, 0x8F, 0xD8, 0x61, 0x86, 0x08,
  0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0xC0, 0x87, 0x3C, 0x92, 0x78, 0xC3,
  0x00, 0xD3, 0xDA, 0x5A, 0x5A, 0x6A, 0x64, 0x64, 0xCD, 0x27, 0x8C, 0x79,
  0x2C, 0xC0, 0xC3, 0x66, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x10, 0x70, 0x60,
  0xFC, 0x31, 0x8C, 0x63, 0x0F, 0xC0, 0x32, 0x22, 0x2C, 0xC2, 0x22, 0x23,
  0xFF, 0xF0, 0xC4, 0x66, 0x63, 0x36, 0x66, 0x4C, 0x73, 0x3C, 0x10,
};

const GFXglyph RobotoMono_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 9, 8, 0, -9 },
  { 32, 7, 9, 8, 1, -9 },
  { 40, 1, 4, 8, 3, -10 },
  { 41, 4, 13, 8, 2, -10 },
  { 48, 4, 13, 8, 2, -10 },
  { 55, 6, 6, 8, 1, -9 },
  { 60, 6, 7, 8, 1, -8 },
  { 66, 2, 3, 8, 2, -1 },
  { 67, 5, 2, 8, 2, -5 },
  { 69, 2, 2, 8, 3, -2 },
  { 70, 6, 10, 8, 1, -9 },
  { 78, 6, 9, 8, 1, -9 },
  { 85, 4, 9, 8, 1, -9 },
  { 90, 7, 9, 8, 0, -9 },
  { 98, 6, 9, 8, 1, -9 },
  { 105, 7, 9, 8, 0, -9 },
  { 113, 6, 9, 8, 1, -9 },
  { 120, 6, 9, 8, 1, -9 },
  { 127, 6, 9, 8, 1, -9 },
  { 134, 6, 9, 8, 1, -9 },
  { 141, 6, 9, 8, 1, -9 },
  { 148, 2, 7, 8, 3, -7 },
  { 150, 2, 9, 8, 3, -7 },
  { 153, 6, 6, 8, 1, -7 },
  { 158, 6, 4, 8, 1, -6 },
  { 161, 6, 6, 8, 1, -7 },
  { 166, 6, 9, 8, 1, -9 },
  { 173, 7, 9, 8, 0, -9 },
  { 181, 8, 9, 8, 0, -9 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 6, 9, 8, 1, -9 },
  { 211, 6, 9, 8, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 6, 9, 8, 1, -9 },
  { 253, 7, 9, 8, 1, -9 },
  { 261, 6, 9, 8, 1, -9 },
  { 268, 6, 9, 8, 1, -9 },
  { 275, 6, 9, 8, 1, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 6, 9, 8, 1, -9 },
  { 296, 7, 11, 8, 1, -9 },
  { 306, 6, 9, 8, 1, -9 },
  { 313, 6, 9, 8, 1, -9 },
  { 320, 8, 9, 8, 0, -9 },
  { 329, 6, 9, 8, 1, -9 },
  { 336, 7, 9, 8, 0, -9 },
  { 344, 8, 9, 8, 0, -9 },
  { 353, 8, 9, 8, 0, -9 },
  { 362, 8, 9, 8, 0, -9 },
  { 371, 6, 9, 8, 1, -9 },
  { 378, 2, 13, 8, 3, -11 },
  { 382, 6, 10, 8, 1, -9 },
  { 390, 2, 13, 8, 3, -11 },
  { 394, 6, 5, 8, 1, -9 },
  { 398, 6, 1, 8, 1, 0 },
  { 399, 2, 1, 8, 3, -9 },
  { 400, 6, 7, 8, 1, -7 },
  { 406, 6, 10, 8, 1, -10 },
  { 414, 6, 7, 8, 1, -7 },
  { 420, 6, 10, 8, 1, -10 },
  { 428, 6, 7, 8, 1, -7 },
  { 434, 6, 10, 8, 1, -10 },
  { 442, 6, 10, 8, 1, -7 },
  { 450, 6, 10, 8, 1, -10 },
  { 458, 6, 9, 8, 1, -9 },
  { 465, 5, 12, 8, 1, -9 },
  { 473, 6, 10, 8, 1, -10 },
  { 481, 6, 10, 8, 1, -10 },
  { 489, 6, 7, 8, 1, -7 },
  { 495, 6, 7, 8, 1, -7 },
  { 501, 6, 7, 8, 1, -7 },
  { 507, 6, 10, 8, 1, -7 },
  { 515, 6, 10, 8, 1, -7 },
  { 523, 5, 7, 8, 2, -7 },
  { 528, 6, 7, 8, 1, -7 },
  { 534, 6, 9, 8, 1, -9 },
  { 541, 6, 7, 8, 1, -7 },
  { 547, 6, 7, 8, 1, -7 },
  { 553, 8, 7, 8, 0, -7 },
  { 560, 6, 7, 8, 1, -7 },
  { 566, 8, 10, 8, 0, -7 },
  { 576, 6, 7, 8, 1, -7 },
  { 582, 4, 12, 8, 2, -10 },
  { 588, 1, 12, 8, 3, -9 },
  { 590, 4, 12, 8, 2, -10 },
  { 596, 7, 3, 8, 0, -5 },
};

const GFXfont RobotoMono_Medium13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium13pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_MEDIUM13PT7B_H_
