#ifndef _ROBOTOMONO_MEDIUM17PT7B_H_
#define _ROBOTOMONO_MEDIUM17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0x99, 0x99, 0x09, 0x82, 0x41, 0x91, 0xFF, 0x7F,
  0xC4, 0xC1, 0x23, 0xFE, 0xFF, 0x8D, 0x82, 0x60, 0x90, 0x08, 0x08, 0x3E,
  0x77, 0x63, 0x63, 0x60, 0x3C, 0x1E, 0x03, 0xC3, 0xC3, 0x77, 0x3E, 0x08,
  0x08, 0x70, 0x36, 0x4C, 0xB3, 0x68, 0x76, 0x01, 0x00, 0xC0, 0x2E, 0x16,
  0xCD, 0xB0, 0x6C, 0x0E, 0x3C, 0x36, 0x19, 0x8C, 0x87, 0xC1, 0x81, 0xE7,
  0xBB, 0xCD, 0x63, 0xBB, 0xCF, 0xF0, 0xEA, 0x80, 0x11, 0x36, 0x4C, 0xCC,
  0xCC, 0xCC, 0xC4, 0x62, 0x31, 0x88, 0x46, 0x23, 0x33, 0x33, 0x33, 0x32,
  0x64, 0xC8, 0x08, 0x04, 0x12, 0x5F, 0xF1, 0xC0, 0xA0, 0xD8, 0xC6, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6D, 0xEC, 0xFF, 0xFC,
  0x5F, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x86,
  0x0C, 0x00, 0x3E, 0x66, 0xC3, 0xC3, 0xC7, 0xCF, 0xF3, 0xE3, 0xC3, 0xC3,
  0x76, 0x3C, 0x1F, 0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x7C, 0xEE,
  0xC6, 0xC3, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x7C, 0xE6,
  0xC3, 0x03, 0x06, 0x3C, 0x3E, 0x03, 0x03, 0xC3, 0xEE, 0x7C, 0x0E, 0x0E,
  0x1E, 0x36, 0x36, 0x66, 0x46, 0xC6, 0xFF, 0x06, 0x06, 0x06, 0x7F, 0x7F,
  0x60, 0x60, 0x7C, 0x7E, 0x03, 0x03, 0x03, 0xC3, 0x77, 0x3E, 0x1C, 0x3C,
  0x60, 0xC0, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0x76, 0x3C, 0xFF, 0xFF,
  0x02, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x3E, 0x66,
  0xC3, 0xC3, 0x66, 0x3E, 0x7E, 0xC3, 0xC3, 0xC3, 0x77, 0x3E, 0x3C, 0x66,
  0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3B, 0x02, 0x06, 0x3C, 0x38, 0x5F, 0x80,
  0x02, 0xFC, 0x5F, 0x80, 0x00, 0x4B, 0x68, 0x03, 0x0F, 0x7C, 0xE0, 0xF0,
  0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x3E, 0x07,
  0x0F, 0x78, 0xE0, 0x80, 0x3E, 0x77, 0xC3, 0x03, 0x07, 0x0E, 0x1C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x1F, 0x0C, 0x66, 0x49, 0x3B, 0x5A, 0x54, 0x9D,
  0x2F, 0x4A, 0x5F, 0x90, 0x06, 0x20, 0x78, 0x0C, 0x03, 0x80, 0xE0, 0x78,
  0x1B, 0x04, 0xC3, 0x30, 0xC6, 0x3F, 0x98, 0x66, 0x1F, 0x83, 0xFE, 0x7F,
  0xB0, 0xD8, 0x6C, 0x37, 0xF3, 0xFD, 0x86, 0xC1, 0xE1, 0xBF, 0xDF, 0xC0,
  0x3E, 0x67, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0x77, 0x3E,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x3E, 0x77, 0xC3, 0xC0, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xC3, 0x77, 0x3E,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x63, 0xFF, 0xF0, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3, 0xEE, 0x7C, 0xC3,
  0xE3, 0xB1, 0x99, 0x8D, 0x87, 0xC3, 0xF1, 0xD8, 0xC6, 0x63, 0xB0, 0xD8,
  0x30, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xE3, 0xE7, 0xE7, 0xF7, 0xFF, 0xDF, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7,
  0xC3, 0x3C, 0x76, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E,
  0x3C, 0xFE, 0x7F, 0xB0, 0xD8, 0x3C, 0x3E, 0x1B, 0xF9, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x3C, 0x3B, 0x30, 0xD8, 0x6C, 0x36, 0x1F, 0x0F, 0x86,
  0xC3, 0x61, 0x9F, 0x87, 0xC0, 0x38, 0x08, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C,
  0x36, 0x3B, 0xF9, 0x98, 0xC6, 0x63, 0xB0, 0xD8, 0x70, 0x3E, 0x33, 0xB0,
  0xD8, 0x16, 0x03, 0xE0, 0x78, 0x06, 0xC3, 0xE1, 0x9D, 0xC7, 0xC0, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7E, 0x3C, 0xE1, 0xD8, 0x66, 0x18, 0xC6, 0x33, 0x0C, 0xC3, 0x30, 0x78,
  0x1E, 0x07, 0x80, 0xE0, 0x30, 0xCC, 0xD3, 0x36, 0xCD, 0xB2, 0x6E, 0x9F,
  0xE7, 0xB9, 0xEE, 0x73, 0x8C, 0xE3, 0x38, 0xCC, 0x61, 0xDC, 0x63, 0x30,
  0x6C, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x3B, 0x0C, 0xE7, 0x1B, 0x87, 0xE1,
  0xD8, 0x63, 0x18, 0xCC, 0x1B, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60,
  0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0,
  0x81, 0x83, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x30, 0x71, 0xE3, 0x44,
  0xD8, 0xC0, 0xFF, 0xFF, 0xE3, 0x3C, 0x66, 0xC3, 0x03, 0x7F, 0xC3, 0xC3,
  0xEF, 0x7B, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xF7, 0xDE, 0x3E, 0x76, 0xC3, 0xC0, 0xC0, 0xC0, 0xC3, 0x77, 0x3E,
  0x03, 0x03, 0x03, 0x03, 0x3F, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F,
  0x3F, 0x3E, 0x77, 0xC3, 0xC3, 0xFF, 0xC0, 0xE1, 0x77, 0x3E, 0x0F, 0x8F,
  0x86, 0x03, 0x0F, 0xF7, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x3F, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x77, 0x3F, 0x03, 0x47,
  0x7E, 0x10, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x38, 0x20, 0x07, 0xCF, 0x87, 0x0E, 0x1C, 0x38, 0x73,
  0xFF, 0xF0, 0x18, 0xC0, 0xF7, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xDC,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x76, 0x73, 0x71, 0xB0, 0xF8, 0x76, 0x33,
  0x98, 0xEC, 0x38, 0xF9, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE7, 0xFF, 0xE0, 0xBF, 0xFF, 0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0xD9,
  0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x76, 0x3C, 0xDE, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xF6, 0xDE, 0xC0, 0xC0, 0xC0, 0x3F, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x77, 0x3F, 0x03, 0x03, 0x03, 0xBF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x3E, 0x67, 0xC3, 0x60, 0x3E, 0x07, 0xC3, 0x67, 0x3E, 0x30, 0x30,
  0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x1F, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0xC3, 0xE1, 0x98, 0xCC, 0xC6, 0x61,
  0xA0, 0xF0, 0x38, 0x18, 0x00, 0xCC, 0xD3, 0x34, 0xC9, 0xB2, 0x7F, 0x9E,
  0xE3, 0x38, 0xCC, 0x33, 0x00, 0xC3, 0xB3, 0x8D, 0x87, 0x81, 0x81, 0xE0,
  0xD8, 0xCE, 0xC3, 0x80, 0xE0, 0xD8, 0x63, 0x18, 0xCC, 0x33, 0x06, 0xC1,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x00, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x70, 0xFF, 0xFF, 0x19, 0x8C, 0x63, 0x19, 0x98, 0xE1,
  0x0C, 0x63, 0x18, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0x18, 0xC6, 0x30,
  0xC7, 0x3B, 0x18, 0xC6, 0x31, 0x98, 0x30, 0x1F, 0x3C, 0xF8, 0x0C,
};

const GFXglyph RobotoMono_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 4, 10, 3, -13 },
  { 6, 10, 12, 10, 0, -12 },
  { 21, 8, 16, 10, 1, -14 },
  { 37, 10, 12, 10, 0, -12 },
  { 52, 9, 12, 10, 1, -12 },
  { 66, 2, 5, 10, 4, -13 },
  { 68, 4, 18, 10, 3, -14 },
  { 77, 4, 18, 10, 3, -14 },
  { 86, 9, 8, 10, 1, -12 },
  { 95, 8, 9, 10, 1, -10 },
  { 104, 3, 5, 10, 3, -2 },
  { 106, 7, 2, 10, 2, -6 },
  { 108, 3, 3, 10, 4, -3 },
  { 110, 7, 13, 10, 2, -12 },
  { 122, 8, 12, 10, 1, -12 },
  { 134, 5, 12, 10, 2, -12 },
  { 142, 8, 12, 10, 1, -12 },
  { 154, 8, 12, 10, 1, -12 },
  { 166, 8, 12, 10, 1, -12 },
  { 178, 8, 12, 10, 1, -12 },
  { 190, 8, 12, 10, 1, -12 },
  { 202, 8, 12, 10, 1, -12 },
  { 214, 8, 12, 10, 1, -12 },
  { 226, 8, 12, 10, 1, -12 },
  { 238, 3, 10, 10, 4, -10 },
  { 242, 3, 13, 10, 4, -10 },
  { 247, 8, 8, 10, 1, -9 },
  { 255, 8, 5, 10, 1, -8 },
  { 260, 8, 8, 10, 1, -9 },
  { 268, 8, 12, 10, 1, -12 },
  { 280, 10, 12, 10, 0, -12 },
  { 295, 10, 12, 10, 0, -12 },
  { 310, 9, 12, 10, 1, -12 },
  { 324, 8, 12, 10, 1, -12 },
  { 336, 8, 12, 10, 1, -12 },
  { 348, 8, 12, 10, 1, -12 },
  { 360, 8, 12, 10, 1, -12 },
  { 372, 8, 12, 10, 1, -12 },
  { 384, 8, 12, 10, 1, -12 },
  { 396, 7, 12, 10, 2, -12 },
  { 407, 8, 12, 10, 1, -12 },
  { 419, 9, 12, 10, 1, -12 },
  { 433, 8, 12, 10, 1, -12 },
  { 445, 8, 12, 10, 1, -12 },
  { 457, 8, 12, 10, 1, -12 },
  { 469, 8, 12, 10, 1, -12 },
  { 481, 9, 12, 10, 1, -12 },
  { 495, 9, 14, 10, 1, -12 },
  { 511, 9, 12, 10, 1, -12 },
  { 525, 9, 12, 10, 1, -12 },
  { 539, 10, 12, 10, 0, -12 },
  { 554, 8, 12, 10, 1, -12 },
  { 566, 10, 12, 10, 0, -12 },
  { 581, 10, 12, 10, 0, -12 },
  { 596, 10, 12, 10, 0, -12 },
  { 611, 10, 12, 10, 0, -12 },
  { 626, 8, 12, 10, 1, -12 },
  { 638, 4, 17, 10, 3, -14 },
  { 647, 7, 13, 10, 2, -12 },
  { 659, 4, 17, 10, 3, -14 },
  { 668, 7, 6, 10, 2, -12 },
  { 674, 8, 2, 10, 1, 0 },
  { 676, 4, 2, 10, 3, -12 },
  { 677, 8, 9, 10, 1, -9 },
  { 686, 8, 13, 10, 1, -13 },
  { 699, 8, 9, 10, 1, -9 },
  { 708, 8, 13, 10, 1, -13 },
  { 721, 8, 9, 10, 1, -9 },
  { 730, 9, 13, 10, 1, -13 },
  { 745, 8, 13, 10, 1, -9 },
  { 758, 8, 13, 10, 1, -13 },
  { 771, 7, 12, 10, 2, -12 },
  { 782, 5, 16, 10, 2, -12 },
  { 792, 9, 13, 10, 1, -13 },
  { 807, 7, 13, 10, 2, -13 },
  { 819, 8, 9, 10, 1, -9 },
  { 828, 8, 9, 10, 1, -9 },
  { 837, 8, 9, 10, 1, -9 },
  { 846, 8, 12, 10, 1, -9 },
  { 858, 8, 12, 10, 1, -9 },
  { 870, 6, 9, 10, 3, -9 },
  { 877, 8, 9, 10, 1, -9 },
  { 886, 8, 11, 10, 1, -11 },
  { 897, 8, 9, 10, 1, -9 },
  { 906, 9, 9, 10, 1, -9 },
  { 917, 10, 9, 10, 0, -9 },
  { 929, 9, 9, 10, 1, -9 },
  { 940, 10, 13, 10, 0, -9 },
  { 957, 8, 9, 10, 1, -9 },
  { 966, 5, 16, 10, 3, -13 },
  { 976, 2, 15, 10, 4, -12 },
  { 980, 5, 16, 10, 3, -13 },
  { 990, 10, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_Medium17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium17pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_MEDIUM17PT7B_H_
