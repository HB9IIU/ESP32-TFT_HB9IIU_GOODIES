#ifndef _ROBOTOMONO_MEDIUM22PT7B_H_
#define _ROBOTOMONO_MEDIUM22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xBF, 0xC7, 0x1C, 0x71, 0xC7, 0x10,
  0x0C, 0xC0, 0xCC, 0x08, 0xC0, 0x88, 0x18, 0x8F, 0xFF, 0xFF, 0xF1, 0x98,
  0x11, 0x83, 0x10, 0xFF, 0xEF, 0xFE, 0x33, 0x02, 0x30, 0x62, 0x06, 0x60,
  0x0C, 0x03, 0x01, 0xE1, 0xFE, 0x73, 0xB8, 0x7E, 0x1F, 0x80, 0x70, 0x1F,
  0x81, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0xC0,
  0x30, 0x38, 0x03, 0xE0, 0x33, 0x11, 0x89, 0x8C, 0x4C, 0x3E, 0xC0, 0xE4,
  0x00, 0x60, 0x02, 0x00, 0x33, 0x01, 0x7C, 0x1B, 0x31, 0x99, 0x84, 0xCC,
  0x06, 0xE0, 0x1E, 0x0E, 0x03, 0xF0, 0x33, 0x87, 0x18, 0x71, 0x83, 0x30,
  0x3E, 0x01, 0xC0, 0x3C, 0x07, 0xE7, 0xE7, 0x6E, 0x3E, 0xE3, 0xEE, 0x1C,
  0x7F, 0xE3, 0xF7, 0xFF, 0xF0, 0x04, 0x31, 0x8C, 0x71, 0x86, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x38, 0x70, 0x80, 0x83,
  0x06, 0x0C, 0x38, 0x61, 0x87, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C,
  0x61, 0x8C, 0x73, 0x84, 0x00, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xED, 0xDF,
  0xF0, 0xC0, 0x78, 0x33, 0x1C, 0xE2, 0x10, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x6D,
  0xB7, 0xF0, 0xFF, 0xFF, 0xEF, 0xE0, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xE0,
  0xE0, 0x00, 0x1E, 0x1F, 0xCE, 0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x3F, 0x3F,
  0xDD, 0xFC, 0x7E, 0x1F, 0x07, 0xC1, 0xB8, 0xE7, 0xF0, 0xF8, 0x02, 0x3D,
  0xFF, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x1E, 0x0F, 0xF1, 0xCF, 0x70, 0xEC, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0x1E, 0x1F,
  0xE7, 0x1F, 0x87, 0x00, 0xC0, 0x70, 0x1C, 0x7E, 0x1F, 0x80, 0x70, 0x0C,
  0x03, 0xE0, 0xF8, 0x77, 0xF8, 0xFC, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xC0,
  0xD8, 0x33, 0x06, 0x61, 0x8C, 0x71, 0x8C, 0x33, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x00, 0x60, 0x0C, 0x7F, 0x9F, 0xE7, 0xF9, 0x80, 0xE0, 0x38, 0x0F,
  0xF3, 0xFE, 0x43, 0x80, 0x70, 0x1C, 0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC,
  0x03, 0x01, 0xE0, 0xF8, 0x1C, 0x07, 0x00, 0xC0, 0x1B, 0xE7, 0xFE, 0xF1,
  0xDC, 0x1B, 0x83, 0xF0, 0x76, 0x0C, 0xE3, 0x8F, 0xE0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x1F, 0x07, 0xF1, 0xC7,
  0x38, 0x66, 0x0C, 0xE1, 0x9C, 0x71, 0xFC, 0x3F, 0x8E, 0x39, 0x83, 0xF0,
  0x76, 0x0E, 0xE3, 0x9F, 0xF0, 0xFC, 0x1E, 0x0F, 0xE7, 0x3D, 0x87, 0xE0,
  0xF8, 0x3E, 0x0D, 0x83, 0x71, 0xCF, 0xF1, 0xEC, 0x07, 0x01, 0x81, 0xE1,
  0xF0, 0x70, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0x70, 0x00, 0x00,
  0x06, 0x66, 0x66, 0xEC, 0x00, 0x81, 0xC3, 0xEF, 0xCF, 0x07, 0x03, 0xF0,
  0x3F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x70, 0x3E, 0x07, 0xE0, 0x78, 0x1C, 0x7F, 0xF8, 0xF0, 0x60,
  0x00, 0x1E, 0x1F, 0xEF, 0x3B, 0x87, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x06, 0x01, 0xF8,
  0x30, 0xC6, 0x06, 0x4F, 0xAC, 0x92, 0x99, 0x39, 0x13, 0x91, 0x29, 0x12,
  0x93, 0x29, 0xFC, 0xCC, 0x86, 0x00, 0x7B, 0x01, 0xF0, 0x06, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB8, 0x1B, 0x83, 0x98, 0x31, 0xC3, 0x1C,
  0x7F, 0xC7, 0xFC, 0x60, 0xEE, 0x06, 0xE0, 0x6C, 0x07, 0xFC, 0x3F, 0xEF,
  0xFB, 0x07, 0xC1, 0xF0, 0x7C, 0x3B, 0xFC, 0xFF, 0xB0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x7F, 0xFB, 0xFC, 0x0F, 0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x0F,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x36, 0x0E, 0xE1,
  0x8F, 0xF0, 0xFC, 0xFC, 0x1F, 0xE3, 0x9E, 0x70, 0xEE, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0D, 0xC7, 0xBF, 0xE7,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF,
  0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0x07, 0xF9, 0xE7, 0x38, 0x7E, 0x0F,
  0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x81, 0xF0, 0x36, 0x06, 0xE1,
  0xCF, 0xF8, 0xFC, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7E,
  0x0C, 0xE3, 0x9F, 0xE1, 0xF8, 0xC0, 0xF8, 0x3B, 0x0E, 0x63, 0x8C, 0x71,
  0x9C, 0x37, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0x9C, 0x63, 0x8C, 0x39, 0x83,
  0xB0, 0x76, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0xB7, 0xF6, 0xFA, 0xDF, 0x73, 0xEE, 0x7D,
  0xCF, 0x91, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFE, 0x1F,
  0xC3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFB, 0x3F, 0x67, 0xE6, 0xFC, 0xDF, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0x0F, 0x07, 0xF1, 0xE7, 0x30,
  0x6E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x76,
  0x0E, 0xE3, 0x8F, 0xE0, 0xF8, 0xFC, 0x3F, 0xEC, 0x7F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x0F, 0x03, 0xF8, 0x79, 0xC6, 0x0E, 0xE0, 0xEE, 0x06, 0xE0, 0x6E,
  0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0x60, 0xE7, 0x1C, 0x3F, 0xC1,
  0xFC, 0x00, 0xE0, 0x07, 0x00, 0x20, 0xFC, 0x1F, 0xF3, 0x1E, 0x60, 0xEC,
  0x1D, 0x81, 0xB0, 0x76, 0x1C, 0xFF, 0x9F, 0xC3, 0x1C, 0x61, 0x8C, 0x39,
  0x83, 0x30, 0x76, 0x07, 0x0F, 0x07, 0xF9, 0xE7, 0xB0, 0x76, 0x06, 0xC0,
  0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x06, 0xE1, 0xDF,
  0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x76, 0x0E, 0xE3, 0x8F, 0xF0, 0xF8,
  0xC0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0x60, 0xC7, 0x1C, 0x71, 0xC3, 0x18,
  0x39, 0x83, 0xB8, 0x1B, 0x81, 0xB0, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0xE3, 0x3B, 0x39, 0xD9, 0xCE, 0xCE, 0x66, 0x73, 0x33, 0x99, 0xDE, 0xCE,
  0xB6, 0x3D, 0xB1, 0xEF, 0x8F, 0x7C, 0x79, 0xC3, 0xCE, 0x1C, 0x70, 0xE3,
  0x87, 0x1C, 0xE0, 0x7E, 0x0E, 0x70, 0xE3, 0x1C, 0x39, 0x81, 0xB8, 0x1F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0x98, 0x31, 0xC7, 0x0C, 0xE0,
  0xEE, 0x07, 0xE0, 0x3B, 0x83, 0x8C, 0x1C, 0x70, 0xC3, 0x8E, 0x0E, 0x60,
  0x77, 0x01, 0xB0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xFF, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0x80, 0x0C,
  0x0E, 0x07, 0x83, 0xC3, 0x61, 0x99, 0x8C, 0xC7, 0xE1, 0x80, 0xFF, 0xFF,
  0xC0, 0xF1, 0x86, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x60, 0x0C, 0x3F, 0x9F,
  0xF3, 0x06, 0xE0, 0xCC, 0x39, 0xFF, 0x1F, 0x70, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x33, 0x8F, 0xF3, 0xCE, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x3B, 0xFE, 0xDF, 0x00, 0x0F, 0x07, 0xF1, 0xE7, 0x38, 0x66,
  0x0F, 0xC0, 0x38, 0x07, 0x00, 0x60, 0xEE, 0x18, 0xFF, 0x0F, 0x80, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC7, 0xB3, 0xFD, 0xC7, 0x60, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xD8, 0x37, 0x1C, 0xFF, 0x1E, 0xC0, 0x0F, 0x07, 0xF1,
  0xE7, 0x38, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x08, 0xFF,
  0x8F, 0xC0, 0x03, 0xE0, 0xFC, 0x38, 0x06, 0x00, 0xC1, 0xFF, 0xBF, 0xF0,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x1E, 0xE7, 0xFD, 0xE7, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0x60, 0xEE, 0x3C, 0xFF, 0x8F, 0x70, 0x0E, 0x41, 0x9E, 0xF1, 0xFC,
  0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0x8D, 0xFB, 0xCE,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0,
  0x0C, 0x03, 0x00, 0x80, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x06, 0x1C, 0x18, 0x07,
  0xEF, 0xDF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1E,
  0x7F, 0xEF, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0,
  0xE6, 0x38, 0xCE, 0x1B, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0x8E, 0x30, 0xE6,
  0x1C, 0xC1, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF,
  0xC0, 0xDD, 0xDF, 0xFF, 0xB9, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x73,
  0xCE, 0x79, 0xCF, 0x39, 0xE7, 0x30, 0xCF, 0x37, 0xEF, 0x3B, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x0F, 0x07, 0xF1,
  0xC7, 0x30, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEE, 0x38, 0xFF,
  0x0F, 0x80, 0xCE, 0x3F, 0xCE, 0x3B, 0x06, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0xEF, 0xFB, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1E, 0xCF,
  0xF7, 0x1D, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x60, 0xDC, 0x73, 0xFC,
  0x7B, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xE7, 0xFF, 0xFF, 0xFE, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1E, 0x1F, 0xEE, 0x3B,
  0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x7F, 0xF8, 0xFC, 0x1C,
  0x03, 0x83, 0xFF, 0x7F, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xFE, 0x0F, 0xC0, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xFF, 0xFD, 0xF7, 0xE0, 0x7C,
  0x1D, 0x83, 0x38, 0x63, 0x1C, 0x63, 0x0E, 0x60, 0xDC, 0x1B, 0x03, 0xE0,
  0x38, 0x07, 0x00, 0xE2, 0x3B, 0x39, 0xD9, 0xCC, 0xCE, 0x66, 0x53, 0x32,
  0x98, 0xF6, 0xC7, 0xBC, 0x3C, 0xE1, 0xC7, 0x0E, 0x38, 0x31, 0xC0, 0xE0,
  0xE7, 0x0E, 0x39, 0xC3, 0xB8, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1B,
  0x83, 0x9C, 0x70, 0xCE, 0x0F, 0xE0, 0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x71,
  0xC3, 0x9C, 0x39, 0x81, 0xB8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x7C, 0x07, 0x80, 0x60, 0x00, 0x7F, 0xEF, 0xFC, 0x07, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF0,
  0x06, 0x0F, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0xF0, 0xE0, 0x38,
  0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0F, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x30, 0x3C, 0x39,
  0xC3, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0C, 0x00, 0x38, 0x07, 0xE1,
  0x6F, 0x3C, 0x3F, 0x00, 0xE0,
};

const GFXglyph RobotoMono_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 6, 6, 13, 3, -17 },
  { 12, 12, 16, 13, 1, -16 },
  { 36, 10, 20, 13, 2, -18 },
  { 61, 13, 16, 13, 0, -16 },
  { 87, 12, 16, 13, 1, -16 },
  { 111, 2, 6, 13, 5, -17 },
  { 113, 6, 23, 13, 4, -18 },
  { 131, 6, 23, 13, 3, -18 },
  { 149, 10, 11, 13, 2, -16 },
  { 163, 11, 11, 13, 1, -13 },
  { 179, 3, 7, 13, 4, -3 },
  { 182, 8, 2, 13, 3, -8 },
  { 184, 4, 3, 13, 5, -3 },
  { 186, 9, 17, 13, 2, -16 },
  { 206, 10, 16, 13, 2, -16 },
  { 226, 7, 16, 13, 2, -16 },
  { 240, 11, 16, 13, 1, -16 },
  { 262, 10, 16, 13, 1, -16 },
  { 282, 11, 16, 13, 1, -16 },
  { 304, 10, 16, 13, 2, -16 },
  { 324, 11, 16, 13, 1, -16 },
  { 346, 11, 16, 13, 1, -16 },
  { 368, 11, 16, 13, 1, -16 },
  { 390, 10, 16, 13, 1, -16 },
  { 410, 4, 12, 13, 5, -12 },
  { 416, 4, 16, 13, 5, -12 },
  { 424, 9, 10, 13, 2, -12 },
  { 436, 10, 7, 13, 2, -10 },
  { 445, 9, 10, 13, 2, -12 },
  { 457, 10, 16, 13, 2, -16 },
  { 477, 12, 16, 13, 1, -16 },
  { 501, 12, 16, 13, 1, -16 },
  { 525, 10, 16, 13, 2, -16 },
  { 545, 11, 16, 13, 1, -16 },
  { 567, 11, 16, 13, 1, -16 },
  { 589, 10, 16, 13, 2, -16 },
  { 609, 10, 16, 13, 2, -16 },
  { 629, 11, 16, 13, 1, -16 },
  { 651, 11, 16, 13, 1, -16 },
  { 673, 9, 16, 13, 2, -16 },
  { 691, 11, 16, 13, 1, -16 },
  { 713, 11, 16, 13, 2, -16 },
  { 735, 10, 16, 13, 2, -16 },
  { 755, 11, 16, 13, 1, -16 },
  { 777, 11, 16, 13, 1, -16 },
  { 799, 11, 16, 13, 1, -16 },
  { 821, 10, 16, 13, 2, -16 },
  { 841, 12, 19, 13, 1, -16 },
  { 870, 11, 16, 13, 2, -16 },
  { 892, 11, 16, 13, 1, -16 },
  { 914, 12, 16, 13, 1, -16 },
  { 938, 11, 16, 13, 1, -16 },
  { 960, 12, 16, 13, 1, -16 },
  { 984, 13, 16, 13, 0, -16 },
  { 1010, 12, 16, 13, 1, -16 },
  { 1034, 13, 16, 13, 0, -16 },
  { 1060, 11, 16, 13, 1, -16 },
  { 1082, 5, 21, 13, 4, -18 },
  { 1096, 8, 17, 13, 3, -16 },
  { 1113, 5, 21, 13, 4, -18 },
  { 1127, 9, 9, 13, 2, -16 },
  { 1138, 9, 2, 13, 2, 0 },
  { 1141, 5, 3, 13, 4, -16 },
  { 1143, 11, 12, 13, 1, -12 },
  { 1160, 10, 17, 13, 2, -17 },
  { 1182, 11, 12, 13, 1, -12 },
  { 1199, 10, 17, 13, 1, -17 },
  { 1221, 11, 12, 13, 1, -12 },
  { 1238, 11, 17, 13, 1, -17 },
  { 1262, 11, 17, 13, 1, -12 },
  { 1286, 10, 17, 13, 2, -17 },
  { 1308, 10, 16, 13, 2, -16 },
  { 1328, 7, 21, 13, 2, -16 },
  { 1347, 11, 17, 13, 2, -17 },
  { 1371, 10, 17, 13, 2, -17 },
  { 1393, 11, 12, 13, 1, -12 },
  { 1410, 10, 12, 13, 2, -12 },
  { 1425, 11, 12, 13, 1, -12 },
  { 1442, 10, 16, 13, 2, -12 },
  { 1462, 10, 16, 13, 1, -12 },
  { 1482, 9, 12, 13, 3, -12 },
  { 1496, 10, 12, 13, 2, -12 },
  { 1511, 11, 14, 13, 1, -14 },
  { 1531, 10, 12, 13, 2, -12 },
  { 1546, 11, 12, 13, 1, -12 },
  { 1563, 13, 12, 13, 0, -12 },
  { 1583, 12, 12, 13, 1, -12 },
  { 1601, 12, 17, 13, 1, -12 },
  { 1627, 11, 12, 13, 1, -12 },
  { 1644, 8, 21, 13, 3, -17 },
  { 1665, 2, 20, 13, 6, -16 },
  { 1670, 7, 21, 13, 4, -17 },
  { 1689, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_Medium22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium22pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_MEDIUM22PT7B_H_
