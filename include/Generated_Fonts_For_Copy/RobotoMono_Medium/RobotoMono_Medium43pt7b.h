#ifndef _ROBOTOMONO_MEDIUM43PT7B_H_
#define _ROBOTOMONO_MEDIUM43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7,
  0x80, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01,
  0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x07, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC1, 0xE0, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xF0, 0x1F,
  0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xEF,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE1, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0, 0xE3, 0xC0, 0xF1, 0xE3, 0x80, 0x7F,
  0xE7, 0x80, 0x7F, 0xC7, 0x00, 0x3F, 0x8E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0xF8, 0x00, 0xF3, 0xFC, 0x00, 0xE7, 0xFE, 0x01, 0xE7, 0x9F, 0x01,
  0xCF, 0x0F, 0x03, 0x8F, 0x0F, 0x03, 0x8F, 0x0F, 0x07, 0x0F, 0x0F, 0x01,
  0x0F, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3E, 0x3F, 0xF8, 0x3E, 0x7E, 0xFC, 0x3E, 0x7C,
  0x7E, 0x3E, 0xFC, 0x3E, 0x3C, 0xF8, 0x1F, 0x7C, 0xF8, 0x1F, 0xFC, 0xF8,
  0x0F, 0xF8, 0xF8, 0x07, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0x7C, 0x0F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x60, 0x02, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x03, 0x80, 0x40, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0x81, 0xC0, 0x4F, 0x0E, 0x0E, 0x7E, 0x71, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x07,
  0xC1, 0xF0, 0x3C, 0x07, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xE7, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x11, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7D, 0xFF, 0x8F, 0x9F, 0xFB, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E,
  0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0xFE, 0x3E,
  0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0x7E, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F,
  0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xCF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xE0, 0xFE,
  0x08, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xF7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0xFB, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x3E, 0x0F, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xF9, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7E,
  0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x8F,
  0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xE0, 0x3F, 0x3F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xDF, 0x03, 0xF1, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7C, 0x08, 0x7E, 0x7F, 0x7F, 0x7F, 0x7E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xE1, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x1C, 0x3C, 0x1F, 0x0E, 0x38, 0x7F, 0xCE, 0x38, 0xFF, 0x8E,
  0x70, 0xF3, 0x8E, 0x71, 0xE3, 0x86, 0x71, 0xC3, 0x86, 0xF1, 0xC3, 0x86,
  0xE3, 0xC3, 0x86, 0xE3, 0x83, 0x86, 0xE3, 0x83, 0x86, 0xE3, 0x83, 0x8E,
  0xE3, 0x83, 0x8E, 0xE3, 0x83, 0x8E, 0xE3, 0xC7, 0x9C, 0xF1, 0xFF, 0xBC,
  0x71, 0xFF, 0xF8, 0x70, 0xF9, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC1, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x80, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x7E, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xC0, 0x3F, 0xBE,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0,
  0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7C, 0x0F, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7E, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x0F, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0,
  0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF8, 0x1F,
  0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x9F, 0x81, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0,
  0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0,
  0x0F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFD, 0xF8, 0x07, 0xF1, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xF8,
  0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F, 0xCF, 0x80,
  0x1F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF7, 0x1E, 0xFF, 0x79, 0xEF, 0xF7,
  0x9E, 0xFF, 0x39, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFF,
  0x1F, 0x8F, 0xF9, 0xF8, 0xFF, 0x9F, 0x8F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F,
  0xF8, 0xF0, 0xFF, 0x86, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xFB, 0xE1,
  0xFF, 0x9E, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x9F, 0xF8, 0x79, 0xFF, 0x87, 0xDF, 0xF8, 0x3D, 0xFF, 0x83, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE0,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x7F,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFC, 0xFE,
  0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBF, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x7C, 0x03,
  0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0, 0x0F, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF8, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E,
  0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7E,
  0x1F, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x7C, 0x7E,
  0x1E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x3C, 0xFF,
  0x3E, 0x3C, 0xFF, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7,
  0xBC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xE7,
  0xE0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x7D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0,
  0x7E, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x83, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xBE, 0x0F, 0xF1, 0xF0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0xFB, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFC, 0x03, 0xEF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xEF, 0xE0, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFB,
  0xFF, 0x8F, 0x9F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0xFE, 0x7C, 0x3F, 0xEF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0x78, 0x3F, 0x8F, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x0C, 0x7F, 0x01, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF1, 0xF0, 0xFF, 0xDF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xDF, 0x07, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0x00, 0x3E,
  0x38, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xF0, 0x7E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xEF,
  0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xCF, 0x80, 0x7E,
  0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x3F, 0x00, 0xF9, 0xFC, 0x03, 0xEF, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0x80,
  0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8,
  0x07, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE3, 0xE3, 0xDF, 0xDF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7F, 0xC3, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F,
  0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0,
  0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78,
  0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F,
  0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xC0, 0xF8, 0x7F, 0x0F, 0x9F, 0xF8, 0xFB,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01,
  0xFB, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xF8, 0xFE, 0x0F, 0xBF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3E, 0xFE, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8,
  0xF9, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF1, 0xE3, 0xFF, 0xBC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF0,
  0xFE, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFE, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x01, 0xF7,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xF8, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E,
  0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80,
  0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF8, 0x3C,
  0x1E, 0xF8, 0x7C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E,
  0x3E, 0x78, 0x7E, 0x3E, 0x7C, 0xFE, 0x3C, 0x3C, 0xEE, 0x3C, 0x3C, 0xEF,
  0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3D, 0xE7, 0x78, 0x3D, 0xC7,
  0x78, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0xFC, 0x00, 0x7D, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0xFC,
  0x1F, 0x83, 0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0xC0,
  0x3F, 0x1F, 0x81, 0xF8, 0x3E, 0x07, 0xC0, 0xFC, 0x3E, 0x01, 0xF9, 0xF8,
  0x03, 0xEF, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x78, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x1D, 0xFF, 0xC0, 0x3B,
  0xFF, 0xE0, 0xFF, 0x8F, 0xF7, 0xFE, 0x07, 0xFF, 0xB8, 0x07, 0xFF, 0x10,
  0x07, 0xFC, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 12, 10, 26, 7, -32 },
  { 40, 23, 31, 26, 1, -31 },
  { 130, 21, 39, 26, 3, -35 },
  { 233, 24, 31, 26, 1, -31 },
  { 326, 24, 31, 26, 2, -31 },
  { 419, 4, 11, 26, 10, -32 },
  { 425, 12, 44, 26, 7, -34 },
  { 491, 11, 44, 26, 7, -34 },
  { 552, 21, 22, 26, 3, -31 },
  { 610, 21, 22, 26, 2, -25 },
  { 668, 7, 13, 26, 7, -5 },
  { 680, 17, 4, 26, 5, -15 },
  { 689, 7, 7, 26, 10, -7 },
  { 696, 17, 34, 26, 5, -31 },
  { 769, 20, 31, 26, 3, -31 },
  { 847, 13, 31, 26, 4, -31 },
  { 898, 21, 31, 26, 2, -31 },
  { 980, 20, 31, 26, 2, -31 },
  { 1058, 23, 31, 26, 1, -31 },
  { 1148, 20, 31, 26, 3, -31 },
  { 1226, 20, 31, 26, 3, -31 },
  { 1304, 21, 31, 26, 2, -31 },
  { 1386, 20, 31, 26, 3, -31 },
  { 1464, 20, 31, 26, 2, -31 },
  { 1542, 7, 25, 26, 10, -25 },
  { 1564, 8, 33, 26, 10, -25 },
  { 1597, 19, 20, 26, 3, -23 },
  { 1645, 20, 13, 26, 3, -20 },
  { 1678, 18, 20, 26, 4, -23 },
  { 1723, 19, 31, 26, 4, -31 },
  { 1797, 24, 30, 26, 1, -30 },
  { 1887, 24, 31, 26, 1, -31 },
  { 1980, 21, 31, 26, 3, -31 },
  { 2062, 22, 31, 26, 2, -31 },
  { 2148, 21, 31, 26, 3, -31 },
  { 2230, 20, 31, 26, 3, -31 },
  { 2308, 20, 31, 26, 3, -31 },
  { 2386, 22, 31, 26, 2, -31 },
  { 2472, 20, 31, 26, 3, -31 },
  { 2550, 18, 31, 26, 4, -31 },
  { 2620, 21, 31, 26, 2, -31 },
  { 2702, 23, 31, 26, 3, -31 },
  { 2792, 19, 31, 26, 4, -31 },
  { 2866, 20, 31, 26, 3, -31 },
  { 2944, 20, 31, 26, 3, -31 },
  { 3022, 22, 31, 26, 2, -31 },
  { 3108, 21, 31, 26, 3, -31 },
  { 3190, 23, 36, 26, 2, -31 },
  { 3294, 22, 31, 26, 3, -31 },
  { 3380, 22, 31, 26, 2, -31 },
  { 3466, 24, 31, 26, 1, -31 },
  { 3559, 20, 31, 26, 3, -31 },
  { 3637, 24, 31, 26, 1, -31 },
  { 3730, 24, 31, 26, 1, -31 },
  { 3823, 24, 31, 26, 1, -31 },
  { 3916, 24, 31, 26, 1, -31 },
  { 4009, 22, 31, 26, 2, -31 },
  { 4095, 9, 42, 26, 9, -35 },
  { 4143, 17, 34, 26, 5, -31 },
  { 4216, 9, 42, 26, 8, -35 },
  { 4264, 17, 17, 26, 5, -31 },
  { 4301, 19, 4, 26, 3, 0 },
  { 4311, 9, 6, 26, 9, -31 },
  { 4318, 20, 23, 26, 3, -23 },
  { 4376, 20, 32, 26, 3, -32 },
  { 4456, 20, 23, 26, 3, -23 },
  { 4514, 19, 32, 26, 3, -32 },
  { 4590, 20, 23, 26, 3, -23 },
  { 4648, 21, 33, 26, 3, -33 },
  { 4735, 20, 32, 26, 3, -23 },
  { 4815, 20, 32, 26, 3, -32 },
  { 4895, 19, 31, 26, 4, -31 },
  { 4969, 13, 40, 26, 5, -31 },
  { 5034, 22, 32, 26, 3, -32 },
  { 5122, 19, 32, 26, 4, -32 },
  { 5198, 22, 23, 26, 2, -23 },
  { 5262, 20, 23, 26, 3, -23 },
  { 5320, 21, 23, 26, 2, -23 },
  { 5381, 20, 32, 26, 3, -23 },
  { 5461, 19, 32, 26, 3, -23 },
  { 5537, 17, 23, 26, 6, -23 },
  { 5586, 20, 23, 26, 3, -23 },
  { 5644, 20, 28, 26, 3, -28 },
  { 5714, 20, 23, 26, 3, -23 },
  { 5772, 22, 23, 26, 2, -23 },
  { 5836, 24, 23, 26, 1, -23 },
  { 5905, 22, 23, 26, 2, -23 },
  { 5969, 24, 32, 26, 1, -23 },
  { 6065, 20, 23, 26, 3, -23 },
  { 6123, 14, 42, 26, 7, -34 },
  { 6197, 4, 40, 26, 11, -31 },
  { 6217, 14, 42, 26, 7, -34 },
  { 6291, 23, 9, 26, 1, -17 },
};

const GFXfont RobotoMono_Medium43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium43pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_MEDIUM43PT7B_H_
