#ifndef _ROBOTOMONO_MEDIUM8PT7B_H_
#define _ROBOTOMONO_MEDIUM8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x32, 0xBE, 0xAE, 0x30, 0x5E, 0xC7, 0x7A, 0xC6, 0x98,
  0x66, 0x8C, 0x62, 0x98, 0xD9, 0x3C, 0xC0, 0x5A, 0x95, 0x95, 0x56, 0x4D,
  0x6A, 0x22, 0xF2, 0x70, 0xE0, 0x80, 0x25, 0x25, 0x00, 0xD6, 0xFB, 0xC0,
  0x75, 0x50, 0x69, 0x12, 0x4F, 0x69, 0x13, 0x97, 0x13, 0x55, 0xF1, 0xF3,
  0x1B, 0xC0, 0x24, 0x79, 0x97, 0xF1, 0x12, 0x24, 0xD6, 0xFB, 0xC0, 0x65,
  0x97, 0x16, 0x90, 0x98, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xF4, 0xA0,
  0x80, 0x33, 0x77, 0xAB, 0x30, 0x21, 0x14, 0xA7, 0x44, 0xCA, 0xAE, 0x9E,
  0x75, 0x88, 0x97, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00,
  0x75, 0x8B, 0x97, 0xB6, 0xFB, 0x40, 0xE9, 0x25, 0xC0, 0x11, 0x11, 0x97,
  0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0xB7, 0xFB, 0x40, 0xB6, 0xFB, 0x40,
  0x65, 0x99, 0x97, 0xEA, 0xBE, 0x88, 0x62, 0xA5, 0x19, 0x38, 0x20, 0xCA,
  0xAE, 0xAB, 0x75, 0x43, 0x97, 0xF9, 0x08, 0x42, 0x10, 0xB6, 0xDB, 0xC0,
  0x8A, 0x94, 0xA6, 0x10, 0xAD, 0x6D, 0xA5, 0x28, 0x9A, 0x88, 0x45, 0x6C,
  0x8A, 0x94, 0x42, 0x10, 0xF1, 0x22, 0x4F, 0xFF, 0x91, 0x24, 0x40, 0xFF,
  0x5A, 0x80, 0xE0, 0x80, 0xEE, 0xF0, 0x93, 0xDB, 0xC0, 0x78, 0x47, 0x11,
  0x79, 0x57, 0x7F, 0x47, 0x6B, 0xA4, 0x80, 0x79, 0x57, 0x56, 0x93, 0xDB,
  0x40, 0x43, 0x25, 0xC0, 0x4D, 0x57, 0x88, 0xAC, 0xCB, 0xC9, 0x25, 0xC0,
  0xFB, 0xBB, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF9, 0x00, 0x79, 0x57, 0x11,
  0xF2, 0x40, 0xF8, 0xF0, 0x5D, 0x26, 0xB6, 0xF0, 0xD5, 0x62, 0xAD, 0x94,
  0xA0, 0xD9, 0x19, 0xB0, 0xDA, 0x94, 0x42, 0x20, 0xEA, 0x70, 0x69, 0x44,
  0x98, 0xFF, 0xC9, 0x14, 0xB0, 0xF8,
};

const GFXglyph RobotoMono_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 5, 2, -6 },
  { 19, 2, 8, 5, 1, -6 },
  { 21, 2, 8, 5, 1, -6 },
  { 23, 4, 4, 5, 1, -6 },
  { 25, 4, 4, 5, 0, -5 },
  { 27, 2, 2, 5, 1, -1 },
  { 28, 3, 1, 5, 1, -3 },
  { 29, 1, 1, 5, 2, -1 },
  { 30, 3, 6, 5, 1, -6 },
  { 33, 3, 6, 5, 1, -6 },
  { 36, 2, 6, 5, 1, -6 },
  { 38, 4, 6, 5, 0, -6 },
  { 41, 4, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 1, 4, 5, 2, -4 },
  { 63, 1, 5, 5, 2, -4 },
  { 64, 3, 3, 5, 1, -4 },
  { 66, 3, 3, 5, 1, -4 },
  { 68, 3, 3, 5, 1, -4 },
  { 70, 3, 6, 5, 1, -6 },
  { 73, 5, 6, 5, 0, -6 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 4, 6, 5, 1, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 0, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 0, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 5, 7, 5, 0, -6 },
  { 131, 4, 6, 5, 1, -6 },
  { 134, 4, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 4, 6, 5, 0, -6 },
  { 163, 1, 8, 5, 2, -7 },
  { 164, 3, 6, 5, 1, -6 },
  { 167, 1, 8, 5, 2, -7 },
  { 168, 3, 3, 5, 1, -6 },
  { 170, 3, 1, 5, 1, 0 },
  { 171, 1, 1, 5, 2, -6 },
  { 172, 3, 4, 5, 1, -4 },
  { 174, 3, 6, 5, 1, -6 },
  { 177, 4, 4, 5, 0, -4 },
  { 179, 4, 6, 5, 0, -6 },
  { 182, 4, 4, 5, 0, -4 },
  { 184, 3, 6, 5, 1, -6 },
  { 187, 4, 6, 5, 0, -4 },
  { 190, 3, 6, 5, 1, -6 },
  { 193, 3, 6, 5, 1, -6 },
  { 196, 2, 8, 5, 1, -6 },
  { 198, 4, 6, 5, 1, -6 },
  { 201, 3, 6, 5, 1, -6 },
  { 204, 4, 4, 5, 0, -4 },
  { 206, 3, 4, 5, 1, -4 },
  { 208, 4, 4, 5, 0, -4 },
  { 210, 3, 6, 5, 1, -4 },
  { 213, 4, 6, 5, 0, -4 },
  { 216, 3, 4, 5, 1, -4 },
  { 218, 3, 4, 5, 1, -4 },
  { 220, 3, 5, 5, 1, -5 },
  { 222, 3, 4, 5, 1, -4 },
  { 224, 4, 4, 5, 0, -4 },
  { 226, 5, 4, 5, 0, -4 },
  { 229, 5, 4, 5, 0, -4 },
  { 232, 5, 6, 5, 0, -4 },
  { 236, 3, 4, 5, 1, -4 },
  { 238, 3, 7, 5, 1, -6 },
  { 241, 1, 8, 5, 2, -6 },
  { 242, 3, 7, 5, 1, -6 },
  { 245, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_Medium8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium8pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_MEDIUM8PT7B_H_
