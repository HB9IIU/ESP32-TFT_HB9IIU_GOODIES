#ifndef _ROBOTOMONO_MEDIUM21PT7B_H_
#define _ROBOTOMONO_MEDIUM21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xD8, 0x05, 0xF8, 0xCF, 0x3C, 0xF3, 0xCC, 0x06,
  0x60, 0x44, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x08, 0x81, 0x88, 0x19,
  0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x11, 0x03, 0x30, 0x33, 0x00, 0x06, 0x01,
  0x81, 0xF0, 0xFE, 0x71, 0xDC, 0x37, 0x0D, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0xD8, 0x37, 0x0D, 0xFF, 0x1F, 0x81, 0x00, 0x40, 0x78, 0x06,
  0xC0, 0xCC, 0xCC, 0xC8, 0x4D, 0x87, 0x90, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xDE, 0x0D, 0x31, 0xB3, 0x13, 0x30, 0x1B, 0x01, 0xE0, 0x1E, 0x07, 0xE1,
  0xCC, 0x39, 0x87, 0x30, 0x6C, 0x0F, 0x01, 0xE0, 0x7C, 0x7D, 0xCF, 0x1F,
  0xE1, 0xEE, 0x1C, 0xFF, 0x8F, 0xB8, 0xFF, 0xF0, 0x08, 0xCC, 0x66, 0x33,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0x63, 0x1C, 0x61, 0x84, 0x83, 0x06,
  0x0C, 0x30, 0x61, 0x87, 0x1C, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0xC3,
  0x18, 0xC2, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x32, 0xFF, 0xCF, 0x81, 0xC0,
  0xD8, 0x73, 0x18, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x6D, 0xFD, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x03, 0x81, 0x81, 0xC0, 0x1F, 0x0F, 0xE7, 0x1D, 0x87,
  0x60, 0xF8, 0x7E, 0x7F, 0xBB, 0xF8, 0xFC, 0x36, 0x0D, 0x87, 0x71, 0xCF,
  0xE1, 0xF0, 0x04, 0xFF, 0xFB, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC0, 0x3F, 0x1F, 0xEE, 0x3B, 0x06, 0xC1, 0xC0, 0x60, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x3F, 0x1F, 0xEE,
  0x1B, 0x87, 0x01, 0xC0, 0x61, 0xF8, 0x7C, 0x03, 0x80, 0x70, 0x1F, 0x07,
  0xE1, 0xDF, 0xE3, 0xF0, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xF8, 0x37,
  0x0C, 0xE3, 0x9C, 0x63, 0x98, 0x73, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00,
  0xE0, 0x3F, 0xCF, 0xF3, 0x01, 0xC0, 0x70, 0x1B, 0x87, 0xF9, 0xCF, 0x01,
  0xC0, 0x38, 0x0D, 0x83, 0x71, 0xDF, 0xE1, 0xF0, 0x07, 0x07, 0xC3, 0x81,
  0xC0, 0x60, 0x1B, 0xCF, 0xFB, 0xC7, 0xE1, 0xF8, 0x3E, 0x0D, 0x87, 0x71,
  0xCF, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0x1F, 0x0F,
  0xE7, 0x1D, 0x87, 0x61, 0xDC, 0x73, 0xF8, 0xFC, 0x73, 0x98, 0x7E, 0x0F,
  0x83, 0x61, 0xDF, 0xE3, 0xF0, 0x1E, 0x1F, 0xE7, 0x1B, 0x87, 0xE1, 0xF8,
  0x3E, 0x1D, 0x87, 0x7F, 0xCF, 0xF0, 0x18, 0x06, 0x07, 0x0F, 0xC3, 0xC0,
  0xEF, 0xE0, 0x00, 0x00, 0x0E, 0xFE, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x66,
  0x6E, 0xC8, 0x01, 0x87, 0xCF, 0xDF, 0x0C, 0x07, 0xC0, 0xFC, 0x1F, 0x01,
  0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0xC0, 0x78, 0x1F,
  0x01, 0xF0, 0x38, 0x7D, 0xF1, 0xE0, 0xC0, 0x00, 0x3E, 0x3F, 0xB8, 0xF8,
  0x30, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x80, 0xE0,
  0x70, 0x07, 0x81, 0xFC, 0x30, 0x62, 0x32, 0x67, 0xB4, 0xC9, 0x49, 0x94,
  0x99, 0x59, 0xB5, 0x9A, 0x4F, 0xE6, 0xEC, 0x60, 0x03, 0x98, 0x1F, 0x80,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x36, 0x0E, 0xE1, 0x8C, 0x31,
  0x8F, 0xF9, 0xFF, 0x3F, 0xEE, 0x0F, 0xC1, 0xF0, 0x18, 0xFF, 0x1F, 0xFB,
  0x87, 0x70, 0x6E, 0x0D, 0xC1, 0xBF, 0xE7, 0xFC, 0xE1, 0xDC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1D, 0xFF, 0xBF, 0xC0, 0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6E,
  0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x83, 0xF0, 0x67, 0x1C,
  0xFF, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0x8E, 0x70, 0xEE, 0x0D, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0xEE, 0x39, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0x07,
  0xF1, 0xC7, 0x70, 0x6E, 0x03, 0x80, 0x30, 0x06, 0x3F, 0xC7, 0xF8, 0x1F,
  0x83, 0xF0, 0x77, 0x0E, 0x7F, 0x87, 0xE0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x87, 0xE1, 0xDF,
  0xE3, 0xF0, 0xE0, 0xEE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0x70, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x0E, 0xE0,
  0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFB,
  0xFE, 0xFF, 0xEF, 0xBB, 0xEE, 0xFB, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0C, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3E, 0xCF, 0xB3, 0xE6,
  0xF9, 0xBE, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1C, 0x1F, 0x07, 0xF1, 0xC7,
  0x70, 0x6E, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0x70,
  0x67, 0x1C, 0x7F, 0x07, 0xC0, 0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0xFE, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x83, 0xF0, 0x67, 0x1C, 0x7F, 0x07, 0xE0, 0x0F, 0x00, 0xE0,
  0x08, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xF0, 0x7C, 0x3B, 0xFC, 0xFE,
  0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1C, 0x1F, 0x0F, 0xF9, 0xC7,
  0x30, 0x7E, 0x00, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3B, 0x83, 0xF0,
  0x76, 0x0E, 0xFF, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0D, 0x83, 0x71, 0xDF, 0xE1, 0xF0, 0xE0,
  0x77, 0x07, 0x70, 0x63, 0x0E, 0x30, 0xE3, 0x8C, 0x38, 0xC1, 0x9C, 0x1D,
  0x81, 0xD8, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE6, 0x36,
  0x73, 0x67, 0x36, 0x73, 0x67, 0x76, 0x77, 0x6D, 0x67, 0xD6, 0x3D, 0xE3,
  0xDE, 0x39, 0xE3, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xC0, 0xE0, 0xFC, 0x19,
  0xC7, 0x18, 0xC3, 0xB8, 0x3E, 0x07, 0x80, 0x70, 0x1F, 0x03, 0x60, 0xEE,
  0x18, 0xC7, 0x1D, 0xC1, 0xB8, 0x38, 0xE0, 0x77, 0x07, 0x30, 0xE3, 0x8E,
  0x18, 0xC1, 0xDC, 0x0D, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xFF,
  0xFF, 0xF8, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x3F, 0xF0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xF0, 0x18, 0x0E,
  0x07, 0x06, 0xC3, 0x63, 0x39, 0x8D, 0xC7, 0xFF, 0xFF, 0xC0, 0xE1, 0x86,
  0x3F, 0x1F, 0xE6, 0x1C, 0x07, 0x1F, 0xDF, 0xF6, 0x1F, 0x87, 0xE1, 0xDF,
  0xF3, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0xC7, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1F, 0xFD, 0xBC, 0x1F, 0x1F, 0xE7, 0x1D,
  0x83, 0xE0, 0x38, 0x0E, 0x01, 0x83, 0x71, 0xCF, 0xE1, 0xF0, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xCF, 0xF7, 0xFD, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xDC, 0x77, 0xFC, 0xFB, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0x70, 0xCF, 0xF1, 0xF8, 0x07, 0xE1, 0xFC, 0x30,
  0x0E, 0x01, 0xC1, 0xFF, 0xBF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3E, 0xDF, 0xF7, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0x71, 0xDF, 0xF3, 0xEC, 0x03, 0x21, 0xDF, 0xE3,
  0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xFB, 0xFF, 0x87, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x1C, 0x0E, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE,
  0x0E, 0x1C, 0x00, 0x07, 0xEF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0F, 0xFB, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xEC, 0x73, 0x38, 0xDC, 0x3E, 0x0F, 0xC3, 0xB8, 0xCE, 0x31, 0xCC, 0x3B,
  0x07, 0xFC, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x63, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x33, 0xE6,
  0x7C, 0xCF, 0x99, 0xF3, 0x3E, 0x67, 0xCC, 0xF9, 0x9F, 0x33, 0x80, 0xDF,
  0x7F, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60,
  0x3F, 0x1F, 0xE6, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x71, 0xDF,
  0xE1, 0xF0, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0xFF, 0xB7, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x3E, 0xDF, 0xF7, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF3, 0xFC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0xCF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x3F, 0x9F, 0xF6, 0x0D, 0x80, 0x7C, 0x0F, 0xE0, 0x3E, 0x03, 0x60,
  0xDF, 0xF3, 0xF8, 0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xC7, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0xC3, 0xF0, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xFF, 0xDF, 0x60, 0xE0, 0xFC,
  0x19, 0x87, 0x38, 0xC3, 0x18, 0x67, 0x0E, 0xC0, 0xD8, 0x1E, 0x01, 0xC0,
  0x38, 0x00, 0xE6, 0x36, 0x63, 0x67, 0x36, 0x76, 0x6F, 0x66, 0xD6, 0x3D,
  0x63, 0x9E, 0x39, 0xC3, 0x8C, 0x38, 0xC0, 0xE0, 0xEE, 0x38, 0xEE, 0x0D,
  0x81, 0xF0, 0x1C, 0x07, 0xC0, 0xD8, 0x3B, 0x8E, 0x3B, 0x83, 0x80, 0xE0,
  0xFC, 0x1D, 0x83, 0x38, 0xE3, 0x18, 0x77, 0x06, 0xC0, 0xD8, 0x1F, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0xF0, 0x1C, 0x00, 0x7F, 0xDF, 0xF0, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x0E, 0x18,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x31, 0xC3, 0xC0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x38, 0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0xC1,
  0x83, 0x87, 0x0E, 0x1C, 0x1C, 0x1C, 0x78, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0x63, 0x82, 0x00, 0x7C, 0x37, 0xE3, 0xC7, 0xE0, 0x1C,
};

const GFXglyph RobotoMono_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 5, 13, 3, -16 },
  { 11, 12, 15, 13, 0, -15 },
  { 34, 10, 19, 13, 1, -17 },
  { 58, 12, 15, 13, 0, -15 },
  { 81, 11, 15, 13, 1, -15 },
  { 102, 2, 6, 13, 5, -16 },
  { 104, 5, 22, 13, 4, -17 },
  { 118, 6, 22, 13, 3, -17 },
  { 135, 10, 10, 13, 2, -15 },
  { 148, 10, 11, 13, 1, -12 },
  { 162, 3, 6, 13, 4, -2 },
  { 165, 8, 2, 13, 3, -8 },
  { 167, 3, 3, 13, 5, -3 },
  { 169, 9, 16, 13, 2, -15 },
  { 187, 10, 15, 13, 1, -15 },
  { 206, 6, 15, 13, 2, -15 },
  { 218, 10, 15, 13, 1, -15 },
  { 237, 10, 15, 13, 1, -15 },
  { 256, 11, 15, 13, 1, -15 },
  { 277, 10, 15, 13, 1, -15 },
  { 296, 10, 15, 13, 1, -15 },
  { 315, 10, 15, 13, 1, -15 },
  { 334, 10, 15, 13, 1, -15 },
  { 353, 10, 15, 13, 1, -15 },
  { 372, 4, 12, 13, 5, -12 },
  { 378, 4, 16, 13, 5, -12 },
  { 386, 9, 9, 13, 2, -11 },
  { 397, 9, 7, 13, 2, -10 },
  { 405, 9, 9, 13, 2, -11 },
  { 416, 9, 15, 13, 2, -15 },
  { 433, 12, 15, 13, 0, -15 },
  { 456, 11, 15, 13, 1, -15 },
  { 477, 11, 15, 13, 1, -15 },
  { 498, 11, 15, 13, 1, -15 },
  { 519, 11, 15, 13, 1, -15 },
  { 540, 9, 15, 13, 2, -15 },
  { 557, 9, 15, 13, 2, -15 },
  { 574, 11, 15, 13, 1, -15 },
  { 595, 10, 15, 13, 1, -15 },
  { 614, 9, 15, 13, 2, -15 },
  { 631, 10, 15, 13, 1, -15 },
  { 650, 12, 15, 13, 1, -15 },
  { 673, 9, 15, 13, 2, -15 },
  { 690, 10, 15, 13, 1, -15 },
  { 709, 10, 15, 13, 1, -15 },
  { 728, 11, 15, 13, 1, -15 },
  { 749, 10, 15, 13, 2, -15 },
  { 768, 11, 18, 13, 1, -15 },
  { 793, 10, 15, 13, 2, -15 },
  { 812, 11, 15, 13, 1, -15 },
  { 833, 12, 15, 13, 0, -15 },
  { 856, 10, 15, 13, 1, -15 },
  { 875, 12, 15, 13, 0, -15 },
  { 898, 12, 15, 13, 0, -15 },
  { 921, 11, 15, 13, 1, -15 },
  { 942, 12, 15, 13, 0, -15 },
  { 965, 11, 15, 13, 1, -15 },
  { 986, 5, 20, 13, 4, -17 },
  { 999, 9, 16, 13, 2, -15 },
  { 1017, 5, 20, 13, 4, -17 },
  { 1030, 9, 8, 13, 2, -15 },
  { 1039, 9, 2, 13, 2, 0 },
  { 1042, 5, 3, 13, 4, -15 },
  { 1044, 10, 11, 13, 1, -11 },
  { 1058, 9, 16, 13, 2, -16 },
  { 1076, 10, 11, 13, 1, -11 },
  { 1090, 10, 16, 13, 1, -16 },
  { 1110, 10, 11, 13, 1, -11 },
  { 1124, 11, 16, 13, 1, -16 },
  { 1146, 10, 15, 13, 1, -11 },
  { 1165, 9, 16, 13, 2, -16 },
  { 1183, 9, 15, 13, 2, -15 },
  { 1200, 7, 19, 13, 2, -15 },
  { 1217, 10, 16, 13, 2, -16 },
  { 1237, 9, 16, 13, 2, -16 },
  { 1255, 11, 11, 13, 1, -11 },
  { 1271, 9, 11, 13, 2, -11 },
  { 1284, 10, 11, 13, 1, -11 },
  { 1298, 9, 15, 13, 2, -11 },
  { 1315, 10, 15, 13, 1, -11 },
  { 1334, 8, 11, 13, 3, -11 },
  { 1345, 10, 11, 13, 1, -11 },
  { 1359, 10, 14, 13, 1, -14 },
  { 1377, 9, 11, 13, 2, -11 },
  { 1390, 11, 11, 13, 1, -11 },
  { 1406, 12, 11, 13, 0, -11 },
  { 1423, 11, 11, 13, 1, -11 },
  { 1439, 11, 15, 13, 1, -11 },
  { 1460, 10, 11, 13, 1, -11 },
  { 1474, 7, 20, 13, 3, -16 },
  { 1492, 2, 19, 13, 5, -15 },
  { 1497, 7, 20, 13, 3, -16 },
  { 1515, 12, 4, 13, 0, -8 },
};

const GFXfont RobotoMono_Medium21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium21pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_MEDIUM21PT7B_H_
