#ifndef _ROBOTOMONO_MEDIUM30PT7B_H_
#define _ROBOTOMONO_MEDIUM30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0xFF, 0xF0,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x03, 0x0C, 0x03, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xC0,
  0x38, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x1F, 0xF0, 0xFF,
  0xE3, 0xC7, 0x9E, 0x0F, 0x70, 0x1D, 0xC0, 0x77, 0x80, 0x1E, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x1D, 0xE0, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x30, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xC7, 0x10, 0xC7,
  0x18, 0xC7, 0x30, 0xC7, 0x30, 0xEE, 0x60, 0x7E, 0xE0, 0x38, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3E, 0x07, 0x7F, 0x06, 0x67, 0x0C,
  0xE3, 0x1C, 0xE3, 0x08, 0xE3, 0x00, 0xE3, 0x00, 0x7F, 0x00, 0x3E, 0x01,
  0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xCE, 0x03, 0xC7, 0x01, 0xE3, 0x80,
  0xF1, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xFC, 0x73, 0xDE, 0x39, 0xC7, 0x9D, 0xE1, 0xFE, 0xF0, 0x7E, 0x78,
  0x3F, 0x1E, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFE, 0x7C, 0xFF, 0xFF,
  0xF6, 0x01, 0x07, 0x0F, 0x0E, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70,
  0x38, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0xE0, 0xC0, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x06, 0x38,
  0xCF, 0xB7, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x80,
  0xE3, 0x83, 0x87, 0x83, 0x06, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x39, 0xCE,
  0x77, 0xB9, 0xDC, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x67, 0xBF, 0xFF,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x70, 0x3B, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x3F, 0xFD, 0xEF, 0xFE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x9F, 0xFE, 0x3F,
  0xF0, 0x3F, 0x80, 0x03, 0x87, 0xDF, 0xFF, 0xFF, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x03, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xE7, 0xC7, 0x03,
  0xDE, 0x07, 0xBC, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x01, 0x00, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCE, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x39, 0xE0, 0xF3, 0xFF, 0xE3, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xDE, 0x07, 0x3C, 0x0E, 0x78, 0x38, 0xF0, 0xE1, 0xE1,
  0xC3, 0xC7, 0x07, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1D, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE7, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xFC, 0x0F, 0xF0,
  0x3D, 0xE0, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x03, 0xE0, 0x3F, 0x81,
  0xFE, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3D, 0xF8, 0xEF, 0xF3,
  0xFF, 0xEF, 0x87, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x39, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x70, 0x79, 0xC0, 0xFF,
  0x03, 0xDC, 0x0E, 0x78, 0x78, 0xF3, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xF9,
  0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0x07, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0x3C, 0xF0,
  0x7B, 0xC0, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFE,
  0x1F, 0x7F, 0xFC, 0xFF, 0xE1, 0xF3, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x27, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x7F, 0xFF, 0x78, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xEE, 0x71, 0x00, 0x00, 0x08, 0x03,
  0xC0, 0x7E, 0x0F, 0xF3, 0xFC, 0x7F, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFE, 0x01, 0xF0, 0x01, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xC0, 0x3F, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xE0, 0x02, 0x00,
  0x00, 0x06, 0x01, 0xFF, 0x1F, 0xFD, 0xF1, 0xEF, 0x07, 0xF0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x07, 0xF0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x70, 0xC6, 0x63,
  0xF3, 0x67, 0x33, 0xC6, 0x33, 0xCE, 0x33, 0xCC, 0x33, 0xCC, 0x73, 0xCC,
  0x63, 0xCC, 0x63, 0xCC, 0x66, 0xCF, 0xFE, 0xE7, 0xBC, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x20, 0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x1C, 0xE0,
  0x0E, 0x78, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x78, 0x0E, 0x38, 0x07, 0x9C, 0x03, 0xDE,
  0x00, 0xEF, 0x00, 0x78, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF,
  0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF,
  0xE7, 0x83, 0xEF, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7B, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xC0, 0x0F, 0xF0,
  0x1F, 0xFC, 0x3E, 0x7C, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x1E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x83, 0xCF,
  0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xF0, 0x79,
  0xE1, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x1F, 0xE0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xB8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x03, 0xB8, 0x07, 0x78, 0x0E, 0xF0, 0x1C, 0xF0, 0x39, 0xFF, 0xF1,
  0xFF, 0xC0, 0xFF, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC1, 0xE7, 0xFF, 0x1F, 0xFC,
  0x1F, 0xC0, 0xF0, 0x1F, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0,
  0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xF3, 0xFE, 0xCD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x8C, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xF0, 0x3F,
  0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFE, 0xE3, 0xFB, 0x8F,
  0xE7, 0x3F, 0x9C, 0xFE, 0x7B, 0xF8, 0xEF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x03,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x78, 0x1C, 0x78, 0x1E, 0x70,
  0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C,
  0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xCF, 0x87, 0x81, 0xE3, 0xC0, 0xF1,
  0xC0, 0x38, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x3C,
  0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0x81, 0xEF, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0xF0, 0x3D,
  0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x1E, 0x1C, 0x3C, 0x3C, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xFF, 0x01, 0xE0, 0x00,
  0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x80, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78,
  0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC,
  0x1F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78,
  0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE1, 0xC7, 0xF1, 0xE3,
  0xB8, 0xF1, 0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x9E, 0x39, 0xCF, 0xBC, 0xEF,
  0xDE, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xDB, 0x8E, 0xCD, 0xC7, 0x66, 0xE3,
  0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC0, 0xF8, 0x0F, 0x3C, 0x0F, 0x0F, 0x07, 0x87,
  0x87, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7B, 0x80, 0x39,
  0xE0, 0x3C, 0x70, 0x3C, 0x3C, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xEF,
  0x00, 0xF8, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0xFF, 0xFF,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xF0,
  0x0F, 0x81, 0xF8, 0x1D, 0x83, 0x9C, 0x39, 0xC3, 0x8E, 0x70, 0xE7, 0x06,
  0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0xF0,
  0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBC, 0x1E, 0xF0, 0x38, 0x00, 0xE0, 0x3F,
  0x8F, 0xFE, 0x7F, 0xFB, 0xC0, 0xEF, 0x03, 0xB8, 0x0E, 0xF0, 0x7B, 0xFF,
  0xE7, 0xFF, 0xCF, 0xEF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3D, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xBC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFE, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0x7E, 0x00, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x0F, 0x78, 0x39, 0xFF, 0xE3, 0xFF, 0x03,
  0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC7, 0xEF, 0x3F, 0xFD, 0xFF, 0xF7, 0x87, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F,
  0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E,
  0x0E, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x19, 0xFF, 0xF3, 0xFF, 0x83, 0xF8, 0x00, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0x9C, 0xFF, 0xF7, 0xFF, 0xDE,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C,
  0x00, 0xF2, 0x07, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xFF,
  0xFB, 0xFF, 0xEF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x7F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0xBF, 0xEF, 0xF3,
  0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x1E, 0xF0, 0x79, 0xE1, 0xE3, 0xC7, 0x87, 0x9E, 0x0F,
  0x78, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFB, 0xC1, 0xE3, 0xC3, 0xC7,
  0xC7, 0x87, 0x8F, 0x07, 0x9E, 0x07, 0xBC, 0x0F, 0x80, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF,
  0xBC, 0xEF, 0xFE, 0xFF, 0xFF, 0xF3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3,
  0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3,
  0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xE3, 0xFF, 0xEF, 0xFF,
  0xBE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0x78, 0x79, 0xFF, 0xE3,
  0xFF, 0x03, 0xF0, 0xF7, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDE,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF3, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9C, 0x0F, 0x70, 0x3D, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x3D, 0xF1, 0xF3, 0xFF, 0x87,
  0xF8, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x7D, 0xFF,
  0xF3, 0xFD, 0xC7, 0xE7, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0xE1, 0x87, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0x73, 0xCE,
  0x77, 0xCE, 0x76, 0xEE, 0x76, 0x6E, 0x76, 0x6E, 0x36, 0x6C, 0x3E, 0x6C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x0F, 0x38, 0x1E,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x3C, 0x3C, 0x3C,
  0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC3, 0x81, 0xE1, 0xE0, 0xE0, 0x70, 0xF0, 0x3C, 0x70, 0x0E, 0x78, 0x07,
  0xB8, 0x03, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x83, 0xC3, 0xC1, 0xC0,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x87, 0x87, 0x83, 0xC0,
  0xF8, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3C,
  0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0,
  0x70, 0x0F, 0x81, 0xF0, 0x7C, 0x3C, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x80, 0x3C, 0x00, 0x7F,
  0x07, 0xFF, 0x87, 0xE3, 0xFF, 0xC1, 0xFE, 0x40, 0x7C,
};

const GFXglyph RobotoMono_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 21, 18, 7, -21 },
  { 12, 8, 8, 18, 5, -23 },
  { 20, 16, 21, 18, 1, -21 },
  { 62, 14, 28, 18, 2, -25 },
  { 111, 16, 22, 18, 1, -22 },
  { 155, 17, 22, 18, 1, -22 },
  { 202, 3, 8, 18, 7, -23 },
  { 205, 8, 31, 18, 5, -24 },
  { 236, 8, 31, 18, 5, -24 },
  { 267, 15, 14, 18, 2, -21 },
  { 294, 14, 16, 18, 2, -18 },
  { 322, 5, 9, 18, 5, -3 },
  { 328, 12, 3, 18, 4, -11 },
  { 333, 5, 5, 18, 7, -5 },
  { 337, 12, 23, 18, 3, -21 },
  { 372, 14, 22, 18, 2, -22 },
  { 411, 9, 21, 18, 3, -21 },
  { 435, 15, 22, 18, 1, -22 },
  { 477, 15, 22, 18, 1, -22 },
  { 519, 15, 21, 18, 1, -21 },
  { 559, 14, 21, 18, 2, -21 },
  { 596, 14, 21, 18, 2, -21 },
  { 633, 15, 21, 18, 1, -21 },
  { 673, 14, 22, 18, 2, -22 },
  { 712, 14, 22, 18, 2, -22 },
  { 751, 5, 17, 18, 7, -17 },
  { 762, 5, 23, 18, 7, -17 },
  { 777, 13, 14, 18, 2, -16 },
  { 800, 14, 9, 18, 2, -14 },
  { 816, 14, 14, 18, 2, -16 },
  { 841, 13, 22, 18, 3, -22 },
  { 877, 16, 21, 18, 1, -21 },
  { 919, 17, 21, 18, 1, -21 },
  { 964, 15, 21, 18, 2, -21 },
  { 1004, 16, 22, 18, 1, -22 },
  { 1048, 15, 21, 18, 2, -21 },
  { 1088, 14, 21, 18, 2, -21 },
  { 1125, 14, 21, 18, 2, -21 },
  { 1162, 15, 22, 18, 1, -22 },
  { 1204, 14, 21, 18, 2, -21 },
  { 1241, 12, 21, 18, 3, -21 },
  { 1273, 14, 21, 18, 2, -21 },
  { 1310, 16, 21, 18, 2, -21 },
  { 1352, 14, 21, 18, 2, -21 },
  { 1389, 14, 21, 18, 2, -21 },
  { 1426, 14, 21, 18, 2, -21 },
  { 1463, 16, 22, 18, 1, -22 },
  { 1507, 15, 21, 18, 2, -21 },
  { 1547, 17, 26, 18, 1, -22 },
  { 1603, 15, 21, 18, 2, -21 },
  { 1643, 16, 22, 18, 1, -22 },
  { 1687, 16, 21, 18, 1, -21 },
  { 1729, 14, 21, 18, 2, -21 },
  { 1766, 16, 21, 18, 1, -21 },
  { 1808, 17, 21, 18, 1, -21 },
  { 1853, 17, 21, 18, 1, -21 },
  { 1898, 16, 21, 18, 1, -21 },
  { 1940, 15, 21, 18, 1, -21 },
  { 1980, 6, 30, 18, 6, -25 },
  { 2003, 12, 23, 18, 3, -21 },
  { 2038, 6, 30, 18, 6, -25 },
  { 2061, 12, 11, 18, 3, -21 },
  { 2078, 14, 3, 18, 2, 0 },
  { 2084, 7, 4, 18, 6, -22 },
  { 2088, 14, 16, 18, 2, -16 },
  { 2116, 14, 23, 18, 2, -23 },
  { 2157, 14, 16, 18, 2, -16 },
  { 2185, 14, 23, 18, 2, -23 },
  { 2226, 14, 16, 18, 2, -16 },
  { 2254, 15, 23, 18, 2, -23 },
  { 2298, 14, 22, 18, 2, -16 },
  { 2337, 14, 23, 18, 2, -23 },
  { 2378, 13, 22, 18, 3, -22 },
  { 2414, 10, 28, 18, 3, -22 },
  { 2449, 15, 23, 18, 2, -23 },
  { 2493, 13, 23, 18, 3, -23 },
  { 2531, 16, 16, 18, 1, -16 },
  { 2563, 14, 16, 18, 2, -16 },
  { 2591, 14, 16, 18, 2, -16 },
  { 2619, 14, 22, 18, 2, -16 },
  { 2658, 14, 22, 18, 2, -16 },
  { 2697, 12, 16, 18, 4, -16 },
  { 2721, 14, 16, 18, 2, -16 },
  { 2749, 14, 20, 18, 2, -20 },
  { 2784, 14, 16, 18, 2, -16 },
  { 2812, 16, 16, 18, 1, -16 },
  { 2844, 16, 16, 18, 1, -16 },
  { 2876, 16, 16, 18, 1, -16 },
  { 2908, 17, 22, 18, 1, -16 },
  { 2955, 14, 16, 18, 2, -16 },
  { 2983, 9, 28, 18, 5, -23 },
  { 3015, 2, 27, 18, 8, -21 },
  { 3022, 10, 28, 18, 5, -23 },
  { 3057, 16, 6, 18, 1, -12 },
};

const GFXfont RobotoMono_Medium30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium30pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_MEDIUM30PT7B_H_
