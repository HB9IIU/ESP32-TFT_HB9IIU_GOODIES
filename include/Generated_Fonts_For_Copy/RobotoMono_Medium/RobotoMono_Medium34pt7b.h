#ifndef _ROBOTOMONO_MEDIUM34PT7B_H_
#define _ROBOTOMONO_MEDIUM34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x1B, 0x86, 0xE1,
  0x80, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x86,
  0x00, 0xE3, 0x80, 0x30, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xC3, 0x00,
  0x71, 0xC0, 0x18, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x83, 0xFF,
  0xFE, 0xFF, 0xFF, 0x83, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x30,
  0x07, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x78, 0x3E,
  0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0x13, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x1E, 0x7C, 0x1F,
  0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x71, 0xC0,
  0x0C, 0x38, 0x61, 0x87, 0x1C, 0x30, 0xE7, 0x07, 0x1C, 0xE0, 0xE7, 0x38,
  0x0F, 0xE6, 0x00, 0xF9, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0xFC, 0x03, 0xBF, 0xC0, 0xE7, 0x38, 0x1C, 0xC3,
  0x87, 0x38, 0x70, 0xC7, 0x0E, 0x08, 0x61, 0xC0, 0x0E, 0x70, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x01, 0xE3, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xDF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x83,
  0xCF, 0xF8, 0x7B, 0xEF, 0x8E, 0x78, 0xF9, 0xCF, 0x0F, 0x7B, 0xC0, 0xFF,
  0x7C, 0x1F, 0xC7, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xF3, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x01, 0xC1, 0xE1, 0xE1,
  0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0x80, 0x40, 0x40,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0,
  0x30, 0x10, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x81,
  0x81, 0xE1, 0x86, 0xFD, 0xBF, 0xFF, 0xFF, 0x0F, 0xF8, 0x03, 0xC0, 0x07,
  0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x3C, 0x38, 0x78, 0x3C, 0x18, 0x18, 0x00,
  0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0xF3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF1, 0xEF, 0xF3, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0xC1, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x80, 0x01, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xF8,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x80, 0x3D, 0xE0, 0x0E, 0x78, 0x07,
  0x9E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x87, 0x81, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x39, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7E, 0x7E, 0x18,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x01,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x71, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFE, 0x7E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x3E,
  0x1F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xEE,
  0x0F, 0xDE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0x79, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E,
  0x79, 0xCF, 0x38, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0xFE, 0x0F, 0xF8, 0xFF,
  0x87, 0xFC, 0x0F, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xFF,
  0x80, 0xF0, 0xF0, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x3E, 0x77, 0x1F, 0xCD,
  0x8F, 0x73, 0xE3, 0x18, 0xF9, 0xC6, 0x3E, 0x61, 0x8F, 0x18, 0x63, 0xC6,
  0x18, 0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0xE6, 0xE7, 0xFB, 0xB9, 0xFF,
  0xC6, 0x18, 0xE1, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x86, 0x01, 0xFF, 0xC0,
  0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xE3, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBF, 0xFF, 0x9F, 0xFF,
  0x0F, 0xFF, 0xE7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xF1,
  0xFF, 0xE0, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1,
  0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xFE, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x1E, 0x0F, 0xCF, 0x03, 0xE7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07,
  0xDE, 0x07, 0xCF, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDE,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7,
  0x80, 0x7B, 0xF0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0x7C, 0x3E, 0x7F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x01, 0xF3,
  0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1,
  0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xCF, 0x03, 0xE3, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3,
  0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x77, 0xFE, 0x77,
  0xF7, 0x77, 0xF7, 0xE7, 0xF7, 0xE7, 0xF3, 0xE7, 0xF3, 0xE7, 0xF3, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF,
  0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0x80, 0x07, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xDE, 0x01, 0xE7, 0x81, 0xF3, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xE1, 0xF0, 0x78, 0x1F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xCF,
  0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE,
  0x00, 0xF7, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x18, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0x00,
  0x80, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xF0, 0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x39, 0xE0, 0x07, 0xB8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xF0,
  0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xEF, 0x1F, 0x1D, 0xE3,
  0xE3, 0x9C, 0x7C, 0xF3, 0x8F, 0x9E, 0x73, 0xF3, 0xCF, 0x7E, 0x79, 0xEE,
  0xEE, 0x3D, 0xDD, 0xC7, 0xBB, 0xB8, 0x76, 0x77, 0x0F, 0xCE, 0xE1, 0xF9,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0xF8, 0x03, 0xEF, 0x80,
  0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x3C, 0x03, 0xC7,
  0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0xBE,
  0x01, 0xE3, 0xC0, 0x7C, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x0F,
  0x1E, 0x01, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF0,
  0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFE, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x78, 0x03, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0xE7, 0x87, 0x1C, 0x78,
  0xE3, 0x87, 0x9C, 0x1D, 0xC0, 0xFE, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xFC, 0x78, 0x3E, 0x78, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8,
  0x3E, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7, 0xF1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xFE, 0x1F, 0x7F, 0xFE, 0xEF, 0xF9, 0xCF, 0xE0, 0x07, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x78, 0x0F,
  0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x0F, 0xCF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xCF,
  0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x02, 0x7E, 0x0F, 0x3F, 0xFF, 0x1F, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0xEF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F,
  0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x00, 0x0F, 0x00, 0x0F,
  0x30, 0x1E, 0x38, 0x3E, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF3, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC1, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x01,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80,
  0xF0, 0x3C, 0x0F, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0xDF, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xEF,
  0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8,
  0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF7, 0xCF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xF0,
  0xE3, 0xF1, 0xDF, 0xFB, 0xFF, 0xF7, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x81, 0xF7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF,
  0x00, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8,
  0x00, 0xE7, 0xE1, 0xDF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xFE, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xEF, 0xE3, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0F, 0xCF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xBF, 0xFF, 0x7F, 0xDE,
  0x3F, 0x3C, 0xF8, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x3C,
  0x0F, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x0E, 0x1E, 0x03, 0xC7,
  0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0xE1, 0xFC, 0x1C, 0x3B,
  0xC7, 0x87, 0x78, 0xF0, 0xEF, 0x1E, 0x3C, 0xE3, 0xE7, 0x9C, 0xFC, 0xE3,
  0x9F, 0x9C, 0x73, 0xB3, 0x8F, 0x66, 0x70, 0xEC, 0xEE, 0x1F, 0x9F, 0x83,
  0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x03,
  0xC1, 0xC0, 0xF8, 0x0F, 0xBC, 0x07, 0x8F, 0x07, 0x87, 0xC7, 0xC1, 0xE3,
  0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8, 0xF8, 0xF8, 0x3E,
  0x78, 0x0F, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x3C, 0x0F,
  0x81, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0x87, 0xE0, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF8, 0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0xFC, 0x07, 0x80, 0x60, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x67, 0xFC, 0x1F, 0xFF, 0x87, 0xE1, 0xFF, 0xF0, 0x3F, 0xE4, 0x03, 0xF0,
  0x00, 0x20,
};

const GFXglyph RobotoMono_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 24, 20, 8, -24 },
  { 13, 10, 9, 20, 5, -26 },
  { 25, 18, 24, 20, 1, -24 },
  { 79, 17, 32, 20, 2, -28 },
  { 147, 19, 25, 20, 1, -25 },
  { 207, 19, 25, 20, 1, -25 },
  { 267, 3, 9, 20, 8, -26 },
  { 271, 9, 35, 20, 6, -27 },
  { 311, 9, 35, 20, 5, -27 },
  { 351, 16, 17, 20, 3, -24 },
  { 385, 16, 18, 20, 2, -20 },
  { 421, 5, 10, 20, 6, -4 },
  { 428, 14, 3, 20, 4, -12 },
  { 434, 5, 5, 20, 8, -5 },
  { 438, 13, 26, 20, 4, -24 },
  { 481, 16, 25, 20, 2, -25 },
  { 531, 10, 24, 20, 3, -24 },
  { 561, 17, 25, 20, 1, -25 },
  { 615, 16, 25, 20, 2, -25 },
  { 665, 18, 24, 20, 1, -24 },
  { 719, 16, 24, 20, 2, -24 },
  { 767, 16, 24, 20, 2, -24 },
  { 815, 17, 24, 20, 1, -24 },
  { 866, 16, 25, 20, 2, -25 },
  { 916, 16, 25, 20, 2, -25 },
  { 966, 6, 19, 20, 8, -19 },
  { 981, 6, 25, 20, 8, -19 },
  { 1000, 14, 15, 20, 3, -18 },
  { 1027, 15, 11, 20, 3, -16 },
  { 1048, 15, 15, 20, 3, -18 },
  { 1077, 15, 25, 20, 3, -25 },
  { 1124, 18, 24, 20, 1, -24 },
  { 1178, 19, 24, 20, 1, -24 },
  { 1235, 17, 24, 20, 2, -24 },
  { 1286, 17, 25, 20, 2, -25 },
  { 1340, 17, 24, 20, 2, -24 },
  { 1391, 15, 24, 20, 3, -24 },
  { 1436, 15, 24, 20, 3, -24 },
  { 1481, 17, 25, 20, 2, -25 },
  { 1535, 16, 24, 20, 2, -24 },
  { 1583, 14, 24, 20, 3, -24 },
  { 1625, 16, 24, 20, 2, -24 },
  { 1673, 18, 24, 20, 2, -24 },
  { 1727, 15, 24, 20, 3, -24 },
  { 1772, 16, 24, 20, 2, -24 },
  { 1820, 16, 24, 20, 2, -24 },
  { 1868, 17, 25, 20, 2, -25 },
  { 1922, 16, 24, 20, 3, -24 },
  { 1970, 19, 29, 20, 1, -25 },
  { 2039, 16, 24, 20, 3, -24 },
  { 2087, 17, 25, 20, 2, -25 },
  { 2141, 19, 24, 20, 1, -24 },
  { 2198, 16, 24, 20, 2, -24 },
  { 2246, 19, 24, 20, 1, -24 },
  { 2303, 19, 24, 20, 1, -24 },
  { 2360, 19, 24, 20, 1, -24 },
  { 2417, 19, 24, 20, 1, -24 },
  { 2474, 17, 24, 20, 2, -24 },
  { 2525, 7, 33, 20, 7, -28 },
  { 2554, 13, 26, 20, 4, -24 },
  { 2597, 7, 33, 20, 7, -28 },
  { 2626, 13, 13, 20, 4, -24 },
  { 2648, 16, 3, 20, 2, 0 },
  { 2654, 7, 5, 20, 7, -25 },
  { 2659, 16, 18, 20, 2, -18 },
  { 2695, 15, 26, 20, 3, -26 },
  { 2744, 16, 18, 20, 2, -18 },
  { 2780, 16, 26, 20, 2, -26 },
  { 2832, 16, 18, 20, 2, -18 },
  { 2868, 17, 26, 20, 2, -26 },
  { 2924, 16, 25, 20, 2, -18 },
  { 2974, 15, 26, 20, 3, -26 },
  { 3023, 15, 25, 20, 3, -25 },
  { 3070, 10, 32, 20, 4, -25 },
  { 3110, 16, 26, 20, 3, -26 },
  { 3162, 15, 26, 20, 3, -26 },
  { 3211, 18, 18, 20, 1, -18 },
  { 3252, 15, 18, 20, 3, -18 },
  { 3286, 17, 18, 20, 2, -18 },
  { 3325, 15, 25, 20, 3, -18 },
  { 3372, 16, 25, 20, 2, -18 },
  { 3422, 13, 18, 20, 5, -18 },
  { 3452, 16, 18, 20, 2, -18 },
  { 3488, 16, 22, 20, 2, -22 },
  { 3532, 15, 18, 20, 3, -18 },
  { 3566, 18, 18, 20, 1, -18 },
  { 3607, 19, 18, 20, 1, -18 },
  { 3650, 17, 18, 20, 2, -18 },
  { 3689, 19, 25, 20, 1, -18 },
  { 3749, 17, 18, 20, 2, -18 },
  { 3788, 11, 33, 20, 5, -27 },
  { 3834, 3, 31, 20, 9, -24 },
  { 3846, 12, 33, 20, 5, -27 },
  { 3896, 18, 8, 20, 1, -14 },
};

const GFXfont RobotoMono_Medium34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium34pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_MEDIUM34PT7B_H_
