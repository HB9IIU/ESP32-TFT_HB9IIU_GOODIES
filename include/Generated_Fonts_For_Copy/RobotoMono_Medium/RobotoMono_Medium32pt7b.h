#ifndef _ROBOTOMONO_MEDIUM32PT7B_H_
#define _ROBOTOMONO_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00,
  0x00, 0xEF, 0xFD, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F,
  0x86, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x30, 0xC0,
  0x38, 0x60, 0x1C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0x0C, 0x01, 0x86,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x01, 0x86, 0x01, 0xC3, 0x00,
  0xE3, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x1E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x3C, 0x00, 0x3F, 0x80, 0x0E, 0x70, 0x03, 0x0C, 0x30, 0xC3, 0x1C, 0x30,
  0xC6, 0x0C, 0x73, 0x83, 0x9C, 0xC0, 0x7E, 0x70, 0x0F, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE3, 0x80, 0x33, 0xF0, 0x1D, 0xFE,
  0x06, 0x71, 0x83, 0x98, 0x71, 0xC6, 0x1C, 0x31, 0xC7, 0x00, 0x71, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x78,
  0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0x71, 0xE0, 0x1E, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xC3, 0x8F, 0xF8, 0xE7,
  0x9E, 0x39, 0xC3, 0xCE, 0xF0, 0x7F, 0xBC, 0x1F, 0xCF, 0x03, 0xF1, 0xE0,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x7C, 0xFF, 0xFF, 0xFF, 0x01,
  0x81, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x02, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x03, 0x83, 0x83, 0x81, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC0, 0x71, 0x86, 0x7D,
  0xBF, 0xFF, 0xFF, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x0E,
  0x78, 0x3C, 0x3C, 0x1C, 0x1C, 0x08, 0x10, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x7B, 0xDE, 0xF7, 0xB9, 0xDE, 0xE2, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF, 0xFE, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x83, 0xCE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0xFF, 0x71, 0xFF,
  0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC1,
  0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x40, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x78, 0x1E,
  0x7C, 0x1E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF0, 0x0F,
  0x78, 0x07, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x83, 0x83, 0xC3,
  0xC1, 0xE1, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x7B, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC1, 0xE3, 0xFF,
  0xC7, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF3, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xE3, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCE, 0x03, 0xDC, 0x07,
  0xBC, 0x0E, 0x78, 0x3C, 0x78, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x8F,
  0x07, 0x9C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1,
  0xF7, 0xFF, 0xC7, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xF7, 0xEF, 0xE7, 0xFF, 0x87, 0xF7, 0x01,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x81, 0xFE, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B,
  0xFF, 0xFF, 0x80, 0x39, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x8E, 0x38, 0xE3, 0x9E, 0x79, 0xCE, 0x18, 0x00, 0x18, 0x03,
  0xC0, 0x7E, 0x1F, 0xF3, 0xFC, 0x7F, 0x83, 0xE0, 0x1E, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xFC, 0x7F, 0x8F, 0xF8, 0x3F, 0x80, 0xF0,
  0x03, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F,
  0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xFC,
  0x03, 0xFF, 0x83, 0x80, 0xE3, 0x80, 0x31, 0x87, 0x9D, 0x8F, 0xE6, 0xC7,
  0x33, 0xE7, 0x39, 0xE3, 0x1C, 0xF1, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1E,
  0x71, 0x8F, 0x38, 0xC7, 0x9C, 0xE6, 0xE7, 0xFF, 0x71, 0xCF, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0xC1, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1D, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xE3, 0xC0, 0x38, 0x70,
  0x1E, 0x1C, 0x07, 0x07, 0x81, 0xC1, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC7, 0x80, 0x71, 0xE0, 0x1E, 0x70, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x3C, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xE0, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x1E, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x07, 0xBC,
  0x03, 0x9E, 0x03, 0xC7, 0x83, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xF1, 0xF8, 0xF0, 0x7C, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xCF, 0x01,
  0xE7, 0xC1, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0xC3, 0xE7, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0x8F,
  0x07, 0xC7, 0x87, 0xC3, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xEF, 0x03, 0xE7, 0xC1, 0xE1,
  0xE0, 0xF0, 0x78, 0x78, 0x3E, 0x3C, 0x0F, 0x1E, 0x07, 0xCF, 0x01, 0xF7,
  0x80, 0x7B, 0xC0, 0x3E, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFB, 0x9F, 0xF7, 0x77,
  0xFE, 0xEF, 0xED, 0xDF, 0xDF, 0x3F, 0xBE, 0x7F, 0x3C, 0xFE, 0x71, 0xFC,
  0xE3, 0xF9, 0xC7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xEE, 0x3F,
  0xDE, 0x7F, 0x9C, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0x80, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xC7, 0xC3, 0xC1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x0F, 0x78,
  0x07, 0x3C, 0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x07, 0xEE, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xF8, 0xF8, 0x3C, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0x71, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x79, 0xC0, 0x1E, 0x78, 0x07,
  0x9E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x78, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF,
  0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0xE1, 0xC3, 0xF8, 0x70, 0xFE, 0x1C, 0x3B,
  0xC7, 0x8E, 0xF1, 0xE3, 0xBC, 0xF8, 0xE7, 0x3E, 0x79, 0xCF, 0x9E, 0x73,
  0xE7, 0x9C, 0xDD, 0xC7, 0x37, 0x71, 0xDD, 0xDC, 0x7F, 0x77, 0x1F, 0xCD,
  0xC3, 0xF3, 0x70, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x81, 0xC1, 0xE0, 0xF8, 0x07, 0xDE,
  0x01, 0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x80, 0xF3,
  0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x0F, 0x3C, 0x07,
  0x8F, 0x83, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E, 0x01, 0xEF, 0x80,
  0x7C, 0xF0, 0x07, 0xFC, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00,
  0x77, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0x80, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x0E, 0xE0, 0x73,
  0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x9C, 0x1D, 0xE0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0x78, 0x70, 0x70, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF3, 0xC1, 0xEF, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xFE, 0x3F, 0xFC,
  0xF8, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDE, 0x0F, 0x9F, 0xFF, 0x3F,
  0xFF, 0x1F, 0x9E, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x79, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xF0, 0xF7,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xDF, 0xFF, 0xBF, 0xFE, 0x79, 0xF8,
  0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xFE, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xF7, 0x81,
  0xEF, 0x07, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xCF, 0x3F,
  0xFE, 0xFF, 0xFD, 0xE0, 0xFB, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF,
  0xFF, 0xCF, 0xFF, 0x8F, 0xEF, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1,
  0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x4F, 0x81, 0x8F, 0xFF, 0x8F, 0xFE, 0x0F,
  0xF0, 0x00, 0x1C, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF3, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0xDE, 0x7F, 0xFC, 0xFF, 0xFB, 0xE1, 0xF7, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xF7, 0x81, 0xEF, 0x07, 0xDF, 0xFF, 0x9F, 0xFF, 0x0F, 0xDE, 0x00,
  0x3C, 0x00, 0x79, 0x81, 0xE7, 0xCF, 0xCF, 0xFF, 0x07, 0xFC, 0x01, 0x80,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x79, 0xF8, 0xF7, 0xFD, 0xFF, 0xFB, 0xF0, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x7C, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF1,
  0xFE, 0x3F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x1F, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E,
  0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0x9E, 0x7F, 0xFF, 0xBF, 0xFF, 0xFE, 0x3C, 0xFF, 0x1C,
  0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC,
  0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F,
  0xF1, 0xC7, 0x80, 0xF3, 0xF1, 0xEF, 0xFB, 0xFF, 0xF7, 0xE1, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x0F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xEF,
  0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0xF3, 0xF1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xBF, 0xFF, 0x7F,
  0xFC, 0xF7, 0xF1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x0F, 0xDE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x81, 0xEF, 0x07, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xDE,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xE3, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xC0, 0xF7, 0x01,
  0xEF, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0x01, 0xEF, 0x03, 0xDF, 0xFF, 0x1F, 0xFE, 0x0F, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0x3C, 0xF0, 0x07, 0xBC,
  0x03, 0x9E, 0x03, 0xC7, 0x01, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0x70, 0x70,
  0x3C, 0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0xDE, 0x00, 0xEE, 0x00, 0x77,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xE1, 0xC3,
  0xF8, 0x70, 0xEE, 0x1C, 0x3B, 0x87, 0x8E, 0xF3, 0xE7, 0x9C, 0xD9, 0xC7,
  0x36, 0x71, 0xCD, 0x9C, 0x73, 0x77, 0x1D, 0xDD, 0xC3, 0xE3, 0x70, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE1, 0xE0, 0x70, 0x78, 0x1C, 0x1C,
  0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3C, 0x3C, 0x7C, 0x1E, 0x78, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07,
  0x81, 0xE1, 0xE0, 0x78, 0x70, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0x77, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x0F, 0x83, 0xC0, 0xFC, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xF8,
  0x1F, 0x07, 0xE1, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x0F, 0x81, 0xE0, 0x10, 0x00, 0x1C, 0x00,
  0x3F, 0x81, 0xFF, 0xE0, 0xFE, 0xFC, 0xFE, 0x1F, 0xF6, 0x07, 0xF8, 0x00,
  0xF0,
};

const GFXglyph RobotoMono_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 9, 8, 19, 5, -24 },
  { 25, 17, 23, 19, 1, -23 },
  { 74, 16, 29, 19, 2, -26 },
  { 132, 18, 23, 19, 1, -23 },
  { 184, 18, 23, 19, 1, -23 },
  { 236, 3, 8, 19, 7, -24 },
  { 239, 9, 32, 19, 5, -25 },
  { 275, 9, 32, 19, 5, -25 },
  { 311, 16, 16, 19, 2, -23 },
  { 343, 15, 17, 19, 2, -19 },
  { 375, 5, 10, 19, 6, -4 },
  { 382, 13, 4, 19, 4, -12 },
  { 389, 6, 5, 19, 7, -5 },
  { 393, 12, 25, 19, 4, -23 },
  { 431, 15, 23, 19, 2, -23 },
  { 475, 10, 23, 19, 3, -23 },
  { 504, 16, 23, 19, 1, -23 },
  { 550, 16, 23, 19, 1, -23 },
  { 596, 17, 23, 19, 1, -23 },
  { 645, 15, 23, 19, 2, -23 },
  { 689, 15, 23, 19, 2, -23 },
  { 733, 16, 23, 19, 1, -23 },
  { 779, 15, 23, 19, 2, -23 },
  { 823, 15, 23, 19, 2, -23 },
  { 867, 5, 18, 19, 8, -18 },
  { 879, 6, 24, 19, 7, -18 },
  { 897, 13, 14, 19, 3, -17 },
  { 920, 14, 10, 19, 3, -15 },
  { 938, 14, 14, 19, 3, -17 },
  { 963, 14, 23, 19, 3, -23 },
  { 1004, 17, 23, 19, 1, -23 },
  { 1053, 18, 23, 19, 1, -23 },
  { 1105, 16, 23, 19, 2, -23 },
  { 1151, 17, 23, 19, 1, -23 },
  { 1200, 16, 23, 19, 2, -23 },
  { 1246, 14, 23, 19, 3, -23 },
  { 1287, 14, 23, 19, 3, -23 },
  { 1328, 17, 23, 19, 1, -23 },
  { 1377, 15, 23, 19, 2, -23 },
  { 1421, 13, 23, 19, 3, -23 },
  { 1459, 15, 23, 19, 2, -23 },
  { 1503, 17, 23, 19, 2, -23 },
  { 1552, 14, 23, 19, 3, -23 },
  { 1593, 15, 23, 19, 2, -23 },
  { 1637, 15, 23, 19, 2, -23 },
  { 1681, 17, 23, 19, 1, -23 },
  { 1730, 15, 23, 19, 3, -23 },
  { 1774, 18, 27, 19, 1, -23 },
  { 1835, 16, 23, 19, 2, -23 },
  { 1881, 16, 23, 19, 2, -23 },
  { 1927, 17, 23, 19, 1, -23 },
  { 1976, 15, 23, 19, 2, -23 },
  { 2020, 17, 23, 19, 1, -23 },
  { 2069, 18, 23, 19, 1, -23 },
  { 2121, 18, 23, 19, 1, -23 },
  { 2173, 18, 23, 19, 1, -23 },
  { 2225, 16, 23, 19, 2, -23 },
  { 2271, 7, 31, 19, 6, -26 },
  { 2299, 12, 25, 19, 4, -23 },
  { 2337, 7, 31, 19, 6, -26 },
  { 2365, 13, 12, 19, 3, -23 },
  { 2385, 15, 3, 19, 2, 0 },
  { 2391, 7, 4, 19, 6, -23 },
  { 2395, 15, 17, 19, 2, -17 },
  { 2427, 15, 24, 19, 2, -24 },
  { 2472, 15, 17, 19, 2, -17 },
  { 2504, 15, 24, 19, 2, -24 },
  { 2549, 15, 17, 19, 2, -17 },
  { 2581, 16, 25, 19, 2, -25 },
  { 2631, 15, 24, 19, 2, -17 },
  { 2676, 15, 24, 19, 2, -24 },
  { 2721, 14, 23, 19, 3, -23 },
  { 2762, 11, 30, 19, 3, -23 },
  { 2804, 16, 24, 19, 2, -24 },
  { 2852, 14, 24, 19, 3, -24 },
  { 2894, 17, 17, 19, 1, -17 },
  { 2931, 15, 17, 19, 2, -17 },
  { 2963, 15, 17, 19, 2, -17 },
  { 2995, 15, 24, 19, 2, -17 },
  { 3040, 15, 24, 19, 2, -17 },
  { 3085, 12, 17, 19, 5, -17 },
  { 3111, 15, 17, 19, 2, -17 },
  { 3143, 15, 21, 19, 2, -21 },
  { 3183, 14, 17, 19, 3, -17 },
  { 3213, 17, 17, 19, 1, -17 },
  { 3250, 18, 17, 19, 1, -17 },
  { 3289, 16, 17, 19, 2, -17 },
  { 3323, 18, 24, 19, 1, -17 },
  { 3377, 15, 17, 19, 2, -17 },
  { 3409, 10, 31, 19, 5, -25 },
  { 3448, 3, 29, 19, 8, -23 },
  { 3459, 11, 31, 19, 5, -25 },
  { 3502, 17, 7, 19, 1, -13 },
};

const GFXfont RobotoMono_Medium32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium32pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_MEDIUM32PT7B_H_
