#ifndef _ROBOTOMONO_MEDIUM44PT7B_H_
#define _ROBOTOMONO_MEDIUM44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x47, 0xBF, 0xFF, 0xF7,
  0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1, 0xE0, 0x01, 0xC1, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0,
  0x03, 0x83, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x07, 0x87, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0xE0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x0F, 0x04, 0x07, 0x07, 0x83, 0x83, 0x83, 0xC3,
  0x81, 0xC1, 0xE3, 0xC0, 0xE0, 0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x3C, 0x78,
  0xE0, 0x0F, 0xFC, 0xF0, 0x03, 0xFC, 0x70, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x0F, 0x3F, 0xE0, 0x07, 0x3F, 0xF8,
  0x07, 0x9E, 0x3C, 0x03, 0x8E, 0x0E, 0x03, 0xC7, 0x07, 0x81, 0xC3, 0x83,
  0xC1, 0xC1, 0xC1, 0xE0, 0x20, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x9F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x1E, 0x3F, 0xFC, 0x1E, 0x7E, 0x7E, 0x1E, 0x7C, 0x7E, 0x3E, 0xFC, 0x3F,
  0x3E, 0xF8, 0x1F, 0xBE, 0xF8, 0x0F, 0xFC, 0xF8, 0x0F, 0xFC, 0xF8, 0x07,
  0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0x7E, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x40, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x70, 0x04, 0x40, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x01, 0x01, 0xE0, 0x07, 0x07, 0x83, 0x9F, 0x0E, 0x3E, 0x7F, 0xBB, 0xFB,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3D, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x87, 0x80, 0x3E, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0x80, 0xF0, 0x06, 0x01, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E, 0x7C, 0xF3, 0xE7, 0x86,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xDF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xDF, 0xF8, 0xF9,
  0xFF, 0xBE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E,
  0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x07, 0xC1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF,
  0x80, 0x3E, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x04, 0x00, 0x7B, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0x04, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x38,
  0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0,
  0x7E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3E, 0x7F, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x3E,
  0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xFC, 0x3F, 0x0F, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xF7, 0xE0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xF1, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xE0, 0x3E, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x18, 0x7E, 0x7F,
  0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x7E, 0x1C, 0x3E,
  0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x20, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1C,
  0x1C, 0x0E, 0x0E, 0x3C, 0x3F, 0x8E, 0x38, 0x7F, 0xC7, 0x78, 0xFD, 0xC7,
  0x70, 0xE1, 0xC7, 0x71, 0xE1, 0xC7, 0x71, 0xC1, 0xC7, 0xF1, 0xC1, 0xC7,
  0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87,
  0xE3, 0xC3, 0x86, 0xE3, 0xC3, 0x8E, 0xF3, 0xC7, 0x8E, 0xF1, 0xFF, 0xFC,
  0x71, 0xFD, 0xF8, 0x70, 0xF8, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7E, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x7C, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x07, 0xE3, 0xE0,
  0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0xFE, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0x7C,
  0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x7F, 0x3E, 0x0F, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x01, 0xF3,
  0xF0, 0x07, 0xCF, 0xE0, 0x3F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C,
  0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFB,
  0xE0, 0x0F, 0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E,
  0x07, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE3,
  0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF8,
  0x07, 0xF1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0,
  0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xE7,
  0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF7, 0xFE, 0xE7, 0xBF, 0xF7,
  0xBD, 0xFF, 0xBF, 0xCF, 0xFD, 0xFE, 0x7F, 0xE7, 0xF3, 0xFF, 0x3F, 0x1F,
  0xF9, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3C, 0x3F, 0xF1, 0xE1, 0xFF, 0x87,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFB, 0xC1, 0xFF, 0xBE, 0x1F, 0xFB, 0xE1,
  0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x87,
  0x9F, 0xF8, 0x7D, 0xFF, 0x83, 0xDF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFD, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x8F, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0x80, 0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xFB, 0xE0, 0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x7E, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x83, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x81, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x9F, 0x80,
  0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF1, 0xF8,
  0x0F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F,
  0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x07, 0xBE,
  0x0F, 0x83, 0xDF, 0x07, 0xC3, 0xE7, 0x83, 0xE1, 0xF3, 0xC3, 0xF0, 0xF9,
  0xF1, 0xF8, 0x7C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E, 0x3F, 0x8F,
  0x1F, 0x1F, 0xC7, 0x87, 0x9F, 0xE3, 0xC3, 0xCF, 0x73, 0xE1, 0xE7, 0xBD,
  0xF0, 0xF3, 0xDE, 0xF8, 0x7D, 0xCF, 0x7C, 0x3E, 0xE7, 0xBE, 0x1F, 0x73,
  0xDE, 0x0F, 0xF8, 0xEF, 0x03, 0xFC, 0x77, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x8F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBE, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F,
  0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0x1F, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFD, 0xF0, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE1, 0xC0, 0x3F, 0x7F, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x01,
  0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xBF, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xF0, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0x7F, 0xF0, 0xF8, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xDF, 0xE7, 0xE0, 0x3E, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x1F, 0x0F, 0xF9, 0xF1, 0xFF,
  0xDF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xDF, 0x07, 0xF9, 0xF0, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x02, 0x1F, 0x80, 0x18, 0xFE, 0x03, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFE, 0x18, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x9F,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7C, 0x03,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x10, 0x03, 0xF3, 0x80, 0x3E, 0x3C, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x81, 0xC0, 0xF8, 0xFF, 0x8F, 0x9F, 0xFC,
  0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x03, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x2F, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xDF, 0x80, 0xFE, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x01, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0xC1, 0xE7, 0xE7, 0xF3, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x0F, 0x8F, 0xBE, 0x1E, 0x0F, 0xFC,
  0x3C, 0x1F, 0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0x7F, 0xE1, 0xE0, 0xFF, 0xC3,
  0xC1, 0xFF, 0x87, 0x83, 0xFF, 0x0F, 0x07, 0xFE, 0x1E, 0x0F, 0xFC, 0x3C,
  0x1F, 0xF8, 0x78, 0x3F, 0xF0, 0xF0, 0x7F, 0xE1, 0xE0, 0xFF, 0xC3, 0xC1,
  0xFF, 0x87, 0x83, 0xFF, 0x0F, 0x07, 0xFE, 0x1E, 0x0F, 0xFC, 0x3C, 0x1F,
  0x00, 0x1C, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xFD, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x07, 0xCF, 0xF8, 0x3E,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F,
  0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0x9F, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0x9F, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xE0, 0x7F,
  0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x78, 0x7F,
  0xFC, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0x7B, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0xFF,
  0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xFF, 0x00,
  0x7C, 0xFC, 0x03, 0xE7, 0xFC, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x0F, 0xF1,
  0xF0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00,
  0x78, 0x7C, 0x00, 0xF8, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xF7, 0x80, 0x03,
  0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x0F, 0xF8,
  0x3C, 0x0F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3E, 0x1F, 0x78, 0x7E, 0x1F, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x7C, 0x7E, 0x1E, 0x7C, 0x7F, 0x1E, 0x3C,
  0xF7, 0x3E, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0xBC, 0x3C,
  0xE7, 0xBC, 0x1F, 0xE3, 0xBC, 0x1F, 0xC3, 0xB8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFE, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xFC,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8, 0xFC, 0x01, 0xFB,
  0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x03, 0xF7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07,
  0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xFE, 0xF0, 0x3F, 0xFE, 0xE0, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0,
};

const GFXglyph RobotoMono_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 12, 11, 26, 7, -33 },
  { 42, 24, 31, 26, 1, -31 },
  { 135, 21, 41, 26, 3, -36 },
  { 243, 25, 32, 26, 1, -32 },
  { 343, 24, 32, 26, 2, -32 },
  { 439, 4, 11, 26, 10, -33 },
  { 445, 11, 45, 26, 8, -35 },
  { 507, 12, 45, 26, 7, -35 },
  { 575, 22, 21, 26, 3, -31 },
  { 633, 22, 23, 26, 2, -26 },
  { 697, 7, 13, 26, 8, -5 },
  { 709, 18, 4, 26, 5, -16 },
  { 718, 7, 7, 26, 10, -7 },
  { 725, 17, 34, 26, 5, -31 },
  { 798, 20, 32, 26, 3, -32 },
  { 878, 13, 31, 26, 4, -31 },
  { 929, 21, 32, 26, 2, -32 },
  { 1013, 21, 32, 26, 2, -32 },
  { 1097, 23, 31, 26, 1, -31 },
  { 1187, 21, 31, 26, 3, -31 },
  { 1269, 20, 31, 26, 3, -31 },
  { 1347, 22, 31, 26, 2, -31 },
  { 1433, 20, 32, 26, 3, -32 },
  { 1513, 20, 32, 26, 3, -32 },
  { 1593, 8, 25, 26, 10, -25 },
  { 1618, 8, 33, 26, 10, -25 },
  { 1651, 19, 20, 26, 3, -24 },
  { 1699, 19, 13, 26, 4, -20 },
  { 1730, 19, 20, 26, 4, -24 },
  { 1778, 19, 32, 26, 4, -32 },
  { 1854, 24, 31, 26, 1, -31 },
  { 1947, 25, 31, 26, 1, -31 },
  { 2044, 22, 31, 26, 3, -31 },
  { 2130, 22, 32, 26, 2, -32 },
  { 2218, 21, 31, 26, 3, -31 },
  { 2300, 21, 31, 26, 3, -31 },
  { 2382, 20, 31, 26, 4, -31 },
  { 2460, 22, 32, 26, 2, -32 },
  { 2548, 20, 31, 26, 3, -31 },
  { 2626, 18, 31, 26, 4, -31 },
  { 2696, 21, 31, 26, 2, -31 },
  { 2778, 23, 31, 26, 3, -31 },
  { 2868, 20, 31, 26, 4, -31 },
  { 2946, 21, 31, 26, 3, -31 },
  { 3028, 20, 31, 26, 3, -31 },
  { 3106, 22, 32, 26, 2, -32 },
  { 3194, 21, 31, 26, 4, -31 },
  { 3276, 24, 37, 26, 2, -32 },
  { 3387, 22, 31, 26, 3, -31 },
  { 3473, 23, 32, 26, 2, -32 },
  { 3565, 24, 31, 26, 1, -31 },
  { 3658, 21, 31, 26, 3, -31 },
  { 3740, 24, 31, 26, 1, -31 },
  { 3833, 25, 31, 26, 1, -31 },
  { 3930, 25, 31, 26, 1, -31 },
  { 4027, 25, 31, 26, 1, -31 },
  { 4124, 22, 31, 26, 2, -31 },
  { 4210, 9, 43, 26, 9, -36 },
  { 4259, 17, 34, 26, 5, -31 },
  { 4332, 9, 43, 26, 9, -36 },
  { 4381, 17, 16, 26, 5, -31 },
  { 4415, 20, 4, 26, 3, 0 },
  { 4425, 9, 6, 26, 9, -32 },
  { 4432, 20, 24, 26, 3, -24 },
  { 4492, 21, 33, 26, 3, -33 },
  { 4579, 20, 24, 26, 3, -24 },
  { 4639, 20, 33, 26, 3, -33 },
  { 4722, 21, 24, 26, 3, -24 },
  { 4785, 22, 34, 26, 3, -34 },
  { 4879, 20, 33, 26, 3, -24 },
  { 4962, 20, 33, 26, 3, -33 },
  { 5045, 19, 32, 26, 5, -32 },
  { 5121, 14, 41, 26, 5, -32 },
  { 5193, 22, 33, 26, 3, -33 },
  { 5284, 20, 33, 26, 4, -33 },
  { 5367, 23, 24, 26, 2, -24 },
  { 5436, 20, 24, 26, 3, -24 },
  { 5496, 22, 24, 26, 2, -24 },
  { 5562, 21, 33, 26, 3, -24 },
  { 5649, 20, 33, 26, 3, -24 },
  { 5732, 17, 24, 26, 7, -24 },
  { 5783, 21, 24, 26, 3, -24 },
  { 5846, 20, 29, 26, 3, -29 },
  { 5919, 20, 23, 26, 3, -23 },
  { 5977, 23, 23, 26, 2, -23 },
  { 6044, 24, 23, 26, 1, -23 },
  { 6113, 23, 23, 26, 2, -23 },
  { 6180, 25, 32, 26, 1, -23 },
  { 6280, 21, 23, 26, 3, -23 },
  { 6341, 14, 42, 26, 7, -34 },
  { 6415, 3, 40, 26, 12, -31 },
  { 6430, 14, 42, 26, 7, -34 },
  { 6504, 24, 10, 26, 1, -18 },
};

const GFXfont RobotoMono_Medium44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium44pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_MEDIUM44PT7B_H_
