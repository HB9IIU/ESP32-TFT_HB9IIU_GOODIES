#ifndef _ROBOTOMONO_MEDIUM24PT7B_H_
#define _ROBOTOMONO_MEDIUM24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F, 0x60, 0xCF, 0x3C,
  0xF3, 0xCF, 0x30, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x7F,
  0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xCC, 0x3F, 0xFD, 0xFF, 0xE3, 0x18,
  0x18, 0xC0, 0xCC, 0x06, 0x60, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x1F,
  0xC7, 0xFC, 0xE3, 0xF8, 0x3F, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xC0, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0x1F, 0xC0, 0x40,
  0x08, 0x00, 0x7C, 0x01, 0xB8, 0x0C, 0x62, 0x31, 0x98, 0xC6, 0xC1, 0xFB,
  0x03, 0xD8, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x6F, 0x81, 0xB7, 0x0D,
  0x8C, 0x66, 0x30, 0x98, 0xC0, 0x37, 0x00, 0x78, 0x1F, 0x01, 0xFC, 0x0E,
  0x70, 0x63, 0x83, 0x1C, 0x1D, 0xC0, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xF1,
  0xDD, 0xCF, 0xC7, 0x6E, 0x1F, 0x70, 0xFB, 0xC7, 0x8F, 0xFE, 0x3F, 0x38,
  0xFF, 0xF0, 0x04, 0x31, 0x8E, 0x31, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x30,
  0xE1, 0x87, 0x1C, 0x71, 0xC3, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x31,
  0x8E, 0x30, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62, 0xF6, 0xE7, 0xFF, 0x0E,
  0x01, 0xF0, 0x1B, 0x83, 0x18, 0x71, 0xC1, 0x08, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x77, 0x77, 0x76, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x6F, 0xF7,
  0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x00, 0x3F, 0x0F, 0xF3,
  0xC7, 0x70, 0x6E, 0x0F, 0x81, 0xF0, 0xFE, 0x3F, 0xCE, 0xFF, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xBC, 0x73, 0xFC, 0x3F, 0x00, 0x02, 0x3F, 0xFF,
  0xBC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x1F, 0x87, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x8F, 0xF9, 0xC7, 0xF0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x7E, 0x0F, 0x80, 0x7C, 0x03, 0x80, 0x3E, 0x07, 0xC1, 0xDC, 0x3B, 0xFE,
  0x1F, 0x80, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xDC, 0x1D,
  0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0xE1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x3F, 0xC7, 0xFE, 0xE1, 0xC0, 0x1C, 0x03, 0x80, 0x7C, 0x0F, 0xC1, 0xFC,
  0x73, 0xFE, 0x3F, 0x00, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x6F, 0xC7, 0xFE, 0xF0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0x60, 0x77,
  0x0E, 0x78, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x3F, 0x0F, 0xF3, 0xC7,
  0x70, 0xEE, 0x0D, 0xC3, 0x9C, 0x73, 0xFC, 0x3F, 0x8E, 0x7B, 0x87, 0x70,
  0x7C, 0x0F, 0xC1, 0xFC, 0x73, 0xFE, 0x3F, 0x00, 0x1F, 0x83, 0xFC, 0x71,
  0xE7, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0xFE, 0x3F,
  0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0xC1, 0xF8, 0x1E, 0x00, 0x6F, 0xFE,
  0x00, 0x00, 0x00, 0x6F, 0xFE, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE7, 0x39, 0xCE, 0x67, 0x00, 0x00, 0x40, 0x70, 0xFC, 0xFC, 0xFC, 0x38,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xF0, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x38, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x30, 0x7C, 0xFE, 0xFC, 0x3C, 0x08, 0x00, 0x3F, 0x8F, 0xFB, 0xC7, 0x70,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x0C, 0x18,
  0xC0, 0x64, 0x79, 0x66, 0x4F, 0x62, 0x73, 0x33, 0x99, 0x9C, 0xCC, 0xA6,
  0x65, 0xB7, 0x6C, 0xEE, 0x60, 0x01, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xD8, 0x0E, 0xC0, 0x77, 0x03, 0x38,
  0x38, 0xC1, 0xC7, 0x0C, 0x38, 0xFF, 0xC7, 0xFF, 0x38, 0x3B, 0x81, 0xDC,
  0x07, 0xE0, 0x38, 0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEF, 0xFC, 0xFF, 0x8E, 0x1E, 0xE0, 0xEE, 0x06, 0xE0, 0x7E, 0x0E,
  0xE1, 0xEF, 0xFC, 0xFF, 0x80, 0x1F, 0xC3, 0xFE, 0x78, 0xE7, 0x07, 0xE0,
  0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x77, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xF3, 0x1F, 0x60,
  0xEC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xB1, 0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xC3, 0xFE, 0x78, 0xE7,
  0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x07, 0xE0, 0x77, 0x07, 0x78, 0x73, 0xFF, 0x1F, 0xC0, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xE0, 0x7E, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80, 0xE0, 0xFE, 0x1E,
  0xE1, 0xCE, 0x38, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xF7, 0x0E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0x70, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0xE1,
  0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0x37, 0xB6, 0xF7, 0xFE, 0xF7, 0xDE, 0xF9,
  0xDF, 0x33, 0xE6, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xE0,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xB1, 0xF6, 0x3E, 0xE7, 0xCC, 0xF9,
  0xDF, 0x1B, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xE0, 0x1F,
  0x83, 0xFC, 0x78, 0xE7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x78, 0xE3, 0xFC, 0x1F,
  0x80, 0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xEE,
  0x0E, 0xFF, 0xCF, 0xF8, 0xFC, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x1F, 0x81, 0xFE, 0x1E, 0x38, 0xE0, 0xEE, 0x07, 0x70,
  0x3B, 0x80, 0xDC, 0x06, 0xE0, 0x37, 0x01, 0xB8, 0x0D, 0xC0, 0xEE, 0x07,
  0x38, 0x39, 0xE3, 0x87, 0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x20,
  0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E,
  0xFF, 0xCF, 0xF8, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x0E,
  0xE0, 0xF0, 0x1F, 0xC3, 0xFE, 0x78, 0xF7, 0x07, 0x70, 0x37, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x3E, 0x07, 0x78,
  0xF3, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xFC, 0x73, 0xFC, 0x3F, 0x00, 0xE0, 0x3F, 0x03, 0xB8,
  0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x70, 0xC3, 0x87, 0x18, 0x39, 0xC1, 0xCE,
  0x07, 0x70, 0x3B, 0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0xC6, 0x3E, 0x39, 0xF1, 0xCF, 0xCE, 0x7E, 0xF3, 0x77, 0x9B, 0xBC, 0xCD,
  0xB6, 0x6D, 0xF3, 0x6F, 0x9A, 0x7C, 0xF3, 0xE7, 0x9E, 0x3C, 0x71, 0xE3,
  0x87, 0x1C, 0x38, 0xE0, 0xE0, 0x7B, 0x83, 0x9C, 0x38, 0x71, 0xC3, 0x9C,
  0x0E, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x3B, 0x83,
  0x9C, 0x1C, 0x71, 0xC3, 0xCE, 0x0E, 0xE0, 0x78, 0xE0, 0x3F, 0x03, 0x9C,
  0x1C, 0xE1, 0xC3, 0x8E, 0x1C, 0xE0, 0x77, 0x03, 0xB0, 0x0F, 0x80, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80,
  0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x1C, 0x0E, 0x0F, 0x06, 0xC7, 0x63, 0x39,
  0x8D, 0xC6, 0xC3, 0x80, 0xFF, 0xFF, 0xF0, 0xF1, 0x86, 0x1F, 0x0F, 0xF3,
  0xCF, 0x70, 0xE0, 0x1C, 0x3F, 0x9F, 0xF7, 0x0E, 0xC1, 0xD8, 0x3B, 0x8F,
  0x7F, 0xE7, 0xEE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDE, 0x3F,
  0xE7, 0xDE, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x8E, 0xFF, 0xDB, 0xF0, 0x0F, 0x83, 0xFC, 0x3D, 0xE7, 0x06, 0x70, 0x76,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xE7, 0x3F, 0xF7, 0xDF,
  0x70, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x77, 0x8F,
  0x3F, 0xF1, 0xF7, 0x0F, 0x81, 0xFC, 0x3D, 0xE7, 0x07, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x60, 0x07, 0x02, 0x78, 0x73, 0xFE, 0x0F, 0xC0, 0x00,
  0x80, 0xFC, 0x3F, 0x8F, 0x01, 0xC0, 0x38, 0x3F, 0xFF, 0xFF, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x0F, 0x73, 0xFF, 0x7D, 0xF7, 0x07, 0x70, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x60, 0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x20,
  0xE7, 0x1E, 0x3F, 0xC1, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xDE, 0x3F, 0xF7, 0xDE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x04, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x04, 0x1C, 0x38, 0x20, 0x0F,
  0xDF, 0xBF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x71, 0xFF, 0xBE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x1E, 0xE3, 0xCE, 0x78, 0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0E,
  0x70, 0xE3, 0x8E, 0x3C, 0xE1, 0xEE, 0x0F, 0xFE, 0x1F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0xCE, 0xED, 0xFF, 0xEF,
  0x7E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6,
  0x3E, 0x63, 0xE6, 0x30, 0xCF, 0x9B, 0xFB, 0xEF, 0x70, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x0F, 0x03,
  0xFC, 0x7D, 0xE7, 0x0E, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77,
  0x07, 0x78, 0xE3, 0xFC, 0x1F, 0x80, 0xCF, 0x1F, 0xF3, 0xCF, 0x70, 0xEE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0x7F, 0xEF, 0xF9,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x73, 0xFF, 0x7D, 0xF7,
  0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x07, 0x78, 0xF3,
  0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC7, 0xEF,
  0xFF, 0xFE, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x1F, 0x0F, 0xFB, 0xC7, 0x70, 0x7E, 0x00, 0xF0, 0x0F, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0x83, 0xBF, 0xE3, 0xF8, 0x18, 0x03, 0x00, 0x60, 0x7F,
  0xEF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x38, 0x07, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xBF, 0xF3, 0xEE, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0x0E, 0x30, 0xE3, 0x8C, 0x39, 0xC1, 0x9C, 0x1D,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE3, 0x1D, 0x8C, 0x76, 0x39,
  0x98, 0xE6, 0x77, 0x99, 0xDE, 0x63, 0x6B, 0x8D, 0x3E, 0x34, 0xF0, 0xF3,
  0xC3, 0xCF, 0x07, 0x1C, 0x18, 0x70, 0xF0, 0x7B, 0x83, 0x8E, 0x38, 0x3B,
  0x81, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x1F, 0x80, 0xEE, 0x0E, 0x38,
  0xE1, 0xEF, 0x07, 0x80, 0xE0, 0x3F, 0x03, 0xDC, 0x1C, 0xE0, 0xE3, 0x0E,
  0x1C, 0x70, 0xE3, 0x03, 0xB8, 0x1D, 0x80, 0x7C, 0x03, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x7F, 0xFF, 0xFE, 0x02, 0x0F, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x38, 0x70, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x1C, 0x0F, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x0F, 0x1F, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0x08, 0x00, 0xF8, 0x37,
  0xF1, 0x98, 0xFE, 0xC1, 0xF0,
};

const GFXglyph RobotoMono_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 6, 6, 14, 4, -18 },
  { 15, 13, 17, 14, 1, -17 },
  { 43, 11, 22, 14, 2, -20 },
  { 74, 14, 17, 14, 0, -17 },
  { 104, 13, 17, 14, 1, -17 },
  { 132, 2, 6, 14, 6, -18 },
  { 134, 6, 24, 14, 4, -19 },
  { 152, 6, 24, 14, 4, -19 },
  { 170, 12, 12, 14, 2, -17 },
  { 188, 12, 12, 14, 1, -14 },
  { 206, 4, 7, 14, 4, -3 },
  { 210, 9, 3, 14, 3, -9 },
  { 214, 4, 4, 14, 5, -4 },
  { 216, 9, 18, 14, 3, -17 },
  { 237, 11, 17, 14, 2, -17 },
  { 261, 7, 17, 14, 2, -17 },
  { 276, 12, 17, 14, 1, -17 },
  { 302, 11, 17, 14, 1, -17 },
  { 326, 12, 17, 14, 1, -17 },
  { 352, 11, 17, 14, 2, -17 },
  { 376, 12, 17, 14, 1, -17 },
  { 402, 12, 17, 14, 1, -17 },
  { 428, 11, 17, 14, 2, -17 },
  { 452, 12, 17, 14, 1, -17 },
  { 478, 4, 14, 14, 6, -14 },
  { 485, 5, 18, 14, 5, -14 },
  { 497, 10, 11, 14, 2, -13 },
  { 511, 11, 7, 14, 2, -11 },
  { 521, 10, 11, 14, 2, -13 },
  { 535, 11, 17, 14, 2, -17 },
  { 559, 13, 17, 14, 1, -17 },
  { 587, 13, 17, 14, 1, -17 },
  { 615, 12, 17, 14, 2, -17 },
  { 641, 12, 17, 14, 1, -17 },
  { 667, 11, 17, 14, 2, -17 },
  { 691, 11, 17, 14, 2, -17 },
  { 715, 11, 17, 14, 2, -17 },
  { 739, 12, 17, 14, 1, -17 },
  { 765, 11, 17, 14, 2, -17 },
  { 789, 10, 17, 14, 2, -17 },
  { 811, 12, 17, 14, 1, -17 },
  { 837, 12, 17, 14, 2, -17 },
  { 863, 11, 17, 14, 2, -17 },
  { 887, 11, 17, 14, 2, -17 },
  { 911, 11, 17, 14, 2, -17 },
  { 935, 12, 17, 14, 1, -17 },
  { 961, 12, 17, 14, 2, -17 },
  { 987, 13, 20, 14, 1, -17 },
  { 1020, 12, 17, 14, 2, -17 },
  { 1046, 12, 17, 14, 1, -17 },
  { 1072, 13, 17, 14, 1, -17 },
  { 1100, 11, 17, 14, 2, -17 },
  { 1124, 13, 17, 14, 1, -17 },
  { 1152, 13, 17, 14, 1, -17 },
  { 1180, 13, 17, 14, 1, -17 },
  { 1208, 13, 17, 14, 1, -17 },
  { 1236, 12, 17, 14, 1, -17 },
  { 1262, 5, 24, 14, 5, -20 },
  { 1277, 9, 18, 14, 3, -17 },
  { 1298, 5, 24, 14, 5, -20 },
  { 1313, 9, 9, 14, 3, -17 },
  { 1324, 10, 2, 14, 2, 0 },
  { 1327, 5, 3, 14, 5, -17 },
  { 1329, 11, 13, 14, 2, -13 },
  { 1347, 11, 18, 14, 2, -18 },
  { 1372, 12, 13, 14, 1, -13 },
  { 1392, 12, 18, 14, 1, -18 },
  { 1419, 12, 13, 14, 1, -13 },
  { 1439, 11, 19, 14, 2, -19 },
  { 1466, 12, 18, 14, 1, -13 },
  { 1493, 11, 18, 14, 2, -18 },
  { 1518, 11, 18, 14, 2, -18 },
  { 1543, 7, 23, 14, 3, -18 },
  { 1564, 12, 18, 14, 2, -18 },
  { 1591, 11, 18, 14, 2, -18 },
  { 1616, 12, 13, 14, 1, -13 },
  { 1636, 11, 13, 14, 2, -13 },
  { 1654, 12, 13, 14, 1, -13 },
  { 1674, 11, 18, 14, 2, -13 },
  { 1699, 12, 18, 14, 1, -13 },
  { 1726, 9, 13, 14, 4, -13 },
  { 1741, 11, 13, 14, 2, -13 },
  { 1759, 11, 16, 14, 2, -16 },
  { 1781, 11, 13, 14, 2, -13 },
  { 1799, 12, 13, 14, 1, -13 },
  { 1819, 14, 13, 14, 0, -13 },
  { 1842, 13, 13, 14, 1, -13 },
  { 1864, 13, 18, 14, 1, -13 },
  { 1894, 11, 13, 14, 2, -13 },
  { 1912, 8, 23, 14, 4, -19 },
  { 1935, 2, 22, 14, 6, -17 },
  { 1941, 8, 23, 14, 4, -19 },
  { 1964, 14, 5, 14, 0, -10 },
};

const GFXfont RobotoMono_Medium24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium24pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_MEDIUM24PT7B_H_
