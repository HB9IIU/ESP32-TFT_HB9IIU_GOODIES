#ifndef _ROBOTOMONO_MEDIUM10PT7B_H_
#define _ROBOTOMONO_MEDIUM10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCC, 0xFC, 0x28, 0xA7, 0xCC, 0xF9, 0x45, 0x00, 0x2F, 0x98,
  0x71, 0x9F, 0x20, 0xE2, 0xA7, 0x08, 0x3D, 0x51, 0xC0, 0x71, 0x67, 0x18,
  0x57, 0x67, 0xC0, 0xE0, 0x5A, 0xAA, 0x90, 0xA5, 0x55, 0xA0, 0x25, 0x5C,
  0xCD, 0x00, 0x66, 0xF6, 0x60, 0xE0, 0xF0, 0x70, 0x12, 0x22, 0x44, 0x48,
  0xF9, 0x9F, 0x99, 0xF0, 0x74, 0x92, 0x48, 0x7E, 0x42, 0x22, 0x31, 0xE0,
  0x7A, 0x42, 0x60, 0xE5, 0xE0, 0x19, 0xCE, 0xBF, 0x8C, 0x60, 0xF8, 0xE9,
  0x19, 0xF0, 0x68, 0xE9, 0x99, 0xF0, 0xF8, 0x44, 0x23, 0x11, 0x80, 0xF9,
  0x96, 0x99, 0xF0, 0xF9, 0x99, 0x73, 0x60, 0x70, 0x70, 0x70, 0x16, 0x3C,
  0xE3, 0xF0, 0xF0, 0xC3, 0x78, 0xF9, 0x12, 0x60, 0x60, 0x39, 0x5B, 0x6D,
  0xB6, 0x27, 0x00, 0x30, 0xC3, 0x1A, 0x79, 0x2C, 0x40, 0xF4, 0xA5, 0xE9,
  0xCF, 0xC0, 0x79, 0x2C, 0x70, 0xC5, 0x27, 0x80, 0xE4, 0xA7, 0x39, 0x4B,
  0x80, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x79, 0x2C, 0x36,
  0xC9, 0x27, 0xC0, 0x99, 0x9F, 0x99, 0x90, 0xF6, 0x66, 0x66, 0xF0, 0x11,
  0x11, 0x19, 0xF0, 0x9D, 0xB9, 0xCA, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0,
  0x9F, 0xFF, 0xD9, 0x90, 0x9D, 0xDF, 0xBB, 0x90, 0x79, 0x2C, 0xF3, 0xCD,
  0x27, 0x80, 0xF4, 0xE7, 0xE8, 0x42, 0x00, 0x79, 0x2C, 0xF3, 0xCD, 0x27,
  0x83, 0xF4, 0xA7, 0xEA, 0x4A, 0x60, 0x79, 0x34, 0x0E, 0x8D, 0x37, 0x80,
  0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24,
  0x9E, 0x30, 0xC3, 0x00, 0xB6, 0xD7, 0x9E, 0x79, 0xA4, 0x80, 0xCD, 0xA3,
  0x0C, 0x31, 0x2C, 0xC0, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x00, 0x78, 0x44,
  0x62, 0x23, 0xE0, 0xEA, 0xAA, 0xB0, 0x84, 0x46, 0x22, 0x11, 0xD5, 0x55,
  0x70, 0x66, 0x59, 0xF0, 0xC0, 0xF1, 0xF9, 0xF0, 0x88, 0x8F, 0x99, 0x9F,
  0xF9, 0x89, 0xF0, 0x11, 0x1F, 0x99, 0x9F, 0xF9, 0xF9, 0xF0, 0x3B, 0x11,
  0xE4, 0x21, 0x08, 0xF9, 0x99, 0xF9, 0xF0, 0x88, 0x8F, 0x99, 0x99, 0x20,
  0xE2, 0x22, 0xF0, 0x23, 0x92, 0x49, 0xE0, 0x84, 0x21, 0x6E, 0x72, 0xD3,
  0xE2, 0x22, 0x22, 0x2F, 0xFE, 0xFB, 0xEF, 0xBC, 0xF9, 0x99, 0x90, 0xF9,
  0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xFC, 0xCC,
  0xC0, 0xF8, 0x79, 0xF0, 0x44, 0xF4, 0x44, 0x70, 0x99, 0x99, 0xF0, 0xCD,
  0x23, 0x0C, 0x30, 0xB5, 0xE7, 0x9E, 0x48, 0x4C, 0xC3, 0x0E, 0xCC, 0xCD,
  0x23, 0x8C, 0x30, 0x86, 0x00, 0xF2, 0x6C, 0xF0, 0x29, 0x29, 0x92, 0x44,
  0xFF, 0x80, 0x93, 0x26, 0x96, 0x90, 0x66, 0x60,
};

const GFXglyph RobotoMono_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -8 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 3, 6, 2, -8 },
  { 28, 2, 10, 6, 2, -8 },
  { 31, 2, 10, 6, 2, -8 },
  { 34, 5, 5, 6, 1, -7 },
  { 38, 4, 5, 6, 1, -6 },
  { 41, 1, 3, 6, 2, -1 },
  { 42, 4, 1, 6, 1, -4 },
  { 43, 2, 2, 6, 2, -2 },
  { 44, 4, 8, 6, 1, -7 },
  { 48, 4, 7, 6, 1, -7 },
  { 52, 3, 7, 6, 1, -7 },
  { 55, 5, 7, 6, 0, -7 },
  { 60, 5, 7, 6, 0, -7 },
  { 65, 5, 7, 6, 0, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 5, 7, 6, 0, -7 },
  { 83, 4, 7, 6, 1, -7 },
  { 87, 4, 7, 6, 1, -7 },
  { 91, 2, 6, 6, 2, -6 },
  { 93, 2, 8, 6, 2, -6 },
  { 95, 4, 4, 6, 1, -5 },
  { 97, 4, 3, 6, 1, -5 },
  { 99, 4, 4, 6, 1, -5 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 6, 7, 6, 0, -7 },
  { 111, 6, 7, 6, 0, -7 },
  { 117, 5, 7, 6, 1, -7 },
  { 122, 6, 7, 6, 0, -7 },
  { 128, 5, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 6, 7, 6, 0, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 5, 7, 6, 1, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 4, 7, 6, 1, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 5, 7, 6, 1, -7 },
  { 187, 6, 8, 6, 0, -7 },
  { 193, 5, 7, 6, 1, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 4, 7, 6, 1, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 5, 7, 6, 0, -7 },
  { 243, 2, 10, 6, 2, -8 },
  { 246, 4, 8, 6, 1, -7 },
  { 250, 2, 10, 6, 2, -8 },
  { 253, 4, 4, 6, 1, -7 },
  { 255, 4, 1, 6, 1, 0 },
  { 256, 2, 1, 6, 2, -7 },
  { 257, 4, 5, 6, 1, -5 },
  { 260, 4, 8, 6, 1, -8 },
  { 264, 4, 5, 6, 1, -5 },
  { 267, 4, 8, 6, 1, -8 },
  { 271, 4, 5, 6, 1, -5 },
  { 274, 5, 8, 6, 1, -8 },
  { 279, 4, 7, 6, 1, -5 },
  { 283, 4, 8, 6, 1, -8 },
  { 287, 4, 7, 6, 1, -7 },
  { 291, 3, 9, 6, 1, -7 },
  { 295, 5, 8, 6, 1, -8 },
  { 300, 4, 8, 6, 1, -8 },
  { 304, 6, 5, 6, 0, -5 },
  { 308, 4, 5, 6, 1, -5 },
  { 311, 4, 5, 6, 1, -5 },
  { 314, 4, 7, 6, 1, -5 },
  { 318, 4, 7, 6, 1, -5 },
  { 322, 4, 5, 6, 1, -5 },
  { 325, 4, 5, 6, 1, -5 },
  { 328, 4, 7, 6, 1, -7 },
  { 332, 4, 5, 6, 1, -5 },
  { 335, 6, 5, 6, 0, -5 },
  { 339, 6, 5, 6, 0, -5 },
  { 343, 6, 5, 6, 0, -5 },
  { 347, 6, 7, 6, 0, -5 },
  { 353, 4, 5, 6, 1, -5 },
  { 356, 3, 10, 6, 2, -8 },
  { 360, 1, 9, 6, 3, -7 },
  { 362, 3, 10, 6, 2, -8 },
  { 366, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Medium10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium10pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_MEDIUM10PT7B_H_
