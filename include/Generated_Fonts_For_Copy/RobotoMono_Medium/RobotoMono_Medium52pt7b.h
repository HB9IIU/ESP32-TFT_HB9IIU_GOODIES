#ifndef _ROBOTOMONO_MEDIUM52PT7B_H_
#define _ROBOTOMONO_MEDIUM52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0x80, 0xFE,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x3E, 0x04, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE1, 0xE0,
  0x3C, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0xF0, 0x0F, 0x87, 0xC7, 0x80, 0x3F,
  0xFC, 0x78, 0x00, 0xFF, 0xC7, 0x80, 0x03, 0xFC, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0xC7, 0xF8, 0x00, 0x3C, 0x7F, 0xE0, 0x03, 0xE7, 0xFF, 0x80, 0x1E,
  0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0xF0, 0x0F, 0x1E, 0x07, 0x80, 0xF0, 0xF0,
  0x3C, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xC1, 0xE0, 0x78,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0x0F, 0xFF, 0x80, 0xF8, 0xFE, 0xFE, 0x07, 0xC7, 0xE3, 0xF8,
  0x7E, 0x7F, 0x0F, 0xC3, 0xF3, 0xF0, 0x7F, 0x1F, 0x3F, 0x81, 0xFD, 0xF9,
  0xF8, 0x07, 0xFF, 0xCF, 0xC0, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xE3, 0xF8,
  0x03, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x83, 0xFF, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F,
  0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x08, 0x60, 0x01, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x40, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x3C, 0x02,
  0x78, 0x1E, 0x0F, 0x3F, 0x8F, 0x1F, 0xFF, 0xF7, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1E,
  0x00, 0xF0, 0x03, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0xF8,
  0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE,
  0x7E, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF,
  0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0x3F, 0xFC, 0x7E, 0x3F, 0xFD, 0xFC, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xEF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0x7F, 0xE1, 0xFC, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFF,
  0x00, 0xFE, 0x3F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x01, 0xFE, 0x0C,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x3F, 0xE0, 0x7C, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF7, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xF7, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01,
  0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xF7, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F,
  0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07,
  0xFF, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xF1, 0xF8, 0x20, 0x1E, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0xDF, 0xE7,
  0xF8, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1,
  0xF0, 0xFC, 0x3E, 0x07, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0xE0, 0xF0, 0x7F, 0xC7, 0x8F,
  0x07, 0xFE, 0x1C, 0x78, 0x7F, 0xF0, 0xE3, 0x87, 0xC3, 0x87, 0x3C, 0x3C,
  0x1C, 0x3D, 0xE1, 0xE0, 0xE1, 0xEF, 0x1E, 0x0F, 0x0F, 0x70, 0xF0, 0x78,
  0x7F, 0x87, 0x83, 0xC3, 0xFC, 0x3C, 0x1E, 0x1D, 0xE1, 0xC0, 0xF0, 0xEF,
  0x1E, 0x07, 0x87, 0x78, 0xF0, 0x38, 0x3B, 0xC7, 0xC1, 0xC3, 0xDE, 0x1E,
  0x0E, 0x1C, 0x70, 0xF0, 0xF0, 0xE3, 0xC7, 0xFF, 0xCF, 0x1E, 0x1F, 0xFF,
  0xF0, 0xF0, 0xFE, 0x7F, 0x07, 0xC3, 0xE1, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x7F,
  0xE7, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x03, 0xF9, 0xF8, 0x0F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xC0, 0x3F, 0xE7, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x03,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x81, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x1F, 0xE3, 0xF8, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x7E,
  0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFF,
  0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x1F, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07,
  0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xF7, 0xFF, 0xF8, 0xFB, 0xFF, 0xBC, 0x7D, 0xFF, 0xDF,
  0x3C, 0xFF, 0xEF, 0xBE, 0x7F, 0xF3, 0xDF, 0x3F, 0xF9, 0xFF, 0x1F, 0xFC,
  0xFF, 0x8F, 0xFE, 0x3F, 0xC7, 0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0xE1, 0xFF,
  0xC7, 0xF0, 0xFF, 0xE1, 0xF0, 0x7F, 0xF0, 0xF8, 0x3F, 0xF8, 0x7C, 0x1F,
  0xFC, 0x1E, 0x1F, 0xFE, 0x0E, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFB, 0xE0, 0xFF, 0xFD, 0xF8, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0x3F,
  0x1F, 0xFF, 0x8F, 0x8F, 0xFF, 0xC7, 0xE7, 0xFF, 0xE1, 0xF3, 0xFF, 0xF0,
  0xFD, 0xFF, 0xF8, 0x3E, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xE0, 0x0F, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x43, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xF3,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x01, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xE7, 0xF0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0x3F, 0xFB,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0xFF,
  0xE0, 0x7C, 0x07, 0xFF, 0x03, 0xE0, 0x7E, 0xF8, 0x1F, 0x83, 0xF7, 0xC0,
  0xFC, 0x1F, 0xBE, 0x0F, 0xE0, 0xFD, 0xF8, 0x7F, 0x07, 0xEF, 0xC3, 0xF8,
  0x3E, 0x7E, 0x1F, 0xC1, 0xF3, 0xF0, 0xFF, 0x0F, 0x8F, 0x87, 0xF8, 0x7C,
  0x7C, 0x3F, 0xC7, 0xE3, 0xE3, 0xFE, 0x3F, 0x1F, 0x1F, 0xF1, 0xF8, 0xF8,
  0xF7, 0x8F, 0x87, 0xE7, 0xBE, 0x7C, 0x3F, 0x3D, 0xF3, 0xE1, 0xF9, 0xEF,
  0x9F, 0x07, 0xDF, 0x3C, 0xF8, 0x3E, 0xF9, 0xE7, 0xC1, 0xF7, 0x8F, 0x7E,
  0x0F, 0xBC, 0x7F, 0xF0, 0x7D, 0xE3, 0xFF, 0x03, 0xEF, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x83,
  0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xEF, 0xC0, 0x3E,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFC,
  0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x80, 0x7E, 0x7F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07,
  0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x07, 0xFC, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xCF, 0xC0, 0xFF, 0xC7, 0xF0, 0x04,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0x7F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x7F, 0x1F,
  0xF3, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xFF, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x80, 0x7F, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03,
  0xFE, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x41, 0xFC,
  0x00, 0x70, 0xFF, 0x00, 0x7C, 0x3F, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x10, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x01, 0xFF, 0x3F, 0x00, 0x10,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x7F, 0x1E, 0x00,
  0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x04, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0x0F, 0xC3, 0xFC, 0x03, 0xF1, 0xFE,
  0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFE, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xEF,
  0xC0, 0x03, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x3E, 0x1F,
  0x3F, 0xCF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC,
  0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83,
  0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0,
  0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F,
  0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07,
  0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF,
  0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x7F,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x81,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE,
  0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFE, 0x01, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFC, 0xFF,
  0xEF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFC,
  0x7F, 0xC0, 0xFC, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x1F, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xF7, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0x3F, 0x00,
  0x30, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xEF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xE0, 0x2F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0x1F, 0xFF, 0xBE, 0x3F,
  0xFC, 0x7C, 0x1F, 0xF0, 0xF8, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF,
  0x03, 0xE0, 0x7E, 0xF8, 0x1F, 0x03, 0xE7, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F,
  0xE0, 0xF9, 0xF0, 0x7F, 0x07, 0xCF, 0xC3, 0xF8, 0x7E, 0x3E, 0x1D, 0xC3,
  0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x78, 0xF8, 0x7C, 0x7B, 0xC7, 0xC3,
  0xE3, 0xDE, 0x3E, 0x0F, 0x9C, 0x71, 0xE0, 0x7D, 0xE3, 0xDF, 0x03, 0xEF,
  0x1E, 0xF8, 0x1F, 0x78, 0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x03, 0xDC, 0x1D,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xF3, 0xFF, 0xE0, 0x0F,
  0x7F, 0xFF, 0x81, 0xF7, 0xE7, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0xF0, 0x03, 0xFF, 0xC3, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0x00,
};

const GFXglyph RobotoMono_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 37, 31, 12, -37 },
  { 34, 14, 13, 31, 8, -39 },
  { 57, 29, 37, 31, 1, -37 },
  { 192, 24, 48, 31, 4, -43 },
  { 336, 29, 39, 31, 1, -38 },
  { 478, 29, 39, 31, 2, -38 },
  { 620, 5, 13, 31, 12, -39 },
  { 629, 14, 53, 31, 9, -41 },
  { 722, 14, 53, 31, 8, -41 },
  { 815, 25, 26, 31, 4, -37 },
  { 897, 25, 27, 31, 3, -31 },
  { 982, 8, 16, 31, 9, -6 },
  { 998, 21, 5, 31, 6, -19 },
  { 1012, 9, 9, 31, 11, -8 },
  { 1023, 20, 40, 31, 6, -37 },
  { 1123, 24, 39, 31, 4, -38 },
  { 1240, 15, 37, 31, 5, -37 },
  { 1310, 25, 37, 31, 2, -37 },
  { 1426, 25, 38, 31, 2, -37 },
  { 1545, 27, 37, 31, 2, -37 },
  { 1670, 24, 38, 31, 4, -37 },
  { 1784, 24, 38, 31, 3, -37 },
  { 1898, 26, 37, 31, 2, -37 },
  { 2019, 25, 38, 31, 3, -37 },
  { 2138, 24, 37, 31, 3, -37 },
  { 2249, 9, 31, 31, 12, -30 },
  { 2284, 10, 40, 31, 12, -30 },
  { 2334, 22, 24, 31, 4, -28 },
  { 2400, 24, 16, 31, 4, -24 },
  { 2448, 23, 24, 31, 4, -28 },
  { 2517, 23, 38, 31, 4, -38 },
  { 2627, 29, 37, 31, 1, -37 },
  { 2762, 30, 37, 31, 1, -37 },
  { 2901, 25, 37, 31, 4, -37 },
  { 3017, 27, 39, 31, 2, -38 },
  { 3149, 26, 37, 31, 3, -37 },
  { 3270, 24, 37, 31, 4, -37 },
  { 3381, 24, 37, 31, 4, -37 },
  { 3492, 27, 38, 31, 2, -37 },
  { 3621, 25, 37, 31, 3, -37 },
  { 3737, 21, 37, 31, 5, -37 },
  { 3835, 24, 38, 31, 3, -37 },
  { 3949, 27, 37, 31, 4, -37 },
  { 4074, 24, 37, 31, 4, -37 },
  { 4185, 25, 37, 31, 3, -37 },
  { 4301, 25, 37, 31, 3, -37 },
  { 4417, 27, 38, 31, 2, -37 },
  { 4546, 25, 37, 31, 4, -37 },
  { 4662, 28, 43, 31, 2, -37 },
  { 4813, 26, 37, 31, 4, -37 },
  { 4934, 26, 37, 31, 3, -37 },
  { 5055, 29, 37, 31, 1, -37 },
  { 5190, 25, 38, 31, 3, -37 },
  { 5309, 29, 37, 31, 1, -37 },
  { 5444, 29, 37, 31, 1, -37 },
  { 5579, 29, 37, 31, 1, -37 },
  { 5714, 29, 37, 31, 1, -37 },
  { 5849, 25, 37, 31, 3, -37 },
  { 5965, 11, 51, 31, 10, -43 },
  { 6036, 20, 40, 31, 6, -37 },
  { 6136, 11, 51, 31, 10, -43 },
  { 6207, 20, 20, 31, 6, -37 },
  { 6257, 23, 5, 31, 4, 0 },
  { 6272, 12, 7, 31, 10, -38 },
  { 6283, 25, 29, 31, 3, -28 },
  { 6374, 24, 40, 31, 4, -39 },
  { 6494, 24, 29, 31, 3, -28 },
  { 6581, 24, 40, 31, 3, -39 },
  { 6701, 25, 29, 31, 3, -28 },
  { 6792, 26, 40, 31, 3, -40 },
  { 6922, 24, 39, 31, 3, -28 },
  { 7039, 24, 39, 31, 4, -39 },
  { 7156, 23, 38, 31, 5, -38 },
  { 7266, 16, 49, 31, 6, -38 },
  { 7364, 26, 39, 31, 4, -39 },
  { 7491, 23, 39, 31, 5, -39 },
  { 7604, 27, 28, 31, 2, -28 },
  { 7699, 24, 28, 31, 4, -28 },
  { 7783, 25, 29, 31, 3, -28 },
  { 7874, 24, 39, 31, 4, -28 },
  { 7991, 24, 39, 31, 3, -28 },
  { 8108, 20, 28, 31, 8, -28 },
  { 8178, 24, 29, 31, 4, -28 },
  { 8265, 25, 35, 31, 3, -34 },
  { 8375, 23, 28, 31, 4, -27 },
  { 8456, 27, 27, 31, 2, -27 },
  { 8548, 29, 27, 31, 1, -27 },
  { 8646, 28, 27, 31, 2, -27 },
  { 8741, 29, 38, 31, 1, -27 },
  { 8879, 25, 27, 31, 3, -27 },
  { 8964, 17, 50, 31, 8, -41 },
  { 9071, 4, 47, 31, 14, -37 },
  { 9095, 17, 50, 31, 8, -41 },
  { 9202, 28, 11, 31, 1, -21 },
};

const GFXfont RobotoMono_Medium52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium52pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_MEDIUM52PT7B_H_
