#ifndef _ROBOTOMONO_MEDIUM23PT7B_H_
#define _ROBOTOMONO_MEDIUM23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6C, 0x00, 0xFF, 0xE7, 0xCF, 0x1E, 0x3C, 0x60,
  0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0x8C, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x98,
  0x19, 0x81, 0x18, 0xFF, 0xE3, 0x10, 0x33, 0x03, 0x30, 0x23, 0x06, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x1F, 0xC7, 0xFD, 0xC3, 0xB8, 0x37, 0x07, 0xF0,
  0x0F, 0x00, 0xFC, 0x07, 0xC0, 0x3C, 0x01, 0xB0, 0x3F, 0x07, 0xE1, 0xCF,
  0xF8, 0xFC, 0x06, 0x00, 0xC0, 0x10, 0x03, 0xE0, 0x19, 0x81, 0x8C, 0xCC,
  0x6C, 0x33, 0x61, 0xF6, 0x02, 0x30, 0x03, 0x00, 0x10, 0x01, 0xBC, 0x09,
  0xF0, 0xD9, 0x8C, 0xCC, 0x26, 0x60, 0x3B, 0x00, 0xF0, 0x06, 0x00, 0xF8,
  0x0F, 0xE0, 0x63, 0x07, 0x18, 0x18, 0xC0, 0xFC, 0x07, 0xC0, 0x1C, 0x03,
  0xF1, 0x9D, 0xCD, 0xCE, 0x6E, 0x3F, 0x70, 0xF3, 0x87, 0x8F, 0xFE, 0x3F,
  0x78, 0xFF, 0xF0, 0x0C, 0x73, 0x8C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x30,
  0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x18, 0x70, 0xC0, 0x83, 0x06, 0x1C,
  0x30, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x1C,
  0x63, 0x08, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x62, 0x2F, 0xFE, 0x3F, 0x03,
  0x80, 0xD8, 0x33, 0x8E, 0x38, 0x84, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x61, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x77, 0x77, 0x6E, 0xC0, 0xFF, 0xFF, 0xC0, 0x2F, 0xFF, 0x03, 0x83, 0x81,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x1F, 0xCE, 0xF6, 0x3F, 0x0F, 0x83, 0xC1, 0xF8, 0x7E, 0x19,
  0xFE, 0x3F, 0x00, 0x06, 0x7F, 0xFF, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x0D,
  0xC1, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0xFF, 0xFF, 0xE0, 0x0E, 0x07, 0xF1, 0xFF, 0x70, 0x6E, 0x0E,
  0x01, 0xC0, 0x30, 0x1E, 0x0F, 0x01, 0xF8, 0x03, 0x80, 0x70, 0x0F, 0xC1,
  0xFC, 0x7B, 0xFE, 0x3F, 0x80, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0D,
  0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xDF, 0xF6, 0x01, 0x80, 0x60, 0x3B,
  0x8F, 0xFB, 0xDF, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0xC1, 0xF8, 0x77, 0xF8,
  0xFC, 0x0F, 0x83, 0xF0, 0xF0, 0x38, 0x07, 0x00, 0xCE, 0x1F, 0xF7, 0xCE,
  0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x0E, 0xE3, 0xCF, 0xF0, 0xFC, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x0C, 0x1F, 0xC7,
  0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x1F, 0xEE, 0x1F, 0x07,
  0xC0, 0xF0, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0x06, 0x07, 0xF1, 0xFF, 0x38,
  0xE6, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xEF, 0x7C, 0xFF, 0x86, 0x70,
  0x0C, 0x03, 0x81, 0xE0, 0xF8, 0x1C, 0x00, 0x27, 0xF7, 0x00, 0x00, 0x00,
  0x27, 0xF7, 0x23, 0x9E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCC,
  0x66, 0x00, 0x00, 0xC1, 0xF1, 0xF9, 0xF0, 0xF0, 0x3C, 0x07, 0xE0, 0x7F,
  0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0xC0, 0x3C, 0x07, 0xE0, 0x7E, 0x03, 0xC1, 0xF1, 0xFB, 0xF0, 0xF0, 0x20,
  0x00, 0x0C, 0x1F, 0xE7, 0xFF, 0x87, 0xE1, 0xC0, 0x70, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x0C, 0x00, 0x0F,
  0x83, 0x8E, 0x60, 0x66, 0x73, 0xCF, 0xBD, 0x99, 0x99, 0x99, 0x99, 0x91,
  0xB9, 0x93, 0x9B, 0x2D, 0xFE, 0xC0, 0x86, 0x00, 0x7F, 0x81, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x0C, 0xC0, 0x66, 0x07, 0x38,
  0x38, 0xC1, 0x86, 0x1F, 0xF8, 0xFF, 0xC6, 0x06, 0x70, 0x3B, 0x81, 0xDC,
  0x07, 0xFF, 0x9F, 0xFB, 0x07, 0x60, 0x7C, 0x0F, 0x83, 0xB0, 0xF7, 0xF8,
  0xFF, 0xD8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xBF, 0xF7, 0xF8, 0x06,
  0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0x60, 0x6E, 0x07, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x1F,
  0x80, 0xFE, 0x1F, 0xF3, 0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xEC, 0x1D, 0x8F, 0x3F, 0xC7, 0xE0, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x06, 0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0x60,
  0x6E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x3F, 0xE3, 0xFE, 0x07, 0xE0,
  0x77, 0x07, 0x78, 0xF3, 0xFE, 0x1F, 0xC0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF,
  0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F, 0xF0, 0xF8, 0xC0,
  0xFC, 0x1C, 0xC3, 0x8C, 0x78, 0xC7, 0x0C, 0xE0, 0xDC, 0x0F, 0xC0, 0xFE,
  0x0F, 0x70, 0xE7, 0x0C, 0x38, 0xC3, 0xCC, 0x1C, 0xC0, 0xEC, 0x0F, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7F, 0x3F, 0xCF,
  0xF3, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xD9, 0xFB,
  0x3F, 0x37, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x07, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0x0E, 0x60, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x66, 0x0E, 0x71, 0xE3,
  0xFC, 0x1F, 0x80, 0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x1E, 0xFF, 0x9F, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0x0E, 0x60, 0x6E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x0E, 0x71, 0xE3,
  0xFC, 0x1F, 0xC0, 0x0F, 0x00, 0x70, 0x02, 0xFF, 0x1F, 0xFB, 0x07, 0x60,
  0x7C, 0x0F, 0x81, 0xF0, 0x77, 0xFE, 0xFF, 0x9F, 0xE3, 0x0C, 0x61, 0xCC,
  0x19, 0x83, 0xB0, 0x36, 0x07, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x60,
  0x76, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0xF3, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB0, 0x37,
  0x0E, 0xE3, 0xCF, 0xF0, 0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x0E, 0x70,
  0xE7, 0x0C, 0x31, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x1B, 0x81, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xC6, 0x3C, 0x63, 0xCE, 0x3C, 0xF7, 0xEF,
  0x7E, 0xF7, 0xEF, 0x76, 0xF6, 0x6B, 0x67, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x71, 0xC3, 0x0C, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x9C, 0x19,
  0xC1, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0x9C, 0x39,
  0xC7, 0x0E, 0xF0, 0x7E, 0x07, 0xF0, 0x3B, 0x81, 0x8E, 0x1C, 0x70, 0xC1,
  0xCE, 0x0E, 0x70, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xEF, 0xFE, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0x70, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x80, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0xF0, 0x0C, 0x07, 0x81, 0xE0, 0xFC, 0x33, 0x0C, 0xC6, 0x1B,
  0x87, 0xFF, 0xFF, 0xF0, 0xE3, 0x0E, 0x3F, 0x8F, 0xF9, 0xC3, 0x80, 0x70,
  0x0E, 0x7F, 0xDE, 0x3B, 0x07, 0xE0, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1F, 0xFE, 0xDF, 0x00, 0x1F, 0x87, 0xF9,
  0xC3, 0xB8, 0x76, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x6E, 0x1C, 0xFF,
  0x0F, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3F, 0xCF, 0xFB,
  0x87, 0x60, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDC, 0x39, 0xFF,
  0x1F, 0x60, 0x1F, 0x83, 0xFC, 0x70, 0xE7, 0x06, 0xE0, 0x6F, 0xFE, 0xFF,
  0xFE, 0x00, 0x70, 0x07, 0x86, 0x3F, 0xE1, 0xF8, 0x03, 0xC1, 0xFC, 0x7D,
  0x8E, 0x01, 0xC0, 0x30, 0x3F, 0xF7, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1F, 0x67, 0xFD,
  0xC3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x07, 0x70, 0xEE, 0x1C, 0xFF,
  0x8F, 0xF0, 0x0E, 0x41, 0xDC, 0x71, 0xFE, 0x0F, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x37, 0xEF, 0xFF, 0x87, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x06, 0x07, 0x07, 0x00, 0x00, 0x7F, 0x7F,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06,
  0x0E, 0x7E, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0,
  0xE6, 0x38, 0xCE, 0x1B, 0x83, 0xF0, 0x7F, 0x0E, 0x71, 0x8E, 0x30, 0xE6,
  0x0E, 0xC1, 0xE0, 0xFE, 0x3F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF,
  0xC0, 0xDF, 0xEF, 0xFF, 0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xC6, 0x7C,
  0x67, 0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xDF, 0xBF, 0xFE, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x1F, 0x83,
  0xFC, 0x70, 0xE6, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x06, 0x60, 0xE7,
  0x0E, 0x3F, 0xC1, 0xF8, 0xDF, 0x3F, 0xEE, 0x1F, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF8, 0xFF, 0xFB, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x3F, 0x67, 0xFD, 0xC3, 0xB0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0x70, 0xEE, 0x1C, 0xFF, 0x8F, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0xEF, 0xFF, 0xFE, 0x3E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x00, 0x3F, 0x9F, 0xFE, 0x1F, 0x80, 0xF0, 0x1F, 0xC1,
  0xF8, 0x07, 0xC0, 0xF8, 0x77, 0xFC, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x7F,
  0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xE0, 0x1F, 0xC1, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x77, 0xEC, 0xF3, 0xE0, 0x76, 0x06, 0x70, 0xE7,
  0x0C, 0x31, 0xC3, 0x9C, 0x19, 0x81, 0xB8, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0x60, 0xE3, 0x1B, 0x18, 0xD9, 0xCE, 0xCF, 0x77, 0x7B, 0x3A, 0xD8, 0xD6,
  0xC7, 0x96, 0x3C, 0xF1, 0xE7, 0x0E, 0x38, 0x30, 0xC0, 0xF0, 0x77, 0x0E,
  0x39, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0xC3, 0x9C,
  0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x38, 0xC3, 0x9C,
  0x19, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xDF, 0xF8, 0x0E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x1C,
  0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x63, 0x87, 0x07, 0x07, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0xC0, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC1, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0x78, 0x73, 0x87,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x8E, 0x18, 0x00, 0x3C, 0x13, 0xF0, 0xD9,
  0xFF, 0x83, 0xE0, 0x0E, 0x00,
};

const GFXglyph RobotoMono_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 16, 14, 5, -16 },
  { 7, 7, 5, 14, 3, -17 },
  { 12, 12, 16, 14, 1, -16 },
  { 36, 11, 21, 14, 2, -19 },
  { 65, 13, 17, 14, 0, -17 },
  { 93, 13, 17, 14, 1, -17 },
  { 121, 2, 6, 14, 5, -17 },
  { 123, 6, 23, 14, 4, -18 },
  { 141, 6, 23, 14, 4, -18 },
  { 159, 11, 11, 14, 2, -16 },
  { 175, 11, 12, 14, 1, -14 },
  { 192, 4, 7, 14, 4, -3 },
  { 196, 9, 2, 14, 3, -8 },
  { 199, 4, 4, 14, 5, -4 },
  { 201, 9, 17, 14, 3, -16 },
  { 221, 10, 17, 14, 2, -17 },
  { 243, 7, 16, 14, 2, -16 },
  { 257, 11, 17, 14, 1, -17 },
  { 281, 11, 17, 14, 1, -17 },
  { 305, 12, 16, 14, 1, -16 },
  { 329, 10, 16, 14, 2, -16 },
  { 349, 11, 16, 14, 1, -16 },
  { 371, 11, 16, 14, 1, -16 },
  { 393, 10, 17, 14, 2, -17 },
  { 415, 11, 17, 14, 1, -17 },
  { 439, 4, 14, 14, 5, -14 },
  { 446, 5, 18, 14, 5, -14 },
  { 458, 10, 10, 14, 2, -12 },
  { 471, 10, 7, 14, 2, -11 },
  { 480, 10, 10, 14, 2, -12 },
  { 493, 10, 17, 14, 2, -17 },
  { 515, 12, 16, 14, 1, -16 },
  { 539, 13, 16, 14, 1, -16 },
  { 565, 11, 16, 14, 2, -16 },
  { 587, 12, 17, 14, 1, -17 },
  { 613, 11, 16, 14, 2, -16 },
  { 635, 10, 16, 14, 2, -16 },
  { 655, 11, 16, 14, 2, -16 },
  { 677, 12, 17, 14, 1, -17 },
  { 703, 11, 16, 14, 1, -16 },
  { 725, 10, 16, 14, 2, -16 },
  { 745, 11, 16, 14, 1, -16 },
  { 767, 12, 16, 14, 2, -16 },
  { 791, 10, 16, 14, 2, -16 },
  { 811, 10, 16, 14, 2, -16 },
  { 831, 11, 16, 14, 1, -16 },
  { 853, 12, 17, 14, 1, -17 },
  { 879, 11, 16, 14, 2, -16 },
  { 901, 12, 20, 14, 1, -17 },
  { 931, 11, 16, 14, 2, -16 },
  { 953, 12, 17, 14, 1, -17 },
  { 979, 12, 16, 14, 1, -16 },
  { 1003, 11, 16, 14, 1, -16 },
  { 1025, 12, 16, 14, 1, -16 },
  { 1049, 12, 16, 14, 1, -16 },
  { 1073, 12, 16, 14, 1, -16 },
  { 1097, 13, 16, 14, 0, -16 },
  { 1123, 12, 16, 14, 1, -16 },
  { 1147, 4, 23, 14, 5, -19 },
  { 1159, 9, 17, 14, 3, -16 },
  { 1179, 4, 23, 14, 5, -19 },
  { 1191, 10, 8, 14, 2, -16 },
  { 1201, 10, 2, 14, 2, 0 },
  { 1204, 5, 3, 14, 5, -17 },
  { 1206, 11, 12, 14, 1, -12 },
  { 1223, 10, 17, 14, 2, -17 },
  { 1245, 11, 12, 14, 1, -12 },
  { 1262, 11, 17, 14, 1, -17 },
  { 1286, 12, 12, 14, 1, -12 },
  { 1304, 11, 18, 14, 2, -18 },
  { 1329, 11, 17, 14, 1, -12 },
  { 1353, 10, 17, 14, 2, -17 },
  { 1375, 10, 17, 14, 2, -17 },
  { 1397, 8, 22, 14, 2, -17 },
  { 1419, 11, 17, 14, 2, -17 },
  { 1443, 10, 17, 14, 2, -17 },
  { 1465, 12, 12, 14, 1, -12 },
  { 1483, 10, 12, 14, 2, -12 },
  { 1498, 12, 12, 14, 1, -12 },
  { 1516, 10, 17, 14, 2, -12 },
  { 1538, 11, 17, 14, 1, -12 },
  { 1562, 9, 12, 14, 3, -12 },
  { 1576, 10, 12, 14, 2, -12 },
  { 1591, 11, 15, 14, 1, -15 },
  { 1612, 10, 12, 14, 2, -12 },
  { 1627, 12, 12, 14, 1, -12 },
  { 1645, 13, 12, 14, 0, -12 },
  { 1665, 12, 12, 14, 1, -12 },
  { 1683, 12, 17, 14, 1, -12 },
  { 1709, 11, 12, 14, 2, -12 },
  { 1726, 7, 22, 14, 4, -18 },
  { 1746, 2, 21, 14, 6, -16 },
  { 1752, 7, 22, 14, 4, -18 },
  { 1772, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_Medium23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium23pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_MEDIUM23PT7B_H_
