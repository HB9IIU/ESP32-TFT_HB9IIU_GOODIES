#ifndef _ROBOTOMONO_MEDIUM42PT7B_H_
#define _ROBOTOMONO_MEDIUM42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x01, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x70, 0x70, 0x71, 0xC0, 0xF1, 0xE3, 0x81, 0xE3, 0xCE, 0x01, 0xFF,
  0x1C, 0x01, 0xFC, 0x70, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0xC0, 0x03, 0x8F,
  0xE0, 0x07, 0x3F, 0xE0, 0x1C, 0xF9, 0xE0, 0x39, 0xE1, 0xC0, 0xE3, 0x83,
  0x83, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x06, 0x1E, 0x1C, 0x00, 0x3C, 0x38,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xC1, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3E,
  0x3E, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x3C, 0xFD, 0xF0,
  0x79, 0xF1, 0xF0, 0xF7, 0xC3, 0xF3, 0xEF, 0x83, 0xF7, 0xDF, 0x03, 0xEF,
  0x3E, 0x03, 0xFE, 0x7C, 0x07, 0xF8, 0xF8, 0x07, 0xF1, 0xF8, 0x0F, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xC1, 0xFF, 0x0F, 0xC0,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0C, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x18, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0xCF, 0x8E, 0x3E, 0x7F,
  0x77, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x80, 0xF8,
  0x3C, 0x07, 0x81, 0xF0, 0x1C, 0x06, 0x00, 0x40, 0x20, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3E, 0xFF, 0xCF, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFB,
  0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0xC0, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0x7E, 0x0F, 0xCF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x7C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x60, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x3F, 0xC3, 0xC0, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xE7, 0xE0, 0x7C,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x3C, 0x07, 0xDF, 0xF0, 0x7B, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xEF,
  0xE0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x03,
  0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xF9, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xC0, 0xF9, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFD, 0xE0, 0x7F, 0x9E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0xF0, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0xF0, 0x07, 0x83,
  0xC0, 0x07, 0x07, 0x01, 0x07, 0x1C, 0x1F, 0x8E, 0x38, 0x7F, 0x8C, 0xE1,
  0xF7, 0x1D, 0xC7, 0x8E, 0x3B, 0x8E, 0x1C, 0x7F, 0x1C, 0x38, 0xFC, 0x70,
  0x71, 0xF8, 0xE0, 0xE3, 0xF1, 0xC1, 0xC7, 0xE3, 0x83, 0x0F, 0xC7, 0x0E,
  0x1B, 0x8E, 0x1C, 0x77, 0x1C, 0x38, 0xEE, 0x3F, 0xFB, 0x8E, 0x3F, 0xFF,
  0x1C, 0x7E, 0xFC, 0x38, 0x30, 0x60, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x04, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x83, 0xE0,
  0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x7C, 0x01, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xCF, 0x81, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xC0, 0x3F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x8F, 0x80, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x83,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF8,
  0x0F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xEF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F,
  0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x0F, 0x80, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7E,
  0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xF7, 0x1F, 0xFF, 0x79, 0xFF, 0xF7, 0xBD,
  0xFF, 0x7B, 0xDF, 0xF3, 0xBD, 0xFF, 0x3F, 0x9F, 0xF3, 0xF9, 0xFF, 0x1F,
  0x9F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF0, 0xF1, 0xFF, 0x0E, 0x1F, 0xF0,
  0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFD, 0xE1, 0xFF, 0xBE, 0x3F, 0xF3, 0xC7, 0xFE, 0x78, 0xFF,
  0xC7, 0x9F, 0xF8, 0xF3, 0xFF, 0x1F, 0x7F, 0xE1, 0xEF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0,
  0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0x7C, 0x01, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x7F, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x7C, 0x01, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0x7C, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xFC,
  0x07, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F,
  0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C,
  0x3E, 0x78, 0x7C, 0x3E, 0x78, 0x7E, 0x3E, 0x78, 0x7E, 0x3E, 0x78, 0xFE,
  0x3C, 0x7C, 0xFE, 0x3C, 0x7C, 0xFE, 0x3C, 0x7C, 0xFE, 0x3C, 0x3C, 0xEF,
  0x3C, 0x3C, 0xEF, 0x7C, 0x3C, 0xEF, 0x7C, 0x3D, 0xE7, 0x7C, 0x3D, 0xE7,
  0x78, 0x3D, 0xE7, 0x78, 0x3F, 0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x83,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3,
  0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x00,
  0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1,
  0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xF7, 0xC7, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0x00, 0xF9, 0xFE, 0x0F,
  0xBF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFB, 0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xFC, 0x03, 0xEF, 0xE0, 0x7C, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFB,
  0xFF, 0x0F, 0x9F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFB, 0xFC, 0xFC, 0x0F, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF8,
  0x1F, 0x9F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x38, 0x7C, 0x3F,
  0xCF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x7F, 0xDF, 0x81, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE,
  0xF8, 0x3F, 0x9F, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFC, 0xFE, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x1E,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x03, 0x0F, 0xC0, 0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x80, 0x01, 0xFF, 0x3C, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFB, 0xFE,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x1F, 0xBF, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE2,
  0x00, 0xFC, 0xE0, 0x1F, 0x3F, 0x0F, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x03, 0x03, 0xE3, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0x7F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30,
  0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0xFE, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xBE, 0x01,
  0xF9, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F,
  0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0x80, 0xFC,
  0x7E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC,
  0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x81, 0xC7, 0xBF, 0xBF, 0xBD, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF,
  0xDF, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F,
  0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C,
  0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC,
  0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1,
  0xE0, 0x00, 0x18, 0x1F, 0x1F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFB,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFC, 0xFE, 0x1F, 0x01, 0xF1,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF,
  0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x0F,
  0x9F, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xBF, 0xCF, 0xC0, 0x7C,
  0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xBF, 0xF0, 0xF9, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x7C, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xF9, 0xFE, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7D,
  0xF8, 0x1F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFC, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0C, 0x7C,
  0x7F, 0xFE, 0x7F, 0xDF, 0x7F, 0xEF, 0xFF, 0xF7, 0xFE, 0x1B, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFE, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xBF, 0x87, 0xF3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFF, 0x9E, 0x1F, 0xE3, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00,
  0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83,
  0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xE0, 0x1F, 0x1F,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xE1, 0xF0, 0xFF,
  0xC3, 0xE1, 0xF7, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3F, 0x8F, 0x3C,
  0x77, 0x1E, 0x78, 0xEE, 0x3C, 0x79, 0xDC, 0xF0, 0xF3, 0xB9, 0xE1, 0xEF,
  0x7B, 0xC3, 0xDC, 0x77, 0x87, 0xB8, 0xEF, 0x07, 0x71, 0xDC, 0x0F, 0xE3,
  0xB8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x07,
  0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3F, 0x00,
  0x7D, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x3E, 0x0F,
  0x80, 0x7C, 0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x03, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0x81,
  0xFC, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x31,
  0xFF, 0xC0, 0x7B, 0xFF, 0xC0, 0xFF, 0xDF, 0xE3, 0xDE, 0x0F, 0xFF, 0xB8,
  0x0F, 0xFE, 0x70, 0x07, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 30, 25, 10, -30 },
  { 20, 12, 11, 25, 6, -32 },
  { 37, 23, 30, 25, 1, -30 },
  { 124, 20, 39, 25, 3, -35 },
  { 222, 23, 30, 25, 1, -30 },
  { 309, 23, 30, 25, 2, -30 },
  { 396, 4, 11, 25, 10, -32 },
  { 402, 11, 42, 25, 7, -33 },
  { 460, 11, 42, 25, 7, -33 },
  { 518, 21, 21, 25, 3, -30 },
  { 574, 21, 22, 25, 2, -25 },
  { 632, 7, 13, 25, 7, -5 },
  { 644, 17, 4, 25, 5, -15 },
  { 653, 7, 6, 25, 9, -6 },
  { 659, 16, 33, 25, 5, -30 },
  { 725, 19, 30, 25, 3, -30 },
  { 797, 12, 30, 25, 4, -30 },
  { 842, 20, 30, 25, 2, -30 },
  { 917, 20, 30, 25, 2, -30 },
  { 992, 22, 30, 25, 1, -30 },
  { 1075, 20, 30, 25, 3, -30 },
  { 1150, 20, 30, 25, 2, -30 },
  { 1225, 20, 30, 25, 2, -30 },
  { 1300, 19, 30, 25, 3, -30 },
  { 1372, 20, 30, 25, 2, -30 },
  { 1447, 7, 23, 25, 10, -23 },
  { 1468, 8, 31, 25, 9, -23 },
  { 1499, 18, 20, 25, 3, -23 },
  { 1544, 19, 12, 25, 3, -19 },
  { 1573, 19, 20, 25, 3, -23 },
  { 1621, 18, 30, 25, 4, -30 },
  { 1689, 23, 30, 25, 1, -30 },
  { 1776, 24, 30, 25, 1, -30 },
  { 1866, 21, 30, 25, 3, -30 },
  { 1945, 21, 30, 25, 2, -30 },
  { 2024, 20, 30, 25, 3, -30 },
  { 2099, 20, 30, 25, 3, -30 },
  { 2174, 20, 30, 25, 3, -30 },
  { 2249, 21, 30, 25, 2, -30 },
  { 2328, 19, 30, 25, 3, -30 },
  { 2400, 17, 30, 25, 4, -30 },
  { 2464, 20, 30, 25, 2, -30 },
  { 2539, 22, 30, 25, 3, -30 },
  { 2622, 20, 30, 25, 3, -30 },
  { 2697, 20, 30, 25, 3, -30 },
  { 2772, 19, 30, 25, 3, -30 },
  { 2844, 21, 30, 25, 2, -30 },
  { 2923, 21, 30, 25, 3, -30 },
  { 3002, 23, 35, 25, 2, -30 },
  { 3103, 21, 30, 25, 3, -30 },
  { 3182, 22, 30, 25, 2, -30 },
  { 3265, 23, 30, 25, 1, -30 },
  { 3352, 20, 30, 25, 3, -30 },
  { 3427, 23, 30, 25, 1, -30 },
  { 3514, 24, 30, 25, 1, -30 },
  { 3604, 24, 30, 25, 1, -30 },
  { 3694, 23, 30, 25, 1, -30 },
  { 3781, 21, 30, 25, 2, -30 },
  { 3860, 9, 41, 25, 8, -34 },
  { 3907, 16, 33, 25, 5, -30 },
  { 3973, 9, 41, 25, 8, -34 },
  { 4020, 16, 16, 25, 5, -30 },
  { 4052, 19, 4, 25, 3, 0 },
  { 4062, 10, 5, 25, 8, -30 },
  { 4069, 19, 23, 25, 3, -23 },
  { 4124, 20, 32, 25, 3, -32 },
  { 4204, 19, 23, 25, 3, -23 },
  { 4259, 19, 32, 25, 3, -32 },
  { 4335, 21, 23, 25, 2, -23 },
  { 4396, 20, 32, 25, 3, -32 },
  { 4476, 19, 32, 25, 3, -23 },
  { 4552, 19, 32, 25, 3, -32 },
  { 4628, 19, 31, 25, 4, -31 },
  { 4702, 14, 40, 25, 4, -31 },
  { 4772, 21, 32, 25, 3, -32 },
  { 4856, 19, 32, 25, 4, -32 },
  { 4932, 21, 23, 25, 2, -23 },
  { 4993, 19, 23, 25, 3, -23 },
  { 5048, 21, 23, 25, 2, -23 },
  { 5109, 20, 32, 25, 3, -23 },
  { 5189, 19, 32, 25, 3, -23 },
  { 5265, 17, 23, 25, 6, -23 },
  { 5314, 19, 23, 25, 3, -23 },
  { 5369, 19, 28, 25, 3, -28 },
  { 5436, 19, 22, 25, 3, -22 },
  { 5489, 21, 22, 25, 2, -22 },
  { 5547, 23, 22, 25, 1, -22 },
  { 5611, 22, 22, 25, 2, -22 },
  { 5672, 24, 31, 25, 1, -22 },
  { 5765, 20, 22, 25, 3, -22 },
  { 5820, 14, 40, 25, 6, -33 },
  { 5890, 3, 38, 25, 11, -30 },
  { 5905, 13, 40, 25, 7, -33 },
  { 5970, 23, 9, 25, 1, -17 },
};

const GFXfont RobotoMono_Medium42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium42pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_MEDIUM42PT7B_H_
