#ifndef _ROBOTOMONO_MEDIUM38PT7B_H_
#define _ROBOTOMONO_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0x80, 0x00, 0x01, 0xDF, 0xFF, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x1C, 0x3C, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1C, 0x1C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE,
  0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xF9, 0xF8, 0xFE, 0x7F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x86, 0x0E,
  0x1C, 0x38, 0x70, 0xE3, 0x83, 0x87, 0x1C, 0x1C, 0x39, 0xC0, 0xF3, 0xCE,
  0x03, 0xFC, 0xE0, 0x0F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC7, 0xE0, 0x0E, 0x7F,
  0x80, 0xE7, 0x9E, 0x07, 0x38, 0x70, 0x71, 0xC3, 0x83, 0x8E, 0x1C, 0x38,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x78, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x7C, 0x03, 0xE1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3E, 0x3C, 0x00,
  0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x83, 0xCF, 0xFE, 0x1E, 0x79, 0xF0, 0xF7, 0xC7, 0xC7, 0xBC,
  0x1F, 0x79, 0xE0, 0x7F, 0xCF, 0x03, 0xFE, 0x78, 0x0F, 0xE3, 0xE0, 0x3E,
  0x1F, 0x87, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFC, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xC0, 0x70, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0x80, 0x10, 0x40, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x08, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x10, 0x38, 0x27,
  0x8E, 0x3F, 0xFB, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x1E, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xCF, 0x00, 0xE1, 0xC0, 0x78, 0x78, 0x3C, 0x0F,
  0x03, 0x03, 0x80, 0x40, 0x40, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0x86, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF, 0xF7,
  0xEF, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xE7, 0x81, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F,
  0x7F, 0x9F, 0x3F, 0xDE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7D, 0xE0, 0x7C, 0xFC, 0x7E,
  0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x1F, 0x07, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C,
  0xF0, 0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xF8, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xF9, 0xF8, 0x7E, 0x7F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x70, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3E, 0xFC, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x3E, 0x07, 0xBF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x83, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xE7, 0x81,
  0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F,
  0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xF8, 0x3E,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x3F, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x9E,
  0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xF3, 0xF3, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0x81, 0xF9, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0x3B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3B, 0xFF, 0xFF, 0xFD, 0xF0, 0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF0, 0x20, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF,
  0x80, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFE, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xC7, 0xE7, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1E, 0x03, 0x81, 0xE0, 0x0E, 0x1E,
  0x00, 0x38, 0xE1, 0xF9, 0xCE, 0x1F, 0xC6, 0x71, 0xE6, 0x33, 0x1E, 0x31,
  0xF8, 0xE1, 0x8F, 0xC7, 0x1C, 0x7E, 0x30, 0xE3, 0xF3, 0x87, 0x1B, 0x9C,
  0x38, 0xDC, 0xE1, 0xC6, 0xE7, 0x0E, 0x37, 0x38, 0x73, 0xB8, 0xFF, 0xB9,
  0xC7, 0xFF, 0xC7, 0x1E, 0x7C, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x40, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1E,
  0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0xF0,
  0x07, 0x9F, 0x01, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0,
  0x3F, 0x3C, 0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0,
  0x0F, 0xBC, 0x07, 0xCF, 0x03, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0x8F, 0xC7, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0xF9,
  0xFC, 0x7F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xF9, 0xFC, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x07, 0xEF, 0x00, 0x7C, 0xF0,
  0x0F, 0x8F, 0x01, 0xF8, 0xF0, 0x3F, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F,
  0x0F, 0xC0, 0xF1, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0xF8,
  0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3F, 0x0F, 0x01,
  0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x8F, 0xFE, 0xE3, 0xBF, 0xF8, 0xEF, 0xFF, 0x7B, 0xFF,
  0xDE, 0xFF, 0x77, 0x3F, 0xDF, 0xCF, 0xF7, 0xF3, 0xFC, 0xF8, 0xFF, 0x3E,
  0x3F, 0xCF, 0x9F, 0xF1, 0xC7, 0xFC, 0x71, 0xFF, 0x1C, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xBC, 0x3F, 0xEF, 0x0F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF,
  0x8F, 0x3F, 0xE3, 0xCF, 0xF8, 0x7B, 0xFE, 0x1E, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xDF, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3C, 0xF8, 0x0F, 0x9F, 0x03, 0xE1,
  0xFD, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFB, 0xF8, 0x7C, 0x0F, 0xC7,
  0xC0, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC3, 0xFB, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x01, 0xF7,
  0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x07, 0xCF,
  0x01, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E,
  0x0F, 0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C,
  0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0x80,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F, 0xE7, 0xC0, 0x7E,
  0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xDF, 0x00, 0xFB, 0xF8, 0x7E, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0x78, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x9F, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC, 0x3E, 0x1F,
  0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xBC, 0x7C, 0x79, 0xE3, 0xE3, 0xCF, 0x1F,
  0x1E, 0x79, 0xFC, 0xF3, 0xCE, 0xE7, 0x9E, 0x77, 0x3C, 0xF3, 0xB9, 0xE7,
  0x9D, 0xCF, 0x1E, 0xEE, 0x70, 0xFF, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1E, 0xF8, 0x01, 0xF3, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x78, 0x0F, 0x83,
  0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x03,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xEE,
  0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x38, 0x3C, 0x78, 0x78, 0xF0, 0xE0, 0xF3,
  0xC1, 0xE7, 0x81, 0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xF8, 0x7E, 0x7C, 0x0F, 0x9E, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0, 0x1E, 0x78,
  0x07, 0xBE, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E, 0x7E, 0x3F, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x3F, 0x9F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0xFE, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x3E, 0x03,
  0xEF, 0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBF, 0x8F, 0xCF, 0xFF, 0xF3, 0xDF, 0xF8, 0xF3, 0xF8, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0x7E, 0x7C, 0x07, 0xDF, 0x01,
  0xF7, 0x80, 0x3D, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x1F, 0x3F,
  0x1F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC1, 0xFD, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0x1F, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x1F, 0x7C, 0x0F, 0xCF, 0xC7, 0xF3, 0xFF, 0xFC, 0x7F, 0xEF, 0x07,
  0xF3, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC3,
  0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x43, 0xF0, 0x0C, 0x3F, 0x8F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xE3, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF3, 0xC7, 0xFE,
  0xF3, 0xFF, 0xFC, 0xFC, 0x7F, 0x7C, 0x07, 0xDF, 0x00, 0xF7, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xDE, 0x00, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x3F, 0x1F, 0xCF, 0xFF,
  0xF1, 0xFF, 0xBC, 0x1F, 0xCF, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0x00, 0x7C,
  0xE0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF,
  0xEF, 0xE3, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x78, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x5E, 0x01, 0xF3, 0xC0, 0x7C, 0x78, 0x1F, 0x0F, 0x07, 0xC1, 0xE1, 0xF0,
  0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF1, 0xF0, 0x3C, 0x3F, 0x07, 0x83, 0xE0,
  0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x7E, 0x78, 0x07, 0xEF, 0x00, 0x7E,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xE7, 0xCF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xF9, 0xFF,
  0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE,
  0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC,
  0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8,
  0xF0, 0xF0, 0xF1, 0xFC, 0x7B, 0xFF, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE,
  0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xE0, 0x3E, 0x3F,
  0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xF3, 0xF8, 0x7B,
  0xFF, 0x3F, 0xFF, 0xDF, 0xC7, 0xEF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x3E, 0xFE, 0x3F, 0x7F, 0xFF, 0x3D,
  0xFF, 0x9E, 0x7F, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF3, 0xC7,
  0xFE, 0xF3, 0xFF, 0xFC, 0xFC, 0x7F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x3F, 0x1F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F,
  0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xBF,
  0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x30, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0x7C, 0x3F, 0xBF, 0xFF, 0xCF, 0xFD, 0xE3, 0xF8, 0xF0, 0xF0, 0x03,
  0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x03, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x70,
  0x7F, 0x83, 0x83, 0xFC, 0x3C, 0x1D, 0xE1, 0xF1, 0xE7, 0x0F, 0x8F, 0x3C,
  0x7C, 0x79, 0xE7, 0xE3, 0xCF, 0x3B, 0x1E, 0x79, 0xDC, 0xE1, 0xCE, 0xE7,
  0x0E, 0x67, 0x78, 0x77, 0x3B, 0xC3, 0xF8, 0xDE, 0x1F, 0xC7, 0xE0, 0xFE,
  0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0,
  0x3C, 0x0F, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0,
  0xF8, 0x1F, 0x1F, 0x00, 0xF9, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFB, 0xE0, 0x0F, 0x9F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C,
  0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x7C, 0x78, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x7C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x9E,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x40, 0x07, 0x80, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x07, 0xF0, 0x7E,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0,
  0x04, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x03, 0xDF, 0xF8, 0x1D, 0xFF,
  0xF1, 0xEF, 0x0F, 0xFF, 0x70, 0x3F, 0xF3, 0x80, 0x7F, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoMono_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 27, 23, 9, -27 },
  { 18, 10, 10, 23, 6, -29 },
  { 31, 21, 27, 23, 1, -27 },
  { 102, 18, 35, 23, 3, -31 },
  { 181, 21, 27, 23, 1, -27 },
  { 252, 21, 27, 23, 2, -27 },
  { 323, 3, 10, 23, 9, -29 },
  { 327, 11, 39, 23, 6, -30 },
  { 381, 10, 39, 23, 6, -30 },
  { 430, 18, 19, 23, 3, -27 },
  { 473, 19, 19, 23, 2, -22 },
  { 519, 6, 11, 23, 7, -4 },
  { 528, 15, 4, 23, 5, -14 },
  { 536, 7, 6, 23, 8, -6 },
  { 542, 15, 29, 23, 4, -27 },
  { 597, 17, 27, 23, 3, -27 },
  { 655, 12, 27, 23, 3, -27 },
  { 696, 19, 27, 23, 1, -27 },
  { 761, 18, 27, 23, 2, -27 },
  { 822, 20, 27, 23, 1, -27 },
  { 890, 17, 27, 23, 3, -27 },
  { 948, 18, 27, 23, 2, -27 },
  { 1009, 18, 27, 23, 2, -27 },
  { 1070, 17, 27, 23, 3, -27 },
  { 1128, 18, 27, 23, 2, -27 },
  { 1189, 6, 22, 23, 9, -22 },
  { 1206, 8, 29, 23, 8, -22 },
  { 1235, 16, 17, 23, 3, -20 },
  { 1269, 17, 12, 23, 3, -18 },
  { 1295, 17, 17, 23, 3, -20 },
  { 1332, 17, 27, 23, 3, -27 },
  { 1390, 21, 27, 23, 1, -27 },
  { 1461, 21, 27, 23, 1, -27 },
  { 1532, 18, 27, 23, 3, -27 },
  { 1593, 19, 27, 23, 2, -27 },
  { 1658, 18, 27, 23, 3, -27 },
  { 1719, 18, 27, 23, 3, -27 },
  { 1780, 18, 27, 23, 3, -27 },
  { 1841, 19, 27, 23, 2, -27 },
  { 1906, 18, 27, 23, 2, -27 },
  { 1967, 16, 27, 23, 3, -27 },
  { 2021, 18, 27, 23, 2, -27 },
  { 2082, 20, 27, 23, 3, -27 },
  { 2150, 18, 27, 23, 3, -27 },
  { 2211, 18, 27, 23, 3, -27 },
  { 2272, 18, 27, 23, 2, -27 },
  { 2333, 19, 27, 23, 2, -27 },
  { 2398, 18, 27, 23, 3, -27 },
  { 2459, 20, 32, 23, 2, -27 },
  { 2539, 19, 27, 23, 3, -27 },
  { 2604, 19, 27, 23, 2, -27 },
  { 2669, 21, 27, 23, 1, -27 },
  { 2740, 18, 27, 23, 2, -27 },
  { 2801, 21, 27, 23, 1, -27 },
  { 2872, 21, 27, 23, 1, -27 },
  { 2943, 21, 27, 23, 1, -27 },
  { 3014, 21, 27, 23, 1, -27 },
  { 3085, 19, 27, 23, 2, -27 },
  { 3150, 8, 37, 23, 8, -31 },
  { 3187, 15, 29, 23, 4, -27 },
  { 3242, 8, 37, 23, 7, -31 },
  { 3279, 15, 14, 23, 4, -27 },
  { 3306, 17, 4, 23, 3, 0 },
  { 3315, 8, 5, 23, 8, -27 },
  { 3320, 18, 20, 23, 2, -20 },
  { 3365, 18, 29, 23, 3, -29 },
  { 3431, 18, 20, 23, 2, -20 },
  { 3476, 18, 29, 23, 2, -29 },
  { 3542, 19, 20, 23, 2, -20 },
  { 3590, 18, 29, 23, 3, -29 },
  { 3656, 18, 28, 23, 2, -20 },
  { 3719, 17, 29, 23, 3, -29 },
  { 3781, 16, 28, 23, 4, -28 },
  { 3837, 12, 36, 23, 4, -28 },
  { 3891, 19, 29, 23, 3, -29 },
  { 3960, 17, 29, 23, 4, -29 },
  { 4022, 19, 20, 23, 2, -20 },
  { 4070, 17, 20, 23, 3, -20 },
  { 4113, 19, 20, 23, 2, -20 },
  { 4161, 17, 28, 23, 3, -20 },
  { 4221, 18, 28, 23, 2, -20 },
  { 4284, 14, 20, 23, 6, -20 },
  { 4319, 17, 20, 23, 3, -20 },
  { 4362, 18, 25, 23, 2, -25 },
  { 4419, 17, 20, 23, 3, -20 },
  { 4462, 19, 20, 23, 2, -20 },
  { 4510, 21, 20, 23, 1, -20 },
  { 4563, 20, 20, 23, 2, -20 },
  { 4613, 21, 28, 23, 1, -20 },
  { 4687, 18, 20, 23, 3, -20 },
  { 4732, 12, 37, 23, 6, -30 },
  { 4788, 3, 35, 23, 10, -27 },
  { 4802, 13, 37, 23, 6, -30 },
  { 4863, 21, 8, 23, 1, -15 },
};

const GFXfont RobotoMono_Medium38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium38pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_MEDIUM38PT7B_H_
