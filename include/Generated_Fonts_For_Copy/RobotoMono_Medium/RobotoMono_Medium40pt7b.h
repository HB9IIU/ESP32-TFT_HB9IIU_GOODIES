#ifndef _ROBOTOMONO_MEDIUM40PT7B_H_
#define _ROBOTOMONO_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0xDE, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7,
  0xC0, 0x7C, 0xFF, 0x7F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xE1, 0x83, 0x87,
  0x87, 0x0E, 0x1E, 0x38, 0x38, 0x78, 0xE0, 0xE1, 0xC7, 0x03, 0xCF, 0x3C,
  0x07, 0xFC, 0xE0, 0x0F, 0xE7, 0x00, 0x04, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x8F, 0x80, 0x1E,
  0x7F, 0x80, 0x73, 0xFF, 0x03, 0xCE, 0x3C, 0x0E, 0x78, 0x70, 0x71, 0xE1,
  0xC1, 0xC7, 0x87, 0x02, 0x1E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xF7, 0xC0,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x1E, 0x3F, 0xF0, 0x79, 0xF3, 0xE1, 0xEF, 0x8F, 0xC7, 0xBE, 0x1F, 0x3E,
  0xF8, 0x3E, 0xF3, 0xC0, 0x7F, 0xCF, 0x81, 0xFE, 0x3E, 0x03, 0xF8, 0xF8,
  0x0F, 0xC1, 0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0x7E, 0x0F, 0xF8,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x70, 0x3C, 0x1F, 0x07,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x40, 0x40, 0x0C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x03, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x06, 0x0E, 0x06, 0x78, 0xE1,
  0xEF, 0xFE, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xB8, 0x00, 0x7B, 0xC0, 0x0F, 0x1E, 0x01, 0xF0, 0xF0, 0x3E,
  0x0F, 0x81, 0xC0, 0x70, 0x04, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDF, 0x79, 0xEF, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x3E, 0xFF, 0x1F, 0x3F, 0xCF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1E,
  0x7C, 0x0F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x70, 0x3F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x03, 0xE8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1E, 0xFC, 0x07, 0xCF, 0xF7, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x3E,
  0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x1C, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0x87, 0xE1, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3F,
  0x7F, 0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x06, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xE0, 0x3C,
  0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xC3, 0xF7, 0xE0, 0x3E, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3E, 0xF0,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xF7, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0x79, 0xF0, 0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0xCF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7,
  0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF9, 0xF8, 0x7F, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xEF, 0x00, 0xE1, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0xEF, 0xDF,
  0x00, 0x3C, 0x7E, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x60, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F, 0xDF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x87, 0xE3, 0x8E,
  0x3F, 0xC6, 0x71, 0xF7, 0x1D, 0xC7, 0x1C, 0x76, 0x3C, 0x71, 0xF8, 0xE1,
  0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC6,
  0xE7, 0x86, 0x1B, 0x8E, 0x18, 0xEE, 0x38, 0xF3, 0xB8, 0xFF, 0xFC, 0x71,
  0xF7, 0xE1, 0xC3, 0x8F, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07,
  0x9F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF0,
  0xF8, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x1E,
  0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0x87, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x83, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xE3, 0xFD, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x78, 0x7F, 0x8F, 0x01, 0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x3E,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x03, 0xE7,
  0x81, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xFD, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF3, 0xE0, 0x7E, 0x7F,
  0xBF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E,
  0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x81, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFD, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0x7F, 0xF9,
  0xEF, 0xFF, 0x3D, 0xFE, 0xE7, 0x7F, 0xDF, 0xEF, 0xFB, 0xFD, 0xFF, 0x3F,
  0x3F, 0xE7, 0xE7, 0xFC, 0xFC, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C,
  0x7F, 0xC3, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFD, 0xE0, 0xFF,
  0x78, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC3,
  0xCF, 0xF0, 0xF3, 0xFC, 0x1E, 0xFF, 0x07, 0xBF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0x80, 0x3E,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0x83, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xF0, 0xFC, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x3E, 0x07, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x83, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xFD, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x87, 0x83, 0xFE, 0x1F, 0x0F, 0x78, 0x7C, 0x7D, 0xE3,
  0xF1, 0xF7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF1,
  0xE7, 0x8F, 0xE7, 0x9F, 0x7F, 0x9E, 0x3D, 0xEE, 0x78, 0xF7, 0x3B, 0xE3,
  0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0xC0, 0xF8, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x87, 0xC0,
  0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xC7, 0xC0,
  0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x7C,
  0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7E, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0xBE, 0x07, 0xEF, 0xE7, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xC7, 0xF9, 0xF0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x60, 0x1F, 0x7F, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF1, 0xF9, 0xF8, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x81, 0xFB, 0xFE, 0xFE, 0x7F, 0xFF, 0x8F, 0x7F, 0xF1, 0xE3, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xFC,
  0x7C, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x0F, 0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFE, 0x7F, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x83, 0xE0, 0xFF, 0x7C, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF9, 0xFE,
  0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDE, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFE, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xE3, 0xC0, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0x8F, 0xC3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1E, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x83,
  0xF0, 0x1C, 0x3F, 0xCF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x02,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x3C, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3,
  0xF9, 0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDE,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x10,
  0x03, 0xE3, 0x00, 0xF8, 0xFC, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x30, 0x3E, 0x7F,
  0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF4, 0x3F, 0xBF,
  0xF9, 0xFF, 0x8F, 0xF8, 0x1C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x2F, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xEF,
  0x80, 0xFC, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x81, 0x0F, 0x7E, 0x7E, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0x00, 0x30, 0x3C, 0x7F, 0x8F, 0x3F, 0xF3, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0x1F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7C, 0x3F,
  0x9F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x1E,
  0x7F, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF3, 0xF9, 0xF8, 0x1F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x81, 0xF3, 0xFC, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xF7,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x3C, 0x7F, 0xF7, 0x8F, 0xFF, 0xF3, 0xF8, 0xFE, 0xFC, 0x0F, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xE7, 0xC0, 0xFC, 0xFE, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x10, 0xF0,
  0xFF, 0xF3, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0x02, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7E, 0x0F, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0xE0, 0xFD,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xBC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0xDF, 0xF3, 0xFF,
  0xBC, 0xFF, 0xCF, 0x0F, 0xE3, 0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x1E, 0x78, 0xF8,
  0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x78,
  0xE7, 0x79, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xF6,
  0x3B, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0xFC, 0x01, 0xFB,
  0xE0, 0x1F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C,
  0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x07, 0xF8, 0x3F,
  0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x1E, 0xF0, 0xFF, 0xFB, 0x81,
  0xFF, 0xEE, 0x03, 0xFF, 0x00, 0x03, 0xF8,
};

const GFXglyph RobotoMono_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 28, 24, 9, -28 },
  { 22, 11, 10, 24, 6, -30 },
  { 36, 22, 28, 24, 1, -28 },
  { 113, 19, 37, 24, 3, -33 },
  { 201, 22, 29, 24, 1, -29 },
  { 281, 22, 29, 24, 2, -29 },
  { 361, 4, 10, 24, 9, -30 },
  { 366, 10, 41, 24, 7, -32 },
  { 418, 11, 41, 24, 6, -32 },
  { 475, 20, 19, 24, 3, -28 },
  { 523, 20, 21, 24, 2, -24 },
  { 576, 6, 12, 24, 7, -5 },
  { 585, 16, 3, 24, 5, -14 },
  { 591, 7, 6, 24, 9, -6 },
  { 597, 15, 30, 24, 5, -28 },
  { 654, 18, 29, 24, 3, -29 },
  { 720, 12, 28, 24, 4, -28 },
  { 762, 20, 29, 24, 1, -29 },
  { 835, 19, 29, 24, 2, -29 },
  { 904, 21, 28, 24, 1, -28 },
  { 978, 18, 28, 24, 3, -28 },
  { 1041, 19, 29, 24, 2, -29 },
  { 1110, 19, 28, 24, 2, -28 },
  { 1177, 18, 29, 24, 3, -29 },
  { 1243, 19, 29, 24, 2, -29 },
  { 1312, 7, 23, 24, 9, -23 },
  { 1333, 8, 30, 24, 9, -23 },
  { 1363, 17, 19, 24, 3, -22 },
  { 1404, 18, 12, 24, 3, -18 },
  { 1431, 18, 19, 24, 3, -22 },
  { 1474, 18, 29, 24, 3, -29 },
  { 1540, 22, 28, 24, 1, -28 },
  { 1617, 23, 28, 24, 1, -28 },
  { 1698, 20, 28, 24, 3, -28 },
  { 1768, 20, 29, 24, 2, -29 },
  { 1841, 19, 28, 24, 3, -28 },
  { 1908, 19, 28, 24, 3, -28 },
  { 1975, 19, 28, 24, 3, -28 },
  { 2042, 20, 29, 24, 2, -29 },
  { 2115, 18, 28, 24, 3, -28 },
  { 2178, 16, 28, 24, 4, -28 },
  { 2234, 19, 28, 24, 2, -28 },
  { 2301, 21, 28, 24, 3, -28 },
  { 2375, 19, 28, 24, 3, -28 },
  { 2442, 19, 28, 24, 3, -28 },
  { 2509, 18, 28, 24, 3, -28 },
  { 2572, 20, 29, 24, 2, -29 },
  { 2645, 20, 28, 24, 3, -28 },
  { 2715, 21, 34, 24, 2, -29 },
  { 2805, 20, 28, 24, 3, -28 },
  { 2875, 20, 29, 24, 2, -29 },
  { 2948, 22, 28, 24, 1, -28 },
  { 3025, 18, 28, 24, 3, -28 },
  { 3088, 22, 28, 24, 1, -28 },
  { 3165, 22, 28, 24, 1, -28 },
  { 3242, 22, 28, 24, 1, -28 },
  { 3319, 22, 28, 24, 1, -28 },
  { 3396, 20, 28, 24, 2, -28 },
  { 3466, 8, 39, 24, 8, -33 },
  { 3505, 15, 30, 24, 5, -28 },
  { 3562, 8, 39, 24, 8, -33 },
  { 3601, 16, 15, 24, 4, -28 },
  { 3631, 18, 4, 24, 3, 0 },
  { 3640, 9, 5, 24, 8, -29 },
  { 3646, 18, 22, 24, 3, -22 },
  { 3696, 19, 30, 24, 3, -30 },
  { 3768, 19, 22, 24, 2, -22 },
  { 3821, 19, 30, 24, 2, -30 },
  { 3893, 20, 22, 24, 2, -22 },
  { 3948, 19, 31, 24, 3, -31 },
  { 4022, 19, 30, 24, 2, -22 },
  { 4094, 18, 30, 24, 3, -30 },
  { 4162, 18, 29, 24, 4, -29 },
  { 4228, 13, 38, 24, 4, -29 },
  { 4290, 20, 30, 24, 3, -30 },
  { 4365, 18, 30, 24, 4, -30 },
  { 4433, 20, 22, 24, 2, -22 },
  { 4488, 18, 22, 24, 3, -22 },
  { 4538, 20, 22, 24, 2, -22 },
  { 4593, 19, 30, 24, 3, -22 },
  { 4665, 19, 30, 24, 2, -22 },
  { 4737, 16, 22, 24, 6, -22 },
  { 4781, 18, 22, 24, 3, -22 },
  { 4831, 18, 26, 24, 3, -26 },
  { 4890, 18, 21, 24, 3, -21 },
  { 4938, 20, 21, 24, 2, -21 },
  { 4991, 22, 21, 24, 1, -21 },
  { 5049, 21, 21, 24, 2, -21 },
  { 5105, 22, 30, 24, 1, -21 },
  { 5188, 19, 21, 24, 3, -21 },
  { 5238, 13, 38, 24, 6, -31 },
  { 5300, 4, 36, 24, 10, -28 },
  { 5318, 14, 38, 24, 6, -31 },
  { 5385, 22, 8, 24, 1, -16 },
};

const GFXfont RobotoMono_Medium40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium40pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_MEDIUM40PT7B_H_
