#ifndef _ROBOTOMONO_MEDIUM37PT7B_H_
#define _ROBOTOMONO_MEDIUM37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x00, 0xC7, 0xBF, 0xF9, 0xE0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x01, 0xE3, 0xC0,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x38,
  0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1E,
  0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE, 0x7C, 0x1F, 0x3C, 0x07, 0xDE,
  0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xEF,
  0xC7, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x0E, 0x38, 0x00, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C,
  0xE0, 0xE3, 0x8E, 0x0F, 0xF9, 0xC0, 0x7F, 0x18, 0x01, 0xE3, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC7, 0xC0,
  0x1C, 0xFE, 0x03, 0x9E, 0xF0, 0x39, 0xC7, 0x07, 0x38, 0x70, 0x63, 0x87,
  0x0E, 0x38, 0x70, 0x21, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E,
  0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03,
  0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0xE7, 0xFE, 0x0E, 0x7D, 0xF1, 0xEF, 0x8F, 0x9E, 0xF0, 0x79,
  0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0xCF, 0x01, 0xFC, 0xF8, 0x0F, 0x8F, 0xC3,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xBE, 0x1F, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xC0,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x70,
  0x6F, 0xCC, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0x78, 0x03, 0x8F, 0x01, 0xE1, 0xE0, 0xF0, 0x7C, 0x1C,
  0x0E, 0x02, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x7B, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x11, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x9F, 0x7F, 0xDF, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x79, 0xE0,
  0x7C, 0xF8, 0x7C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x60,
  0x7C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xF8, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0x1F,
  0x1E, 0x01, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x3E, 0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0xCF, 0xC7, 0xF0, 0x80, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7,
  0xC0, 0xF9, 0xF0, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x7F, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03,
  0xE3, 0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x01, 0xE3, 0xC0, 0xF0, 0xFC, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x9E,
  0x01, 0xE7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0,
  0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xC0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0x79, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0xE0, 0x7D, 0xF8, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xF3,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x33, 0xEF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xFB, 0xFF, 0xFF, 0x78,
  0x18, 0x7D, 0xFB, 0xF7, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF3, 0xC1,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xCF, 0x81, 0xE0, 0x1C, 0x1C, 0x00, 0xE3, 0x83, 0x06, 0x30, 0xFE,
  0x67, 0x1F, 0xE7, 0x73, 0xCE, 0x76, 0x38, 0xE3, 0xE3, 0x0E, 0x3E, 0x70,
  0xE3, 0xE7, 0x0C, 0x3E, 0x70, 0xC3, 0xE7, 0x0C, 0x7E, 0x70, 0xC6, 0xE7,
  0x1C, 0x6E, 0x7B, 0xCE, 0xE3, 0xFF, 0xC6, 0x3E, 0x78, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x02, 0x01, 0xF9, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07,
  0xCF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x03, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0x01, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78,
  0xF8, 0x7E, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x3F, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0x3E,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8,
  0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0,
  0x3E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xDE, 0x00, 0xF7, 0xC0, 0x3C, 0xFC, 0x3F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xC0, 0x7F, 0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x7D, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0xF0, 0x07, 0xFE, 0x01, 0xF3, 0xC0, 0x7E, 0x78, 0x0F,
  0x8F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF1, 0xF0,
  0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xEF, 0x80, 0xF8, 0xF8, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0x80, 0x7E,
  0xF0, 0x07, 0xDE, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xDC, 0xFF, 0xF7, 0x3B, 0xFD, 0xEE, 0xFF,
  0x3F, 0xBF, 0xCF, 0xCF, 0xF3, 0xF3, 0xFC, 0x7C, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF8, 0xE3, 0xFE, 0x30, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFE, 0xE1, 0xFF, 0xBC,
  0x7F, 0xEF, 0x1F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8F, 0x7F, 0xE3, 0xDF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x00,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE1, 0xF8, 0xF8,
  0x1F, 0x1E, 0x01, 0xF7, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80,
  0x7C, 0xF0, 0x0F, 0x1F, 0x03, 0xE1, 0xF9, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0,
  0xFE, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3E, 0x1F, 0x87, 0xC0, 0xF8, 0x78, 0x07, 0xCF, 0x80, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x7C, 0x0F,
  0x83, 0xF3, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xFB,
  0xC0, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x07,
  0xCF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F,
  0x9E, 0x00, 0xF3, 0xC0, 0x1F, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xF1, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0,
  0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07,
  0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE1, 0xE1, 0xEF, 0x0F,
  0x8F, 0x3C, 0x7C, 0x79, 0xE7, 0xE3, 0xCF, 0x3F, 0x1E, 0x79, 0xF8, 0xE3,
  0xCF, 0xCF, 0x1E, 0x7F, 0x78, 0xF3, 0xBB, 0xC7, 0xBD, 0xDE, 0x1D, 0xCE,
  0xF0, 0xFE, 0x77, 0x87, 0xF3, 0xBC, 0x3F, 0x9F, 0xC1, 0xFC, 0x7E, 0x0F,
  0xE3, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3F,
  0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xFC, 0x01, 0xF3,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87,
  0xC0, 0x3E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xC0, 0x1F,
  0x1F, 0x01, 0xF0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xFB, 0xC0, 0x0F, 0x9F,
  0x00, 0xF8, 0x78, 0x07, 0xC3, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x1E,
  0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0x70,
  0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xEF, 0x03, 0xDE, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xC0, 0xF8, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFC, 0x7C, 0x0F, 0x9E, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0,
  0x1E, 0x78, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E, 0x7C, 0x3F,
  0x9F, 0xFF, 0xE3, 0xFF, 0x78, 0x7F, 0x9F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF1, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xC1, 0xF7, 0xC0,
  0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x3E, 0xFC, 0x3F,
  0x7F, 0xFF, 0x3D, 0xFF, 0x1E, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x17, 0x80, 0x79, 0xF0, 0x1E, 0x3E, 0x1F, 0x87, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xC7, 0x87,
  0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F, 0x3F, 0x1F, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFC, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x11, 0xF0, 0x0E, 0x3F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0x02, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE3,
  0x87, 0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F, 0x3F, 0x1F, 0x9F, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x40, 0x3E, 0x70,
  0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF1, 0xF0, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF,
  0xC1, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFC, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF0,
  0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xF9, 0xF0, 0x3C, 0x3E, 0x0F, 0x07,
  0xC3, 0xC1, 0xF8, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F, 0x7E,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0xF1, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xF7, 0x80, 0x7D, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0xF1, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x81,
  0xF7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x3E,
  0xFC, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1E, 0x7F, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xE7, 0x87, 0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0,
  0xFB, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F,
  0x3E, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFC, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0xF0, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0x9B, 0xF0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xCF, 0xEF, 0x80, 0xF7,
  0xC0, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFC,
  0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x80, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFE, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0x7C, 0x3F, 0xBF, 0xFF, 0xCF, 0xFB, 0xE3, 0xF8, 0xF0, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x7C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0,
  0x60, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF7,
  0x0F, 0x8E, 0x71, 0xF8, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x99, 0x9E,
  0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xF9, 0xDC, 0x3F, 0x0F,
  0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xF1,
  0xF0, 0x1E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xCF,
  0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x1F, 0x7C, 0x01,
  0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC3,
  0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x07,
  0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x7D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x1F, 0x03, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0xFE, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x03, 0xF0,
  0x7F, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x08,
  0x00, 0x0E, 0x00, 0x03, 0xF8, 0x07, 0x7F, 0xC0, 0x7F, 0xFF, 0x0F, 0xF1,
  0xFF, 0xEE, 0x07, 0xFE, 0xE0, 0x3F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoMono_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 10, 9, 22, 6, -28 },
  { 33, 20, 26, 22, 1, -26 },
  { 98, 17, 35, 22, 3, -31 },
  { 173, 20, 27, 22, 1, -27 },
  { 241, 20, 27, 22, 2, -27 },
  { 309, 3, 10, 22, 9, -28 },
  { 313, 10, 37, 22, 6, -29 },
  { 360, 10, 37, 22, 6, -29 },
  { 407, 18, 18, 22, 3, -26 },
  { 448, 18, 19, 22, 2, -22 },
  { 491, 6, 11, 22, 6, -4 },
  { 500, 14, 3, 22, 5, -13 },
  { 506, 6, 6, 22, 8, -6 },
  { 511, 15, 28, 22, 4, -26 },
  { 564, 17, 27, 22, 3, -27 },
  { 622, 11, 26, 22, 3, -26 },
  { 658, 19, 27, 22, 1, -27 },
  { 723, 17, 27, 22, 2, -27 },
  { 781, 19, 26, 22, 1, -26 },
  { 843, 17, 26, 22, 3, -26 },
  { 899, 18, 26, 22, 2, -26 },
  { 958, 18, 26, 22, 2, -26 },
  { 1017, 18, 27, 22, 2, -27 },
  { 1078, 17, 27, 22, 2, -27 },
  { 1136, 6, 21, 22, 9, -21 },
  { 1152, 7, 28, 22, 8, -21 },
  { 1177, 16, 17, 22, 3, -20 },
  { 1211, 17, 11, 22, 3, -17 },
  { 1235, 16, 17, 22, 3, -20 },
  { 1269, 17, 27, 22, 3, -27 },
  { 1327, 20, 26, 22, 1, -26 },
  { 1392, 21, 26, 22, 1, -26 },
  { 1461, 18, 26, 22, 3, -26 },
  { 1520, 18, 27, 22, 2, -27 },
  { 1581, 19, 26, 22, 2, -26 },
  { 1643, 17, 26, 22, 3, -26 },
  { 1699, 17, 26, 22, 3, -26 },
  { 1755, 18, 27, 22, 2, -27 },
  { 1816, 18, 26, 22, 2, -26 },
  { 1875, 16, 26, 22, 3, -26 },
  { 1927, 17, 26, 22, 2, -26 },
  { 1983, 19, 26, 22, 3, -26 },
  { 2045, 17, 26, 22, 3, -26 },
  { 2101, 18, 26, 22, 2, -26 },
  { 2160, 18, 26, 22, 2, -26 },
  { 2219, 19, 27, 22, 2, -27 },
  { 2284, 18, 26, 22, 3, -26 },
  { 2343, 20, 32, 22, 2, -27 },
  { 2423, 18, 26, 22, 3, -26 },
  { 2482, 19, 27, 22, 2, -27 },
  { 2547, 20, 26, 22, 1, -26 },
  { 2612, 18, 26, 22, 2, -26 },
  { 2671, 20, 26, 22, 1, -26 },
  { 2736, 21, 26, 22, 1, -26 },
  { 2805, 21, 26, 22, 1, -26 },
  { 2874, 21, 26, 22, 1, -26 },
  { 2943, 18, 26, 22, 2, -26 },
  { 3002, 8, 36, 22, 7, -30 },
  { 3038, 15, 28, 22, 4, -26 },
  { 3091, 8, 36, 22, 7, -30 },
  { 3127, 15, 14, 22, 4, -26 },
  { 3154, 16, 3, 22, 3, 0 },
  { 3160, 9, 5, 22, 7, -27 },
  { 3166, 18, 20, 22, 2, -20 },
  { 3211, 17, 28, 22, 3, -28 },
  { 3271, 18, 20, 22, 2, -20 },
  { 3316, 17, 28, 22, 2, -28 },
  { 3376, 18, 20, 22, 2, -20 },
  { 3421, 19, 29, 22, 2, -29 },
  { 3490, 17, 28, 22, 2, -20 },
  { 3550, 17, 28, 22, 3, -28 },
  { 3610, 16, 27, 22, 4, -27 },
  { 3664, 12, 35, 22, 4, -27 },
  { 3717, 18, 28, 22, 3, -28 },
  { 3780, 16, 28, 22, 4, -28 },
  { 3836, 20, 20, 22, 1, -20 },
  { 3886, 17, 20, 22, 3, -20 },
  { 3929, 18, 20, 22, 2, -20 },
  { 3974, 17, 28, 22, 3, -20 },
  { 4034, 17, 28, 22, 2, -20 },
  { 4094, 14, 20, 22, 6, -20 },
  { 4129, 17, 20, 22, 3, -20 },
  { 4172, 18, 24, 22, 2, -24 },
  { 4226, 17, 20, 22, 3, -20 },
  { 4269, 20, 20, 22, 1, -20 },
  { 4319, 20, 20, 22, 1, -20 },
  { 4369, 19, 20, 22, 2, -20 },
  { 4417, 21, 28, 22, 1, -20 },
  { 4491, 18, 20, 22, 2, -20 },
  { 4536, 12, 36, 22, 6, -29 },
  { 4590, 3, 33, 22, 10, -26 },
  { 4603, 12, 36, 22, 6, -29 },
  { 4657, 20, 8, 22, 1, -15 },
};

const GFXfont RobotoMono_Medium37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium37pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_MEDIUM37PT7B_H_
