#ifndef _ROBOTOMONO_MEDIUM12PT7B_H_
#define _ROBOTOMONO_MEDIUM12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0x80, 0x14, 0x28, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x58, 0x20, 0xCF, 0xB3, 0xC1, 0xC1, 0xA3, 0xC9, 0xE2, 0x00, 0x61, 0x5A,
  0xA3, 0x41, 0x02, 0x8A, 0x95, 0x0E, 0x23, 0x4D, 0x1C, 0x63, 0x99, 0xE6,
  0xFC, 0xE0, 0x25, 0x2D, 0x24, 0x89, 0x12, 0x91, 0x32, 0x49, 0x2D, 0x68,
  0x20, 0x8A, 0xDE, 0x31, 0x20, 0x21, 0x3F, 0xF2, 0x10, 0x58, 0xF8, 0xB0,
  0x08, 0xC4, 0x23, 0x10, 0x88, 0x46, 0x00, 0x36, 0xE3, 0x1B, 0xE6, 0x39,
  0x70, 0x17, 0xB3, 0x33, 0x33, 0x30, 0x31, 0xFC, 0x43, 0x08, 0x63, 0x18,
  0x7C, 0x66, 0xE2, 0x17, 0x0C, 0x31, 0xF0, 0x0C, 0x38, 0x71, 0x66, 0xC9,
  0xBF, 0x86, 0x0C, 0x7F, 0xF1, 0xEF, 0x84, 0x39, 0x78, 0x13, 0xB1, 0x6D,
  0xC6, 0x39, 0x70, 0xFF, 0xC2, 0x21, 0x18, 0x8C, 0x40, 0x36, 0xE3, 0x97,
  0x66, 0x31, 0x78, 0x67, 0xE3, 0x18, 0xFC, 0x22, 0x60, 0xF0, 0x3C, 0xF0,
  0x0F, 0x80, 0x1F, 0xB0, 0xF0, 0x80, 0xFF, 0xC1, 0xF0, 0xC1, 0xC7, 0xE8,
  0x00, 0x37, 0xE2, 0x11, 0x10, 0x04, 0x20, 0x3C, 0xB6, 0xAD, 0x5A, 0xB7,
  0x90, 0x1C, 0x10, 0x30, 0xE1, 0x42, 0xCC, 0x9F, 0x23, 0xC6, 0xE3, 0xE8,
  0xE2, 0xF2, 0x38, 0xE3, 0xF8, 0x33, 0xE8, 0xE0, 0x82, 0x08, 0xF2, 0x78,
  0xC3, 0xE8, 0xA3, 0x8E, 0x38, 0xA6, 0xF0, 0xFF, 0xE1, 0x0F, 0xC2, 0x10,
  0xF8, 0xFF, 0xF8, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x33, 0xE8, 0xE0, 0x82,
  0x78, 0xF3, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xFF, 0xC8, 0x42,
  0x10, 0x84, 0xF8, 0x08, 0x42, 0x10, 0x84, 0x33, 0x70, 0x8E, 0x29, 0x2C,
  0xE3, 0xC9, 0xA2, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xCF, 0x7D,
  0xF7, 0xBE, 0xB8, 0xE3, 0x8C, 0x8E, 0x73, 0xDA, 0xDE, 0x73, 0x88, 0x33,
  0xE8, 0xA3, 0x8E, 0x38, 0xF2, 0x70, 0xE3, 0xE8, 0xE3, 0x9B, 0xC8, 0x20,
  0x80, 0x33, 0xE8, 0xA3, 0x8E, 0x38, 0xF2, 0x78, 0x30, 0xE3, 0xE8, 0xE3,
  0x9B, 0xC9, 0xA2, 0x8C, 0x33, 0xE8, 0xF0, 0x70, 0x68, 0xE3, 0x78, 0xFF,
  0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x39,
  0x70, 0xC6, 0x8D, 0x13, 0x22, 0xC5, 0x0A, 0x1C, 0x10, 0xD3, 0xA5, 0x5A,
  0xF6, 0xCD, 0x9B, 0x36, 0x6C, 0xC6, 0xC8, 0xB1, 0xC1, 0x87, 0x0B, 0x32,
  0xC6, 0xC6, 0x89, 0x91, 0x63, 0x83, 0x04, 0x08, 0x10, 0xFB, 0xE1, 0x84,
  0x21, 0x84, 0x20, 0xFC, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC2, 0x10, 0xC2,
  0x10, 0x42, 0x18, 0x40, 0xED, 0xB6, 0xDB, 0x6D, 0xF0, 0x21, 0x94, 0xAC,
  0x80, 0xF8, 0xC4, 0xFC, 0x5F, 0x18, 0xFC, 0x84, 0x21, 0xF8, 0xC6, 0x39,
  0xF8, 0xFC, 0x61, 0x0C, 0xB8, 0x08, 0x43, 0xF8, 0xC6, 0x39, 0x78, 0x7A,
  0x2F, 0xE0, 0xC9, 0xE0, 0x3C, 0x86, 0x3E, 0x61, 0x86, 0x18, 0x60, 0xFC,
  0x63, 0x1C, 0xBC, 0x3F, 0x20, 0x84, 0x21, 0xF8, 0xC6, 0x31, 0x88, 0x31,
  0x01, 0xE3, 0x18, 0xC6, 0xF8, 0x13, 0x07, 0x11, 0x11, 0x11, 0xF4, 0x82,
  0x08, 0x26, 0xB3, 0x8F, 0x26, 0x8C, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0xFC, 0xFF, 0xAF, 0x5E, 0xBD, 0x7A, 0xC0, 0xFC, 0x63, 0x18, 0xC4, 0xFA,
  0x28, 0xE3, 0xC9, 0xC0, 0xFC, 0x63, 0x18, 0xFE, 0x10, 0xFC, 0x63, 0x1C,
  0xBC, 0x21, 0xFC, 0x88, 0x88, 0xFC, 0x5C, 0x38, 0xBC, 0x63, 0x3E, 0xC6,
  0x31, 0x87, 0x8C, 0x63, 0x1C, 0xBC, 0xC6, 0xC8, 0xB1, 0x43, 0x82, 0x00,
  0xD2, 0xAD, 0xB3, 0x66, 0xCD, 0x80, 0xCD, 0x43, 0x1C, 0x5A, 0x30, 0xC6,
  0xC8, 0xB1, 0x41, 0x82, 0x04, 0x38, 0x40, 0xF8, 0x63, 0x18, 0xC3, 0xF0,
  0x36, 0x66, 0x4C, 0x66, 0x62, 0x30, 0xFF, 0xE0, 0xC4, 0x44, 0x63, 0x64,
  0x44, 0xC0, 0x61, 0xBC, 0x30,
};

const GFXglyph RobotoMono_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 6, 11, 7, 1, -10 },
  { 22, 7, 9, 7, 0, -9 },
  { 30, 6, 9, 7, 1, -9 },
  { 37, 1, 3, 7, 3, -9 },
  { 38, 3, 13, 7, 2, -10 },
  { 43, 3, 13, 7, 2, -10 },
  { 48, 6, 6, 7, 1, -9 },
  { 53, 5, 6, 7, 1, -7 },
  { 57, 2, 3, 7, 2, -1 },
  { 58, 5, 1, 7, 1, -4 },
  { 59, 2, 2, 7, 3, -2 },
  { 60, 5, 10, 7, 1, -9 },
  { 67, 5, 9, 7, 1, -9 },
  { 73, 4, 9, 7, 1, -9 },
  { 78, 6, 9, 7, 0, -9 },
  { 85, 5, 9, 7, 1, -9 },
  { 91, 7, 9, 7, 0, -9 },
  { 99, 5, 9, 7, 1, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 2, 7, 7, 3, -7 },
  { 131, 2, 9, 7, 3, -7 },
  { 134, 5, 5, 7, 1, -6 },
  { 138, 5, 4, 7, 1, -6 },
  { 141, 5, 5, 7, 1, -6 },
  { 145, 5, 9, 7, 1, -9 },
  { 151, 7, 8, 7, 0, -8 },
  { 158, 7, 9, 7, 0, -9 },
  { 166, 6, 9, 7, 1, -9 },
  { 173, 6, 9, 7, 1, -9 },
  { 180, 6, 9, 7, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 6, 9, 7, 1, -9 },
  { 200, 6, 9, 7, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 5, 9, 7, 1, -9 },
  { 219, 5, 9, 7, 1, -9 },
  { 225, 6, 9, 7, 1, -9 },
  { 232, 5, 9, 7, 1, -9 },
  { 238, 6, 9, 7, 1, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 6, 9, 7, 1, -9 },
  { 258, 6, 9, 7, 1, -9 },
  { 265, 6, 10, 7, 1, -9 },
  { 273, 6, 9, 7, 1, -9 },
  { 280, 6, 9, 7, 1, -9 },
  { 287, 7, 9, 7, 0, -9 },
  { 295, 5, 9, 7, 1, -9 },
  { 301, 7, 9, 7, 0, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 7, 9, 7, 0, -9 },
  { 333, 6, 9, 7, 1, -9 },
  { 340, 3, 12, 7, 2, -10 },
  { 345, 5, 10, 7, 1, -9 },
  { 352, 3, 12, 7, 2, -10 },
  { 357, 5, 5, 7, 1, -9 },
  { 361, 5, 1, 7, 1, 0 },
  { 362, 3, 2, 7, 2, -9 },
  { 363, 5, 6, 7, 1, -6 },
  { 367, 5, 9, 7, 1, -9 },
  { 373, 5, 6, 7, 1, -6 },
  { 377, 5, 9, 7, 1, -9 },
  { 383, 6, 6, 7, 1, -6 },
  { 388, 6, 9, 7, 1, -9 },
  { 395, 5, 9, 7, 1, -6 },
  { 401, 5, 9, 7, 1, -9 },
  { 407, 5, 9, 7, 1, -9 },
  { 413, 4, 12, 7, 1, -9 },
  { 419, 6, 9, 7, 1, -9 },
  { 426, 6, 9, 7, 1, -9 },
  { 433, 7, 6, 7, 0, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 6, 6, 7, 1, -6 },
  { 448, 5, 8, 7, 1, -6 },
  { 453, 5, 8, 7, 1, -6 },
  { 458, 4, 6, 7, 2, -6 },
  { 461, 5, 6, 7, 1, -6 },
  { 465, 5, 8, 7, 1, -8 },
  { 470, 5, 6, 7, 1, -6 },
  { 474, 7, 6, 7, 0, -6 },
  { 480, 7, 6, 7, 0, -6 },
  { 486, 6, 6, 7, 1, -6 },
  { 491, 7, 9, 7, 0, -6 },
  { 499, 6, 6, 7, 1, -6 },
  { 504, 4, 11, 7, 2, -9 },
  { 510, 1, 11, 7, 3, -9 },
  { 512, 4, 11, 7, 2, -9 },
  { 518, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_Medium12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium12pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_MEDIUM12PT7B_H_
