#ifndef _ROBOTOMONO_MEDIUM19PT7B_H_
#define _ROBOTOMONO_MEDIUM19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xDB, 0x60, 0x0F, 0xC0, 0xDE, 0xE7, 0x30, 0x0C, 0xC1,
  0x90, 0x32, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xC8, 0x11, 0x1F, 0xF8,
  0x4C, 0x19, 0x83, 0x20, 0x64, 0x00, 0x0C, 0x06, 0x03, 0x87, 0xE7, 0x3B,
  0x0D, 0x86, 0xE0, 0x3C, 0x0F, 0x80, 0xE0, 0x3E, 0x1B, 0x0D, 0xFE, 0x7E,
  0x0C, 0x06, 0x00, 0x30, 0x0F, 0x03, 0x22, 0x66, 0xCC, 0x90, 0xF4, 0x01,
  0x80, 0x20, 0x0D, 0xC1, 0x7C, 0x69, 0x89, 0x30, 0x36, 0x03, 0x80, 0x1C,
  0x0F, 0x87, 0x61, 0x8C, 0x66, 0x1F, 0x83, 0x81, 0xE0, 0xEC, 0xF3, 0xBC,
  0x7B, 0x0E, 0xFF, 0x9F, 0x70, 0xFF, 0xC0, 0x08, 0xCC, 0x46, 0x31, 0x98,
  0xC6, 0x31, 0x84, 0x31, 0x8C, 0x30, 0xC2, 0x86, 0x18, 0x63, 0x18, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x62, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0x32,
  0xFF, 0xC7, 0x81, 0xE0, 0x4C, 0x33, 0x88, 0x40, 0x0C, 0x06, 0x03, 0x01,
  0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x6D, 0xBC, 0x80, 0xFF,
  0xFF, 0x7F, 0x80, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x70, 0x60, 0x60, 0xC0, 0x1C, 0x1F, 0x98, 0xCC, 0x3E, 0x1F,
  0x1F, 0x9F, 0xFB, 0xF1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0x08, 0xFF,
  0xB9, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x1C, 0x3F, 0xB9, 0xD8, 0x6C,
  0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0xFF, 0xFC, 0x1C,
  0x3F, 0xB8, 0xD8, 0x70, 0x38, 0x18, 0x7C, 0x3E, 0x03, 0x00, 0xF0, 0x78,
  0x77, 0xF1, 0xF0, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB1, 0x98, 0xCC, 0xC6,
  0xC3, 0x7F, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x7F, 0xBF, 0xD8, 0x0C, 0x06,
  0x03, 0xF1, 0xFC, 0x47, 0x01, 0x80, 0xF8, 0x6C, 0x37, 0xF1, 0xF0, 0x02,
  0x0F, 0x0E, 0x0E, 0x06, 0x07, 0xF3, 0xFD, 0xC7, 0xC1, 0xE0, 0xF8, 0x6C,
  0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x03, 0x03, 0x03, 0x80, 0x1C, 0x1F, 0x98, 0xEC, 0x36,
  0x1B, 0x1C, 0xFC, 0x7E, 0x63, 0xF0, 0xF8, 0x7C, 0x37, 0xF1, 0xF0, 0x1C,
  0x3F, 0x18, 0xDC, 0x7C, 0x1E, 0x0F, 0x86, 0xC7, 0x7F, 0x8D, 0xC0, 0xC0,
  0xE3, 0xE1, 0xC0, 0x6F, 0x60, 0x00, 0x00, 0x6F, 0x60, 0x67, 0x70, 0x00,
  0x00, 0x06, 0x66, 0x6C, 0x40, 0x01, 0x83, 0xCF, 0x9E, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xF0, 0x7C, 0x0F,
  0x07, 0x3E, 0xF0, 0xC0, 0x38, 0x7E, 0xE7, 0xC3, 0x03, 0x07, 0x0E, 0x1C,
  0x18, 0x18, 0x00, 0x00, 0x38, 0x18, 0x1F, 0x86, 0x18, 0x89, 0x37, 0xB4,
  0x92, 0xB2, 0x76, 0x4E, 0xCB, 0x5B, 0x49, 0xB9, 0x80, 0x18, 0x81, 0xF0,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x36, 0x06, 0x60, 0xCC, 0x31,
  0x87, 0xF8, 0xFF, 0x38, 0x66, 0x0F, 0xC0, 0xC0, 0xF8, 0x3F, 0xCE, 0x3B,
  0x86, 0xE1, 0xB8, 0x6F, 0xF3, 0xFC, 0xE1, 0xB8, 0x7E, 0x1F, 0x86, 0xFF,
  0xBF, 0xC0, 0x1C, 0x0F, 0xC6, 0x3B, 0x86, 0xC1, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x19, 0x86, 0x7F, 0x8F, 0x80, 0xF0, 0x3F, 0x8E, 0x73,
  0x8E, 0xE1, 0xB8, 0x6E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x1B, 0x8E, 0xFF,
  0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1C, 0x1F, 0x9C, 0xFC,
  0x3C, 0x06, 0x03, 0x01, 0x8F, 0xC7, 0xE0, 0xF0, 0x6C, 0x37, 0xF9, 0xF8,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0xE1, 0xF8,
  0x6E, 0x3B, 0x9C, 0xEE, 0x3B, 0x0F, 0xC3, 0xF0, 0xFE, 0x39, 0xCE, 0x33,
  0x8E, 0xE1, 0xB8, 0x70, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE1, 0xF1, 0xFC, 0xFE, 0x7D, 0x7E,
  0xBF, 0x77, 0xBB, 0xCD, 0xE4, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xC1, 0xF0,
  0xF8, 0x7E, 0x3F, 0x1E, 0xCF, 0x67, 0x9B, 0xCD, 0xE3, 0xF1, 0xF8, 0x7C,
  0x3E, 0x0C, 0x1C, 0x0F, 0xC7, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x6C, 0x19, 0x8E, 0x7F, 0x0F, 0x80, 0xF0, 0x7F, 0x31, 0xD8,
  0x7C, 0x3E, 0x1F, 0x0D, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00,
  0x1C, 0x0F, 0xC7, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x19, 0x8E, 0x7F, 0x0F, 0xC0, 0x1C, 0x03, 0xF8, 0x3F, 0xCE, 0x3B,
  0x86, 0xE1, 0xB8, 0x6E, 0x3B, 0xFC, 0xFE, 0x39, 0xCE, 0x33, 0x8E, 0xE1,
  0xB8, 0x70, 0x1C, 0x1F, 0xC6, 0x3B, 0x87, 0xE0, 0x1C, 0x07, 0xC0, 0x7C,
  0x03, 0x80, 0x7C, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFC, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xE0, 0xEC, 0x1D, 0x83,
  0x38, 0x63, 0x1C, 0x63, 0x0E, 0x60, 0xCC, 0x1B, 0x03, 0x60, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x00, 0xE6, 0x6C, 0xCD, 0x99, 0xB7, 0x36, 0xE6, 0xDD,
  0x9B, 0xF3, 0x5E, 0x6B, 0xC7, 0x78, 0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x00,
  0x60, 0xEE, 0x18, 0xC7, 0x1C, 0xC1, 0xB8, 0x3E, 0x03, 0xC0, 0x70, 0x0F,
  0x03, 0xF0, 0x66, 0x18, 0xE7, 0x0D, 0xC1, 0xC0, 0xE0, 0x6C, 0x1D, 0xC3,
  0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30,
  0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0xFF, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18, 0x18, 0x38, 0x3C, 0x6C,
  0x66, 0x46, 0xC3, 0xFF, 0xFF, 0xC0, 0xC6, 0x30, 0x3E, 0x3B, 0xB8, 0xE0,
  0x33, 0xFB, 0x8F, 0x87, 0xC7, 0x7F, 0xBE, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0xF7, 0xFB, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xF7, 0xF8,
  0x3E, 0x3F, 0x98, 0x7C, 0x3C, 0x06, 0x03, 0x80, 0xC3, 0x7F, 0x1F, 0x00,
  0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0xFD, 0x8F, 0xC3, 0xC1, 0xE0, 0xF8,
  0x6C, 0x77, 0xF9, 0xEC, 0x3E, 0x3F, 0x98, 0x7C, 0x3F, 0xFF, 0xFF, 0x80,
  0xC2, 0x7F, 0x9F, 0x80, 0x03, 0x83, 0xF1, 0xC0, 0x60, 0x18, 0x3F, 0xEF,
  0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x3D,
  0xBF, 0xD8, 0x7C, 0x3C, 0x1E, 0x0F, 0x86, 0xC3, 0x7F, 0x9E, 0xC0, 0x68,
  0x77, 0xF1, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0x18, 0x18, 0x00, 0x00, 0xF8,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x0C, 0x70, 0x80,
  0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xFB, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xCE, 0xE3, 0xF0, 0xFC, 0x3F, 0x0E,
  0x63, 0x9C, 0xE3, 0xB8, 0x70, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFB, 0xBF, 0xEC, 0xCF, 0x33,
  0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x30, 0xDF, 0x7F, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xC0, 0x3E, 0x3F, 0xB8, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x1F, 0x00, 0xFF, 0x7F, 0xB8, 0xFC,
  0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0x3D, 0xBF, 0xD8, 0x7C, 0x3C, 0x1E, 0x0F, 0x86, 0xC3, 0x7F, 0x9E, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0xDF, 0xFF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x80, 0x3F, 0x3B, 0xD8, 0x6C, 0x07, 0xE0, 0xFC, 0x07, 0xC3, 0x77, 0x9F,
  0x80, 0x18, 0x0C, 0x3F, 0xFF, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0xE1, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0x7B, 0xC1, 0xF8, 0x66, 0x39, 0x8C, 0x33, 0x0D, 0x83, 0x60, 0x78, 0x1C,
  0x03, 0x00, 0xC6, 0x6C, 0xCD, 0xB9, 0xB7, 0x66, 0xAC, 0xD7, 0x8A, 0xF1,
  0xCE, 0x31, 0x86, 0x30, 0xE1, 0xDC, 0xE3, 0x70, 0x78, 0x1C, 0x07, 0x83,
  0xE0, 0xCC, 0x63, 0xB8, 0x70, 0xC1, 0xF8, 0x66, 0x19, 0x8E, 0x33, 0x0D,
  0xC3, 0xE0, 0x78, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x70, 0x1C, 0x00, 0xFF,
  0xFF, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x0C,
  0x71, 0x8C, 0x30, 0xC3, 0x0C, 0xF3, 0x83, 0x0C, 0x30, 0xC3, 0x06, 0x18,
  0x30, 0xFF, 0xFF, 0xC0, 0xC3, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x73,
  0x8C, 0x30, 0xC3, 0x0C, 0x63, 0x80, 0x10, 0x0F, 0x8D, 0xBF, 0xE3, 0xE0,
};

const GFXglyph RobotoMono_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 4, 11, 3, -14 },
  { 10, 11, 14, 11, 0, -14 },
  { 30, 9, 18, 11, 1, -16 },
  { 51, 11, 14, 11, 0, -14 },
  { 71, 10, 14, 11, 1, -14 },
  { 89, 2, 5, 11, 4, -14 },
  { 91, 5, 19, 11, 3, -15 },
  { 103, 5, 19, 11, 3, -15 },
  { 115, 10, 10, 11, 1, -14 },
  { 128, 9, 10, 11, 1, -11 },
  { 140, 3, 6, 11, 3, -2 },
  { 143, 8, 2, 11, 2, -7 },
  { 145, 3, 3, 11, 4, -3 },
  { 147, 8, 15, 11, 2, -14 },
  { 162, 9, 14, 11, 1, -14 },
  { 178, 5, 14, 11, 2, -14 },
  { 187, 9, 14, 11, 1, -14 },
  { 203, 9, 14, 11, 1, -14 },
  { 219, 9, 14, 11, 1, -14 },
  { 235, 9, 14, 11, 1, -14 },
  { 251, 9, 14, 11, 1, -14 },
  { 267, 9, 14, 11, 1, -14 },
  { 283, 9, 14, 11, 1, -14 },
  { 299, 9, 14, 11, 1, -14 },
  { 315, 4, 11, 11, 4, -11 },
  { 321, 4, 15, 11, 4, -11 },
  { 329, 9, 8, 11, 1, -10 },
  { 338, 8, 6, 11, 2, -9 },
  { 344, 8, 8, 11, 2, -10 },
  { 352, 8, 14, 11, 2, -14 },
  { 366, 11, 13, 11, 0, -13 },
  { 384, 11, 14, 11, 0, -14 },
  { 404, 10, 14, 11, 1, -14 },
  { 422, 10, 14, 11, 1, -14 },
  { 440, 10, 14, 11, 1, -14 },
  { 458, 9, 14, 11, 1, -14 },
  { 474, 8, 14, 11, 2, -14 },
  { 488, 9, 14, 11, 1, -14 },
  { 504, 9, 14, 11, 1, -14 },
  { 520, 8, 14, 11, 2, -14 },
  { 534, 9, 14, 11, 1, -14 },
  { 550, 10, 14, 11, 1, -14 },
  { 568, 8, 14, 11, 2, -14 },
  { 582, 9, 14, 11, 1, -14 },
  { 598, 9, 14, 11, 1, -14 },
  { 614, 10, 14, 11, 1, -14 },
  { 632, 9, 14, 11, 2, -14 },
  { 648, 10, 16, 11, 1, -14 },
  { 668, 10, 14, 11, 1, -14 },
  { 686, 10, 14, 11, 1, -14 },
  { 704, 11, 14, 11, 0, -14 },
  { 724, 9, 14, 11, 1, -14 },
  { 740, 11, 14, 11, 0, -14 },
  { 760, 11, 14, 11, 0, -14 },
  { 780, 11, 14, 11, 0, -14 },
  { 800, 11, 14, 11, 0, -14 },
  { 820, 9, 14, 11, 1, -14 },
  { 836, 4, 19, 11, 4, -16 },
  { 846, 8, 15, 11, 2, -14 },
  { 861, 4, 19, 11, 4, -16 },
  { 871, 8, 8, 11, 2, -14 },
  { 879, 9, 2, 11, 1, 0 },
  { 882, 4, 3, 11, 4, -14 },
  { 884, 9, 10, 11, 1, -10 },
  { 896, 9, 14, 11, 1, -14 },
  { 912, 9, 10, 11, 1, -10 },
  { 924, 9, 14, 11, 1, -14 },
  { 940, 9, 10, 11, 1, -10 },
  { 952, 10, 15, 11, 1, -15 },
  { 971, 9, 14, 11, 1, -10 },
  { 987, 9, 14, 11, 1, -14 },
  { 1003, 8, 14, 11, 2, -14 },
  { 1017, 6, 18, 11, 2, -14 },
  { 1031, 10, 14, 11, 1, -14 },
  { 1049, 8, 14, 11, 2, -14 },
  { 1063, 10, 10, 11, 1, -10 },
  { 1076, 9, 10, 11, 1, -10 },
  { 1088, 9, 10, 11, 1, -10 },
  { 1100, 9, 14, 11, 1, -10 },
  { 1116, 9, 14, 11, 1, -10 },
  { 1132, 7, 10, 11, 3, -10 },
  { 1141, 9, 10, 11, 1, -10 },
  { 1153, 9, 12, 11, 1, -12 },
  { 1167, 8, 10, 11, 2, -10 },
  { 1177, 10, 10, 11, 1, -10 },
  { 1190, 11, 10, 11, 0, -10 },
  { 1204, 10, 10, 11, 1, -10 },
  { 1217, 10, 14, 11, 1, -10 },
  { 1235, 9, 10, 11, 1, -10 },
  { 1247, 6, 18, 11, 3, -15 },
  { 1261, 1, 18, 11, 5, -14 },
  { 1264, 6, 18, 11, 3, -15 },
  { 1278, 11, 4, 11, 0, -8 },
};

const GFXfont RobotoMono_Medium19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium19pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_MEDIUM19PT7B_H_
