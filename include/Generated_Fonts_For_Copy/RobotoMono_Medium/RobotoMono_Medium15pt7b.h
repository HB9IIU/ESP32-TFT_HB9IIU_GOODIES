#ifndef _ROBOTOMONO_MEDIUM15PT7B_H_
#define _ROBOTOMONO_MEDIUM15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x90, 0x0B, 0x80, 0xDD, 0x90, 0x1B, 0x09, 0x04, 0x8F,
  0xF7, 0xF8, 0xB0, 0xD1, 0xFE, 0x24, 0x12, 0x0B, 0x00, 0x10, 0x71, 0xFA,
  0x3C, 0x6C, 0x0E, 0x07, 0x07, 0x8F, 0x9B, 0xE1, 0x02, 0x00, 0x60, 0x68,
  0x34, 0x9A, 0x87, 0x40, 0x40, 0x68, 0x2E, 0x35, 0x92, 0xC1, 0xC0, 0x38,
  0x7C, 0x4C, 0x4C, 0x78, 0x70, 0xF3, 0xDA, 0x8E, 0xCE, 0x7B, 0xFF, 0x23,
  0x4C, 0xC8, 0x88, 0x88, 0x8C, 0x46, 0x30, 0x84, 0x23, 0x31, 0x11, 0x11,
  0x33, 0x26, 0xC0, 0x18, 0x22, 0x4F, 0xF1, 0x85, 0x19, 0x92, 0x10, 0x20,
  0x47, 0xFF, 0xE2, 0x04, 0x08, 0xFF, 0x80, 0xFC, 0xFC, 0x0C, 0x61, 0x84,
  0x30, 0xC2, 0x18, 0x61, 0x0C, 0x20, 0x38, 0xFB, 0x1E, 0x3C, 0xFB, 0xF9,
  0xE3, 0xC6, 0xD9, 0xF0, 0x09, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x39,
  0xFB, 0x14, 0x30, 0xC1, 0x86, 0x18, 0x61, 0x83, 0xF8, 0x39, 0xFB, 0x18,
  0x30, 0xC7, 0x03, 0x03, 0x87, 0x99, 0xF0, 0x06, 0x0E, 0x0E, 0x1E, 0x36,
  0x26, 0x66, 0xFF, 0x7F, 0x06, 0x06, 0x7E, 0xFD, 0x02, 0x07, 0xDD, 0xC1,
  0x83, 0xC7, 0xDD, 0xF0, 0x18, 0x71, 0x86, 0x0F, 0xDD, 0xB1, 0xE3, 0xC6,
  0xD9, 0xF0, 0xFF, 0xFC, 0x10, 0x60, 0xC3, 0x06, 0x08, 0x30, 0x41, 0x80,
  0x38, 0xFB, 0x1E, 0x36, 0xC7, 0x1B, 0xE3, 0xC7, 0xDD, 0xF0, 0x38, 0xFB,
  0x16, 0x3C, 0x78, 0xDF, 0x93, 0x0C, 0x79, 0xC0, 0xF0, 0x0F, 0x6C, 0x00,
  0x1B, 0x6B, 0x00, 0x06, 0x3D, 0xC6, 0x07, 0x81, 0xC0, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0x70, 0x33, 0xDC, 0x20, 0x00, 0x38, 0xFF,
  0x18, 0x30, 0x41, 0x86, 0x08, 0x00, 0x20, 0xE0, 0x0C, 0x19, 0x18, 0x4B,
  0xA5, 0x4C, 0xA6, 0xD5, 0xAA, 0x5A, 0x30, 0x0F, 0x00, 0x08, 0x0E, 0x07,
  0x02, 0x83, 0x61, 0xB0, 0xC8, 0x7E, 0x7F, 0x30, 0xB0, 0x60, 0xF9, 0xFF,
  0x1E, 0x3C, 0x7F, 0xB1, 0xE1, 0xC3, 0x9F, 0xF0, 0x38, 0xFF, 0x1E, 0x18,
  0x10, 0x20, 0x60, 0xC7, 0xCD, 0xF0, 0xF1, 0xFB, 0x1E, 0x3C, 0x38, 0x70,
  0xE3, 0xC7, 0xBB, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1,
  0x83, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x00,
  0x38, 0xFF, 0x1E, 0x08, 0x10, 0x23, 0xE3, 0xC6, 0xCC, 0xF0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFC, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xC7, 0x99, 0xE0, 0xC3, 0xC6, 0xCC, 0xD8, 0xD8, 0xF0, 0xF8, 0xCC,
  0xCC, 0xC6, 0xC3, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0xF8, 0xC7, 0xCF, 0xBF, 0x5E, 0xBF, 0x74, 0xEB, 0xC7, 0x8F, 0x18, 0xC7,
  0x8F, 0x9F, 0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x8F, 0x18, 0x38, 0xFB, 0x1E,
  0x38, 0x30, 0x60, 0xE3, 0xC7, 0xD9, 0xF0, 0xF9, 0xFF, 0x1E, 0x1C, 0x3F,
  0xFF, 0x60, 0xC1, 0x83, 0x00, 0x38, 0x7C, 0xC6, 0xC6, 0x82, 0x82, 0x82,
  0xC2, 0xC6, 0xEE, 0x7C, 0x07, 0x02, 0xF8, 0xFE, 0xC6, 0xC6, 0xC6, 0xFE,
  0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0x38, 0xFF, 0x1E, 0x0E, 0x0F, 0x83, 0x83,
  0xC3, 0xCD, 0xF0, 0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xDD, 0xF0, 0xC1, 0xB1, 0x98, 0xCC, 0x62, 0x21, 0xB0, 0xD8, 0x28, 0x1C,
  0x0E, 0x06, 0x00, 0xC9, 0xE4, 0xD3, 0x4B, 0xA5, 0x53, 0xA9, 0xDC, 0xEE,
  0x77, 0x1B, 0x88, 0x80, 0xE1, 0xB1, 0x8C, 0x86, 0xC1, 0xC0, 0xE0, 0x70,
  0x6C, 0x36, 0x31, 0xB8, 0xE0, 0xC1, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0,
  0x70, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF, 0xFC, 0x30, 0x61, 0x82, 0x0C,
  0x30, 0x61, 0x83, 0xF8, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xC0, 0x83, 0x04,
  0x10, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x83, 0xED, 0xB6, 0xDB, 0x6D, 0xB7,
  0xC0, 0x21, 0xC5, 0x16, 0xDA, 0x30, 0xFE, 0xCC, 0x7D, 0x98, 0x19, 0xFC,
  0x78, 0xF3, 0xBF, 0xC1, 0x83, 0x07, 0xEE, 0xF8, 0xF1, 0xE3, 0xC7, 0xDF,
  0xF0, 0x3C, 0xDF, 0x1E, 0x0C, 0x18, 0xD9, 0xBE, 0x06, 0x0C, 0x1B, 0xFE,
  0xF8, 0xF1, 0xE3, 0xC7, 0xDD, 0xF8, 0x3C, 0xDF, 0x1F, 0xFF, 0xF8, 0x19,
  0x9E, 0x04, 0x3C, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80,
  0x7F, 0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xBF, 0x07, 0x99, 0xF0, 0xC1, 0x83,
  0x06, 0xEE, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x30, 0xC0, 0x3C, 0xF0,
  0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x33, 0x0F, 0xF3, 0x33, 0x33, 0x33, 0x3E,
  0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC, 0xCC, 0xC7, 0xF8,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8, 0xFF, 0xFE, 0x4C,
  0x99, 0x32, 0x64, 0xC9, 0xDD, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D,
  0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xBE, 0xFD, 0xDF, 0x1E, 0x3C, 0x78, 0xFB,
  0xFE, 0xC1, 0x83, 0x00, 0x7F, 0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xBF, 0x06,
  0x0C, 0x18, 0xDF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0x7D, 0xCF, 0x03, 0x81,
  0xE0, 0xF1, 0xBE, 0x30, 0x63, 0xF9, 0x83, 0x06, 0x0C, 0x18, 0x32, 0x3C,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBF, 0xC7, 0x8D, 0x13, 0x66, 0xC5,
  0x0E, 0x08, 0xC9, 0xA4, 0x97, 0x4A, 0xA7, 0x73, 0xB8, 0xD8, 0x44, 0xC6,
  0x6C, 0x2C, 0x38, 0x38, 0x2C, 0x64, 0xC7, 0xE1, 0xB1, 0x88, 0xC6, 0xC3,
  0x60, 0xE0, 0x70, 0x18, 0x18, 0x0C, 0x1C, 0x00, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0x7F, 0x08, 0xCC, 0x63, 0x18, 0x98, 0x21, 0x8C, 0x63, 0x0C,
  0x20, 0xFF, 0xFC, 0x47, 0x08, 0x42, 0x10, 0xC3, 0x31, 0x08, 0x42, 0x71,
  0x00, 0x71, 0xF9, 0x8F,
};

const GFXglyph RobotoMono_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 4, 3, 9, 2, -11 },
  { 8, 9, 11, 9, 0, -11 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 9, 11, 9, 0, -11 },
  { 47, 8, 11, 9, 1, -11 },
  { 58, 2, 4, 9, 3, -11 },
  { 59, 4, 15, 9, 3, -12 },
  { 67, 4, 15, 9, 2, -12 },
  { 75, 7, 8, 9, 1, -11 },
  { 82, 7, 8, 9, 1, -9 },
  { 89, 2, 5, 9, 3, -2 },
  { 91, 6, 1, 9, 2, -5 },
  { 92, 3, 2, 9, 3, -2 },
  { 93, 6, 12, 9, 2, -11 },
  { 102, 7, 11, 9, 1, -11 },
  { 112, 5, 11, 9, 1, -11 },
  { 119, 7, 11, 9, 1, -11 },
  { 129, 7, 11, 9, 1, -11 },
  { 139, 8, 11, 9, 0, -11 },
  { 150, 7, 11, 9, 1, -11 },
  { 160, 7, 11, 9, 1, -11 },
  { 170, 7, 11, 9, 1, -11 },
  { 180, 7, 11, 9, 1, -11 },
  { 190, 7, 11, 9, 1, -11 },
  { 200, 2, 8, 9, 4, -8 },
  { 202, 3, 11, 9, 3, -8 },
  { 207, 7, 7, 9, 1, -8 },
  { 214, 7, 5, 9, 1, -7 },
  { 219, 7, 7, 9, 1, -8 },
  { 226, 7, 11, 9, 1, -11 },
  { 236, 9, 11, 9, 0, -11 },
  { 249, 9, 11, 9, 0, -11 },
  { 262, 7, 11, 9, 1, -11 },
  { 272, 7, 11, 9, 1, -11 },
  { 282, 7, 11, 9, 1, -11 },
  { 292, 7, 11, 9, 1, -11 },
  { 302, 7, 11, 9, 1, -11 },
  { 312, 7, 11, 9, 1, -11 },
  { 322, 7, 11, 9, 1, -11 },
  { 332, 7, 11, 9, 1, -11 },
  { 342, 7, 11, 9, 1, -11 },
  { 352, 8, 11, 9, 1, -11 },
  { 363, 7, 11, 9, 1, -11 },
  { 373, 7, 11, 9, 1, -11 },
  { 383, 7, 11, 9, 1, -11 },
  { 393, 7, 11, 9, 1, -11 },
  { 403, 7, 11, 9, 1, -11 },
  { 413, 8, 13, 9, 1, -11 },
  { 426, 8, 11, 9, 1, -11 },
  { 437, 7, 11, 9, 1, -11 },
  { 447, 9, 11, 9, 0, -11 },
  { 460, 7, 11, 9, 1, -11 },
  { 470, 9, 11, 9, 0, -11 },
  { 483, 9, 11, 9, 0, -11 },
  { 496, 9, 11, 9, 0, -11 },
  { 509, 9, 11, 9, 0, -11 },
  { 522, 7, 11, 9, 1, -11 },
  { 532, 3, 14, 9, 3, -12 },
  { 538, 6, 12, 9, 2, -11 },
  { 547, 3, 14, 9, 3, -12 },
  { 553, 6, 6, 9, 2, -11 },
  { 558, 7, 1, 9, 1, 0 },
  { 559, 3, 2, 9, 3, -11 },
  { 560, 7, 8, 9, 1, -8 },
  { 567, 7, 11, 9, 1, -11 },
  { 577, 7, 8, 9, 1, -8 },
  { 584, 7, 11, 9, 1, -11 },
  { 594, 7, 8, 9, 1, -8 },
  { 601, 7, 12, 9, 1, -12 },
  { 612, 7, 11, 9, 1, -8 },
  { 622, 7, 11, 9, 1, -11 },
  { 632, 6, 11, 9, 2, -11 },
  { 641, 4, 14, 9, 2, -11 },
  { 648, 8, 11, 9, 1, -11 },
  { 659, 7, 11, 9, 1, -11 },
  { 669, 7, 8, 9, 1, -8 },
  { 676, 7, 8, 9, 1, -8 },
  { 683, 7, 8, 9, 1, -8 },
  { 690, 7, 11, 9, 1, -8 },
  { 700, 7, 11, 9, 1, -8 },
  { 710, 6, 8, 9, 2, -8 },
  { 716, 7, 8, 9, 1, -8 },
  { 723, 7, 10, 9, 1, -10 },
  { 732, 7, 8, 9, 1, -8 },
  { 739, 7, 8, 9, 1, -8 },
  { 746, 9, 8, 9, 0, -8 },
  { 755, 8, 8, 9, 1, -8 },
  { 763, 9, 11, 9, 0, -8 },
  { 776, 7, 8, 9, 1, -8 },
  { 783, 5, 15, 9, 2, -12 },
  { 793, 1, 14, 9, 4, -11 },
  { 795, 5, 15, 9, 2, -12 },
  { 805, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_Medium15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium15pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_MEDIUM15PT7B_H_
