#ifndef _ROBOTOMONO_MEDIUM47PT7B_H_
#define _ROBOTOMONO_MEDIUM47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xFE, 0x0F,
  0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xF0, 0xF0, 0x20, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE1, 0xC0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x38, 0x0F,
  0x0F, 0x1E, 0x01, 0xFF, 0xC7, 0x00, 0x7F, 0xE3, 0xC0, 0x0F, 0xF1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x7E, 0x00,
  0x1E, 0x7F, 0xC0, 0x07, 0x1F, 0xF8, 0x03, 0xCF, 0x9F, 0x01, 0xE3, 0xC3,
  0xC0, 0x78, 0xE0, 0xF0, 0x3C, 0x78, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0x87,
  0x83, 0xC0, 0x20, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xF8, 0xFF, 0xF8, 0x3E, 0x3F,
  0x7F, 0x0F, 0x9F, 0x8F, 0xC3, 0xE7, 0xC1, 0xF8, 0xFB, 0xF0, 0x3F, 0x7C,
  0xFC, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0xCF, 0xC0, 0x3F, 0xE3, 0xF0, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0x81, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x30, 0x01, 0x60, 0x03, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x38, 0x01, 0x80, 0x08, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x06, 0x07, 0x80, 0xBE, 0x1E, 0x1F, 0xFE, 0x79, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0xFC, 0x1E, 0x03, 0xE0, 0x18, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF8, 0x70, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7E, 0xFF, 0xF3,
  0xF3, 0xFF, 0xDF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0C,
  0x01, 0xF0, 0x3F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xE0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0,
  0x7F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9,
  0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0x7C, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x07,
  0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x78, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3E, 0x03, 0xF8, 0x10, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x7F, 0x03, 0xF7, 0xFF, 0x0F, 0xBF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xCF, 0xF3, 0xF8, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x3E,
  0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xFC, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7E, 0x01,
  0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xFE,
  0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFD,
  0xF8, 0x0F, 0xE7, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFB, 0xE0, 0x3F, 0x8F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x1F, 0x1F, 0xCF, 0xEF, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x78, 0x7C, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x70,
  0x70, 0x3F, 0x0E, 0x3C, 0x3F, 0xE3, 0x8E, 0x1F, 0xF8, 0xE7, 0x87, 0x8E,
  0x3D, 0xC3, 0xC3, 0x87, 0x70, 0xE0, 0xE1, 0xDC, 0x78, 0x38, 0x7F, 0x1E,
  0x0E, 0x1F, 0xC7, 0x03, 0x87, 0xF1, 0xC1, 0xE1, 0xFC, 0x70, 0x78, 0xEF,
  0x1C, 0x1C, 0x3B, 0xC7, 0x07, 0x0E, 0xF1, 0xC1, 0xC3, 0xBC, 0x78, 0xF1,
  0xC7, 0x1F, 0xFE, 0xF1, 0xC3, 0xFB, 0xF8, 0x78, 0xFE, 0xFC, 0x1E, 0x0E,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x38, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xF0, 0x07, 0xF7,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC1, 0xFF,
  0x1F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC7, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x80,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x1F, 0xC0,
  0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x03,
  0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF,
  0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF0, 0x0F, 0xF1, 0xF8, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xDF, 0xFF, 0xC7, 0xBF, 0xF7, 0x9F, 0x7F, 0xEF, 0x3C,
  0xFF, 0xDE, 0x79, 0xFF, 0x9E, 0xF3, 0xFF, 0x3F, 0xC7, 0xFE, 0x7F, 0x9F,
  0xFC, 0xFF, 0x3F, 0xF8, 0xFE, 0x7F, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF,
  0xC3, 0xE3, 0xFF, 0x87, 0x87, 0xFF, 0x0F, 0x0F, 0xFE, 0x0E, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFD, 0xF0, 0xFF, 0xF7, 0xC3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3E, 0x3F,
  0xFC, 0x7C, 0xFF, 0xF1, 0xF3, 0xFF, 0xC3, 0xEF, 0xFF, 0x0F, 0xBF, 0xFC,
  0x1E, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x7F, 0x9F, 0x00, 0x3F, 0xBE, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x7F,
  0x7C, 0x07, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7F, 0x3E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x3F,
  0x87, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7D, 0xF0,
  0xFC, 0x1F, 0x7C, 0x3F, 0x07, 0xDF, 0x0F, 0xC1, 0xF7, 0xC3, 0xF0, 0x7D,
  0xF0, 0xFE, 0x3E, 0x7C, 0x3F, 0x8F, 0x9F, 0x0F, 0xE3, 0xE7, 0xC7, 0xF8,
  0xF8, 0xF9, 0xFE, 0x3E, 0x3E, 0x7F, 0x8F, 0x8F, 0x9E, 0xF3, 0xE3, 0xE7,
  0xBC, 0xF0, 0xF9, 0xCF, 0x3C, 0x3E, 0xF3, 0xDF, 0x0F, 0xBC, 0xF7, 0xC1,
  0xEF, 0x3D, 0xF0, 0x7B, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x00, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D,
  0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF8, 0x78, 0x1F, 0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x07, 0xE7,
  0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0x83, 0xE7, 0xE0, 0x0F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0xFE, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xBF, 0x0F, 0xF8, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F, 0x81, 0xF7, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFE, 0x3F, 0xDF, 0xC0, 0x7E, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFB, 0xFC,
  0x1F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xDF, 0xFC, 0x3E, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0x87, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x3F, 0x83, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x8F, 0xC3, 0xFF, 0xBF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xF8, 0x7F, 0xDF, 0xC0, 0x7F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xF8, 0x7F, 0xCF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFB, 0xF0, 0x3F, 0xCF, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFC, 0x7F,
  0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x43, 0xF8, 0x01, 0xC3, 0xFC, 0x0F, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xF0,
  0x60, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x7C, 0x3F, 0xF9, 0xF1,
  0xFF, 0xF7, 0xCF, 0xFF, 0xFF, 0x3F, 0xC7, 0xFD, 0xFC, 0x07, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0,
  0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF,
  0x03, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC4, 0x00, 0x3E, 0x18,
  0x01, 0xF8, 0xF0, 0x0F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0xC1,
  0xF3, 0xFF, 0x8F, 0xBF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF,
  0x87, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xE7, 0xC0,
  0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x1F,
  0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xFC, 0x03, 0xE7, 0xF0, 0x07, 0xDF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F,
  0x81, 0xFC, 0x1F, 0x01, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0xF8,
  0x03, 0xF9, 0xF0, 0x03, 0xFB, 0xE0, 0x03, 0xF8, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xF8, 0xFC, 0xFB, 0xFD, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x3F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x7F, 0x07, 0xCF, 0xFE,
  0x3E, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0x7F, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xF8, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7D, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC3, 0xF8,
  0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0xF8, 0xFE, 0x07, 0xDF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xF0, 0xFF, 0x7E, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0x7F, 0xF0, 0xF9, 0xFF, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x7C,
  0x3F, 0xFB, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x87, 0xFD, 0xFC,
  0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xBF, 0x03, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x3F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF,
  0x00, 0x3F, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xF7, 0xE0,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFB, 0xE3, 0xFF, 0x9F, 0x0F, 0xF0, 0xF8,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0,
  0x7F, 0xE0, 0x7C, 0x1F, 0x78, 0x3F, 0x07, 0x9F, 0x0F, 0xC3, 0xE7, 0xC3,
  0xF0, 0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x7F, 0x8F, 0x8F, 0x1F, 0xE3, 0xC3,
  0xC7, 0xF8, 0xF0, 0xF9, 0xCE, 0x3C, 0x3E, 0x73, 0x9F, 0x0F, 0xBC, 0xF7,
  0xC1, 0xEF, 0x3D, 0xE0, 0x7B, 0x87, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8,
  0x77, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0x80, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x83, 0xFF, 0x80, 0x3D, 0xFF, 0xF0, 0x1E,
  0x7F, 0xFE, 0x07, 0xBE, 0x1F, 0xFF, 0xEF, 0x01, 0xFF, 0xF3, 0xC0, 0x3F,
  0xFC, 0x70, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoMono_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 33, 28, 11, -33 },
  { 26, 13, 11, 28, 7, -35 },
  { 44, 26, 33, 28, 1, -33 },
  { 152, 23, 44, 28, 3, -39 },
  { 279, 26, 34, 28, 1, -34 },
  { 390, 26, 34, 28, 2, -34 },
  { 501, 4, 12, 28, 11, -35 },
  { 507, 12, 48, 28, 8, -37 },
  { 579, 13, 48, 28, 7, -37 },
  { 657, 22, 23, 28, 4, -33 },
  { 721, 23, 25, 28, 2, -28 },
  { 793, 8, 14, 28, 8, -5 },
  { 807, 18, 5, 28, 6, -17 },
  { 819, 8, 7, 28, 10, -7 },
  { 826, 19, 36, 28, 5, -33 },
  { 912, 22, 34, 28, 3, -34 },
  { 1006, 14, 33, 28, 4, -33 },
  { 1064, 23, 34, 28, 2, -34 },
  { 1162, 22, 34, 28, 2, -34 },
  { 1256, 24, 33, 28, 2, -33 },
  { 1355, 22, 33, 28, 3, -33 },
  { 1446, 22, 34, 28, 3, -34 },
  { 1540, 23, 33, 28, 2, -33 },
  { 1635, 22, 34, 28, 3, -34 },
  { 1729, 22, 34, 28, 3, -34 },
  { 1823, 8, 26, 28, 11, -26 },
  { 1849, 9, 35, 28, 10, -26 },
  { 1889, 20, 21, 28, 4, -25 },
  { 1942, 21, 15, 28, 4, -22 },
  { 1982, 20, 21, 28, 4, -25 },
  { 2035, 21, 34, 28, 4, -34 },
  { 2125, 26, 33, 28, 1, -33 },
  { 2233, 27, 33, 28, 1, -33 },
  { 2345, 23, 33, 28, 3, -33 },
  { 2440, 24, 34, 28, 2, -34 },
  { 2542, 23, 33, 28, 3, -33 },
  { 2637, 21, 33, 28, 4, -33 },
  { 2724, 22, 33, 28, 4, -33 },
  { 2815, 24, 34, 28, 2, -34 },
  { 2917, 22, 33, 28, 3, -33 },
  { 3008, 20, 33, 28, 4, -33 },
  { 3091, 23, 33, 28, 2, -33 },
  { 3186, 25, 33, 28, 3, -33 },
  { 3290, 21, 33, 28, 4, -33 },
  { 3377, 23, 33, 28, 3, -33 },
  { 3472, 22, 33, 28, 3, -33 },
  { 3563, 24, 34, 28, 2, -34 },
  { 3665, 23, 33, 28, 4, -33 },
  { 3760, 25, 40, 28, 2, -34 },
  { 3885, 24, 33, 28, 3, -33 },
  { 3984, 24, 34, 28, 2, -34 },
  { 4086, 26, 33, 28, 1, -33 },
  { 4194, 22, 33, 28, 3, -33 },
  { 4285, 26, 33, 28, 1, -33 },
  { 4393, 26, 33, 28, 1, -33 },
  { 4501, 27, 33, 28, 1, -33 },
  { 4613, 26, 33, 28, 1, -33 },
  { 4721, 24, 33, 28, 2, -33 },
  { 4820, 10, 46, 28, 9, -39 },
  { 4878, 19, 36, 28, 5, -33 },
  { 4964, 10, 46, 28, 9, -39 },
  { 5022, 19, 17, 28, 5, -33 },
  { 5063, 21, 4, 28, 3, 0 },
  { 5074, 11, 6, 28, 9, -34 },
  { 5083, 22, 25, 28, 3, -25 },
  { 5152, 21, 35, 28, 4, -35 },
  { 5244, 22, 25, 28, 3, -25 },
  { 5313, 22, 35, 28, 3, -35 },
  { 5410, 23, 25, 28, 3, -25 },
  { 5482, 23, 36, 28, 3, -36 },
  { 5586, 22, 35, 28, 3, -25 },
  { 5683, 21, 35, 28, 4, -35 },
  { 5775, 20, 34, 28, 5, -34 },
  { 5860, 15, 44, 28, 5, -34 },
  { 5943, 23, 35, 28, 4, -35 },
  { 6044, 21, 35, 28, 5, -35 },
  { 6136, 24, 25, 28, 2, -25 },
  { 6211, 21, 25, 28, 4, -25 },
  { 6277, 23, 25, 28, 3, -25 },
  { 6349, 21, 35, 28, 4, -25 },
  { 6441, 22, 35, 28, 3, -25 },
  { 6538, 18, 25, 28, 7, -25 },
  { 6595, 22, 25, 28, 3, -25 },
  { 6664, 22, 31, 28, 3, -31 },
  { 6750, 21, 25, 28, 4, -25 },
  { 6816, 24, 25, 28, 2, -25 },
  { 6891, 26, 25, 28, 1, -25 },
  { 6973, 25, 25, 28, 2, -25 },
  { 7052, 27, 35, 28, 1, -25 },
  { 7171, 23, 25, 28, 3, -25 },
  { 7243, 16, 45, 28, 7, -37 },
  { 7333, 4, 42, 28, 12, -33 },
  { 7354, 15, 45, 28, 8, -37 },
  { 7439, 26, 10, 28, 1, -19 },
};

const GFXfont RobotoMono_Medium47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium47pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_MEDIUM47PT7B_H_
