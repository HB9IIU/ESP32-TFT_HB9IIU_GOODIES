#ifndef _ROBOTOMONO_MEDIUM11PT7B_H_
#define _ROBOTOMONO_MEDIUM11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x43, 0xB4, 0x24, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x23, 0xB7,
  0x1E, 0x18, 0x31, 0x71, 0x00, 0x62, 0xAA, 0x94, 0x10, 0xB5, 0x43, 0x30,
  0xD1, 0x21, 0x87, 0x5B, 0x93, 0x3F, 0xE0, 0x29, 0x49, 0x24, 0x89, 0x80,
  0x91, 0x26, 0xDB, 0x4A, 0x00, 0x21, 0x3E, 0x4D, 0xA8, 0x21, 0x3E, 0x42,
  0x00, 0xF8, 0xF8, 0x70, 0x18, 0x8C, 0x42, 0x31, 0x08, 0x80, 0x74, 0xE3,
  0x7C, 0xC6, 0x6E, 0x3E, 0x92, 0x49, 0x39, 0x2C, 0xC2, 0x10, 0xC6, 0x1F,
  0x74, 0x86, 0x67, 0x0E, 0x7E, 0x08, 0x62, 0x8A, 0x4B, 0xF0, 0x82, 0xFC,
  0x21, 0xE1, 0x86, 0x6E, 0x36, 0x21, 0xE9, 0xC6, 0x6E, 0xFC, 0x30, 0x86,
  0x10, 0x42, 0x18, 0x74, 0xE7, 0xEF, 0x46, 0x7E, 0x74, 0xA7, 0x3F, 0x8C,
  0x4C, 0xC6, 0x4C, 0x00, 0x12, 0xC0, 0x0B, 0xA0, 0xE1, 0x80, 0xF8, 0x3E,
  0x87, 0x06, 0xE8, 0x00, 0x74, 0xC6, 0x22, 0x10, 0x04, 0x39, 0x17, 0xEB,
  0xAE, 0xF4, 0x1E, 0x10, 0xC2, 0x8A, 0x69, 0xF4, 0x71, 0xF4, 0xE3, 0xF9,
  0xC6, 0x3E, 0x39, 0x34, 0x70, 0xC1, 0x04, 0xCE, 0xE4, 0xA3, 0x18, 0xC6,
  0x7E, 0xFC, 0x21, 0xEF, 0x42, 0x1F, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x39,
  0x34, 0x10, 0xDD, 0x14, 0x4F, 0x8C, 0x63, 0xFF, 0xC6, 0x31, 0xF9, 0x08,
  0x42, 0x10, 0x9F, 0x18, 0xC6, 0x31, 0x8E, 0x7E, 0x8A, 0x4B, 0x38, 0xE2,
  0xC9, 0xA3, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x9E, 0xF7, 0xDA, 0xD6, 0x31,
  0x8E, 0x73, 0xDA, 0xDE, 0x73, 0x39, 0x34, 0x71, 0xC5, 0x14, 0xCE, 0xF4,
  0xE3, 0x1F, 0x42, 0x10, 0x39, 0x34, 0x71, 0xC5, 0x14, 0xCE, 0x04, 0xF4,
  0xE3, 0x3F, 0x4A, 0x71, 0x74, 0xE1, 0xC3, 0x86, 0x2E, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x8C, 0x63, 0x18, 0xC6, 0x6E, 0xC5, 0x14, 0xDA, 0x28,
  0xE3, 0x04, 0x97, 0x57, 0x5D, 0x6D, 0xB6, 0xDA, 0xC5, 0xB2, 0x8C, 0x30,
  0xA6, 0xF1, 0xC5, 0x36, 0x8E, 0x30, 0x41, 0x04, 0xF8, 0xC4, 0x46, 0x22,
  0x1F, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0xC2, 0x10, 0x42, 0x18,
  0xD5, 0x55, 0x5C, 0x23, 0x15, 0xB0, 0xF8, 0xC4, 0x74, 0xCF, 0xB9, 0xFC,
  0x84, 0x3D, 0x38, 0xC6, 0x7E, 0x74, 0xE1, 0x09, 0xB8, 0x18, 0xDF, 0x39,
  0xCE, 0x7D, 0x74, 0xE3, 0xE8, 0xB8, 0x3B, 0x3E, 0xC6, 0x31, 0x8C, 0x6C,
  0xE7, 0x39, 0xBC, 0x7E, 0x84, 0x3D, 0x38, 0xC6, 0x31, 0x20, 0x38, 0x42,
  0x10, 0x9F, 0x30, 0x73, 0x33, 0x33, 0x3E, 0x84, 0x27, 0x6E, 0x72, 0x53,
  0xE1, 0x08, 0x42, 0x10, 0x9F, 0xFF, 0x5D, 0x75, 0xD7, 0x50, 0xF4, 0xE3,
  0x18, 0xC4, 0x74, 0xE3, 0x19, 0xB8, 0xF4, 0xE3, 0x19, 0xFA, 0x10, 0x6C,
  0xE7, 0x39, 0xFC, 0x63, 0xBD, 0x88, 0x88, 0x74, 0xF0, 0x78, 0xF8, 0x47,
  0xD0, 0x84, 0x20, 0xE0, 0x8C, 0x63, 0x19, 0xF4, 0xC5, 0x36, 0x8A, 0x30,
  0x40, 0x97, 0x57, 0x5D, 0x6D, 0xA0, 0x8A, 0x9C, 0xC5, 0x4C, 0xC5, 0x36,
  0x8A, 0x38, 0x43, 0x18, 0xF8, 0x8C, 0xCC, 0x7C, 0x2D, 0x25, 0x12, 0x48,
  0x80, 0xFF, 0xC0, 0x99, 0x24, 0x52, 0x4A, 0x00, 0xF6, 0x70,
};

const GFXglyph RobotoMono_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 2, 7, 2, -8 },
  { 4, 6, 8, 7, 0, -8 },
  { 10, 5, 10, 7, 1, -9 },
  { 17, 6, 8, 7, 0, -8 },
  { 23, 7, 8, 7, 0, -8 },
  { 30, 1, 3, 7, 3, -8 },
  { 31, 3, 11, 7, 2, -9 },
  { 36, 3, 11, 7, 2, -9 },
  { 41, 5, 6, 7, 1, -8 },
  { 45, 5, 5, 7, 1, -6 },
  { 49, 2, 3, 7, 2, -1 },
  { 50, 5, 1, 7, 1, -4 },
  { 51, 2, 2, 7, 2, -2 },
  { 52, 5, 9, 7, 1, -8 },
  { 58, 5, 8, 7, 1, -8 },
  { 63, 3, 8, 7, 1, -8 },
  { 66, 6, 8, 7, 0, -8 },
  { 72, 5, 8, 7, 1, -8 },
  { 77, 6, 8, 7, 0, -8 },
  { 83, 5, 8, 7, 1, -8 },
  { 88, 5, 8, 7, 1, -8 },
  { 93, 6, 8, 7, 0, -8 },
  { 99, 5, 8, 7, 1, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 1, 7, 7, 3, -7 },
  { 110, 3, 9, 7, 2, -7 },
  { 114, 5, 5, 7, 1, -6 },
  { 118, 5, 3, 7, 1, -5 },
  { 120, 5, 5, 7, 1, -6 },
  { 124, 5, 8, 7, 1, -8 },
  { 129, 6, 8, 7, 0, -8 },
  { 135, 6, 8, 7, 0, -8 },
  { 141, 5, 8, 7, 1, -8 },
  { 146, 6, 8, 7, 0, -8 },
  { 152, 5, 8, 7, 1, -8 },
  { 157, 5, 8, 7, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 6, 8, 7, 0, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 5, 8, 7, 1, -8 },
  { 183, 5, 8, 7, 1, -8 },
  { 188, 6, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 6, 8, 7, 0, -8 },
  { 215, 5, 8, 7, 1, -8 },
  { 220, 6, 9, 7, 0, -8 },
  { 227, 5, 8, 7, 1, -8 },
  { 232, 5, 8, 7, 1, -8 },
  { 237, 6, 8, 7, 0, -8 },
  { 243, 5, 8, 7, 1, -8 },
  { 248, 6, 8, 7, 0, -8 },
  { 254, 6, 8, 7, 0, -8 },
  { 260, 6, 8, 7, 0, -8 },
  { 266, 6, 8, 7, 0, -8 },
  { 272, 5, 8, 7, 1, -8 },
  { 277, 3, 11, 7, 2, -9 },
  { 282, 5, 9, 7, 1, -8 },
  { 288, 2, 11, 7, 2, -9 },
  { 291, 5, 4, 7, 1, -8 },
  { 294, 5, 1, 7, 1, 0 },
  { 295, 3, 2, 7, 2, -8 },
  { 296, 5, 6, 7, 1, -6 },
  { 300, 5, 8, 7, 1, -8 },
  { 305, 5, 6, 7, 1, -6 },
  { 309, 5, 8, 7, 1, -8 },
  { 314, 5, 6, 7, 1, -6 },
  { 318, 5, 8, 7, 1, -8 },
  { 323, 5, 8, 7, 1, -6 },
  { 328, 5, 8, 7, 1, -8 },
  { 333, 5, 8, 7, 1, -8 },
  { 338, 4, 10, 7, 1, -8 },
  { 343, 5, 8, 7, 1, -8 },
  { 348, 5, 8, 7, 1, -8 },
  { 353, 6, 6, 7, 0, -6 },
  { 358, 5, 6, 7, 1, -6 },
  { 362, 5, 6, 7, 1, -6 },
  { 366, 5, 8, 7, 1, -6 },
  { 371, 5, 8, 7, 1, -6 },
  { 376, 4, 6, 7, 2, -6 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 5, 7, 7, 1, -7 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 6, 6, 7, 0, -6 },
  { 397, 6, 6, 7, 0, -6 },
  { 402, 5, 6, 7, 1, -6 },
  { 406, 6, 8, 7, 0, -6 },
  { 412, 5, 6, 7, 1, -6 },
  { 416, 3, 11, 7, 2, -9 },
  { 421, 1, 10, 7, 3, -8 },
  { 423, 3, 11, 7, 2, -9 },
  { 428, 6, 2, 7, 0, -4 },
};

const GFXfont RobotoMono_Medium11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Medium11pt7bBitmaps,
  (GFXglyph *)RobotoMono_Medium11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_MEDIUM11PT7B_H_
