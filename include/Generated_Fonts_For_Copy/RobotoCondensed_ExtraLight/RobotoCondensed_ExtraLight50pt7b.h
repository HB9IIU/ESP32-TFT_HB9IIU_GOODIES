#ifndef _ROBOTOCONDENSED_EXTRALIGHT50PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC7, 0x8F,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x08, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x40, 0x01, 0x80, 0x80, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x81,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80,
  0xC0, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x18, 0x08,
  0x00, 0x30, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x10, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x70, 0x3C, 0x38, 0x03, 0x0C,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x03,
  0x70, 0x01, 0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x3F, 0xF8, 0x03, 0xF8, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x30, 0x20, 0x08, 0x04, 0x04, 0x01,
  0x01, 0x80, 0x80, 0x20, 0x60, 0x10, 0x04, 0x0C, 0x02, 0x00, 0x83, 0x00,
  0x60, 0x30, 0x60, 0x0C, 0x06, 0x18, 0x00, 0x80, 0x82, 0x00, 0x18, 0x30,
  0xC0, 0x01, 0xFC, 0x10, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x0F, 0x00, 0x01, 0x87, 0xF0, 0x00, 0x60,
  0xC3, 0x00, 0x0C, 0x30, 0x30, 0x03, 0x04, 0x02, 0x00, 0x61, 0x80, 0x40,
  0x18, 0x30, 0x0C, 0x03, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x10, 0x18,
  0x06, 0x06, 0x03, 0x00, 0xC0, 0x80, 0x60, 0x10, 0x30, 0x04, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x08, 0x03, 0x00,
  0x10, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x00,
  0xC3, 0x80, 0x01, 0x8E, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x37, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x06,
  0x01, 0x86, 0x06, 0x03, 0x18, 0x0E, 0x06, 0x60, 0x0C, 0x0C, 0xC0, 0x0C,
  0x19, 0x80, 0x0C, 0x33, 0x00, 0x1C, 0xC6, 0x00, 0x19, 0x8C, 0x00, 0x1B,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x60, 0x01, 0xB0,
  0x70, 0x0E, 0x70, 0x78, 0x78, 0x60, 0x7F, 0xC0, 0x60, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x20, 0x18, 0x0F, 0x03, 0x07, 0x7C, 0x67, 0xC1, 0xFF, 0xC0, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x30,
  0x60, 0x0E, 0x06, 0x01, 0x80, 0xE0, 0x60, 0x0C, 0x0C, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x33, 0x33, 0x33, 0x36,
  0x6C, 0x40, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xC0, 0xE0, 0x60, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03,
  0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x07, 0x07,
  0x03, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x40, 0x70, 0xFC, 0xF1, 0xF0,
  0x70, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70, 0x38, 0x18, 0x03,
  0x86, 0x00, 0x30, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0,
  0xC0, 0x0C, 0x70, 0x01, 0x98, 0x00, 0x64, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x03, 0x87, 0x01, 0xC0, 0xFF, 0xE0,
  0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x30, 0x18, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0xFC, 0x06, 0xFF, 0xC1, 0xE0,
  0x38, 0x70, 0x07, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x98, 0x00, 0x66, 0x00, 0x19, 0xC0,
  0x0C, 0x30, 0x03, 0x07, 0x03, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x1F, 0x80, 0x8F, 0xFC, 0x33, 0x81, 0xC6, 0xC0, 0x18,
  0xF0, 0x01, 0x9C, 0x00, 0x33, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x00, 0xB0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0x20, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x61,
  0x80, 0x0C, 0x18, 0x03, 0x01, 0xC0, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70,
  0x38, 0x18, 0x01, 0x87, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x18, 0xC0, 0x03, 0x0C, 0x00, 0xC0, 0xE0, 0x70, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x70, 0x38, 0x18, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x02, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x33, 0x00, 0x0E, 0x70, 0x03,
  0x87, 0x80, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x76, 0x00, 0x1D, 0x80, 0x0F, 0x30, 0x06, 0xC7, 0x03, 0x30, 0xFF, 0x8C,
  0x1F, 0x83, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0xEF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xE6, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x33, 0x36, 0x6C, 0xC0, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0xE0, 0x71, 0x80, 0x66, 0x00,
  0x6C, 0x00, 0xD0, 0x01, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x0F, 0x80, 0x10, 0xC0, 0x0F,
  0xF0, 0x06, 0x30, 0x07, 0x06, 0x01, 0x88, 0x03, 0x00, 0xC0, 0x26, 0x00,
  0xC0, 0x20, 0x09, 0x80, 0x60, 0x08, 0x03, 0x60, 0x18, 0x02, 0x00, 0xD0,
  0x0C, 0x00, 0x80, 0x3C, 0x03, 0x00, 0x20, 0x0F, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x20, 0x06, 0x00, 0xF0, 0x08, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x60,
  0x0F, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x60, 0x06, 0x00, 0xF0, 0x18, 0x01,
  0x80, 0x2C, 0x06, 0x00, 0x60, 0x0B, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x60,
  0x0E, 0x01, 0xB0, 0x18, 0x03, 0x80, 0x4C, 0x02, 0x00, 0xE0, 0x31, 0x00,
  0xC0, 0x58, 0x0C, 0x60, 0x30, 0x32, 0x06, 0x18, 0x07, 0x38, 0xE3, 0x06,
  0x00, 0xFC, 0x1F, 0x80, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x00, 0x40, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x70,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x00,
  0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xF0, 0x0E, 0x03, 0x00,
  0x1C, 0x18, 0x00, 0x38, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x23, 0x00, 0x01, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x1C, 0x03, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x01,
  0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x38, 0x3F, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0x1E, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xCE, 0x00, 0x07,
  0x1C, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x30,
  0x07, 0x07, 0x03, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xC0, 0x00, 0x3B, 0x00,
  0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x0E,
  0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x3E, 0x00, 0x0C, 0xCC, 0x00,
  0x36, 0x38, 0x00, 0xF0, 0x60, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x07, 0xEC, 0x00,
  0x00, 0x6F, 0x60, 0x00, 0x03, 0x79, 0x80, 0x00, 0x1B, 0xCC, 0x00, 0x01,
  0x9E, 0x60, 0x00, 0x0C, 0xF1, 0x80, 0x00, 0x67, 0x8C, 0x00, 0x06, 0x3C,
  0x20, 0x00, 0x31, 0xE1, 0x80, 0x01, 0x0F, 0x0C, 0x00, 0x18, 0x78, 0x20,
  0x00, 0xC3, 0xC1, 0x80, 0x0C, 0x1E, 0x0C, 0x00, 0x60, 0xF0, 0x30, 0x03,
  0x07, 0x81, 0x80, 0x30, 0x3C, 0x0C, 0x01, 0x81, 0xE0, 0x30, 0x0C, 0x0F,
  0x01, 0x80, 0xC0, 0x78, 0x0C, 0x06, 0x03, 0xC0, 0x30, 0x30, 0x1E, 0x01,
  0x83, 0x00, 0xF0, 0x04, 0x18, 0x07, 0x80, 0x30, 0x80, 0x3C, 0x01, 0x8C,
  0x01, 0xE0, 0x04, 0x60, 0x0F, 0x00, 0x32, 0x00, 0x78, 0x01, 0xB0, 0x03,
  0xC0, 0x05, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x06, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x71, 0x80,
  0x01, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x60, 0x01,
  0xC1, 0x80, 0x07, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x18, 0x01, 0xC0,
  0x30, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x0C,
  0x07, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x07,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00,
  0x01, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x0C,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0,
  0x03, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x30, 0x00, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0,
  0xC0, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0x67, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x26,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xB0,
  0x00, 0x19, 0x80, 0x00, 0xCE, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0xF0, 0x1E,
  0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x36,
  0x00, 0x0B, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00, 0x6C, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x06, 0x30, 0x01, 0x18, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0xC3, 0x00,
  0x20, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0xC0,
  0xC0, 0x30, 0x20, 0x18, 0x18, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x06, 0x06, 0x01, 0x03, 0x00, 0xC0, 0x80,
  0x30, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC1, 0x00, 0x30,
  0xC0, 0x08, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x08, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x4C, 0x00, 0x32, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0B, 0x00,
  0x02, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0C, 0xC0,
  0x00, 0x39, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0E, 0x03,
  0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x0C, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0x36, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xFE,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0, 0x06, 0x80, 0x33, 0x00, 0xCC,
  0x03, 0x10, 0x18, 0x60, 0x61, 0x81, 0x82, 0x0C, 0x0C, 0x30, 0x30, 0xC0,
  0x46, 0x01, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xE0, 0xC0, 0xC1, 0xC1, 0x81, 0x80, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xC0, 0x70, 0xE0, 0x0E, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x09,
  0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0x00, 0x23, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00,
  0x2C, 0x00, 0x0B, 0x00, 0x06, 0x40, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x6C,
  0xE0, 0x73, 0x1F, 0xF8, 0xC3, 0xF8, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x3F, 0x06, 0x7F,
  0xE3, 0x60, 0x39, 0xE0, 0x0E, 0xE0, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xBC, 0x01, 0xDB, 0x01, 0xCC,
  0xFF, 0xC6, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xC0, 0x70, 0xE0,
  0x0E, 0x30, 0x01, 0x98, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xCC, 0x00, 0x63, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x7E, 0x08, 0xFF, 0xC4, 0xE0, 0x32, 0x60,
  0x0D, 0x60, 0x03, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x60,
  0x01, 0xB0, 0x00, 0xCC, 0x00, 0xA7, 0x01, 0xD1, 0xFF, 0x88, 0x3F, 0x80,
  0x01, 0xF8, 0x01, 0xFF, 0x81, 0xC0, 0x70, 0x60, 0x0E, 0x30, 0x01, 0x98,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x0C, 0x78, 0x0E, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFE, 0xFF, 0xE0, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xE0,
  0x8F, 0xFC, 0x4E, 0x03, 0x26, 0x00, 0xD6, 0x00, 0x3B, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x0A, 0x70,
  0x1D, 0x1F, 0xF8, 0x83, 0xF8, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x40, 0x03, 0x70, 0x03, 0x1C, 0x03, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC1, 0xF0, 0xC7, 0xFC, 0xCC, 0x0E, 0xD8, 0x06, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xDF, 0x00, 0x00, 0x1B, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x03, 0x01, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x9F, 0x8F, 0x80,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x66, 0x00, 0x73, 0x00, 0x71, 0x80, 0x70, 0xC0, 0x70,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x30,
  0x01, 0xB8, 0x00, 0xFE, 0x00, 0x79, 0x80, 0x38, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x38, 0x60, 0x0C,
  0x30, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xF0, 0x07, 0xE1, 0x8F,
  0xF8, 0x3F, 0xE3, 0x70, 0x38, 0xC0, 0x66, 0x80, 0x33, 0x00, 0x6F, 0x00,
  0x3C, 0x00, 0xDC, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x78, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00,
  0x07, 0x80, 0x06, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x78, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0C,
  0xC1, 0xF0, 0xC7, 0xFC, 0xCC, 0x0E, 0xD8, 0x06, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70, 0x3C, 0x18,
  0x01, 0x87, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x66, 0x00, 0x18, 0xE0, 0x03, 0x0C, 0x00, 0xC0, 0xE0,
  0x78, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xC3, 0xF0, 0x67, 0xFE, 0x36, 0x03,
  0x9E, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1B, 0xC0, 0x1D, 0xB0, 0x1C, 0xCF, 0xFC, 0x61,
  0xF8, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xE0, 0x8F, 0xFC, 0x4E, 0x03, 0x26, 0x00, 0xD6, 0x00, 0x3B, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x0A,
  0x70, 0x1D, 0x1F, 0xF8, 0x83, 0xF0, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0xC3, 0xF3, 0xFD, 0xC3, 0x40, 0xF0, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x70, 0x1C, 0x60, 0x06, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x70,
  0x0E, 0x1F, 0xFC, 0x07, 0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x07, 0xFF, 0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x3F, 0x01, 0xE0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60,
  0x0F, 0x30, 0x1B, 0x3F, 0xF3, 0x0F, 0xC3, 0xC0, 0x00, 0x6C, 0x00, 0x09,
  0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x08, 0x18, 0x03, 0x03, 0x00, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x00, 0x8C, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x2C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x1E, 0x00, 0x38, 0x01, 0x98, 0x01, 0xC0, 0x0C, 0xC0, 0x0E, 0x00, 0x66,
  0x00, 0xD0, 0x03, 0x30, 0x06, 0xC0, 0x30, 0xC0, 0x26, 0x01, 0x86, 0x03,
  0x30, 0x0C, 0x30, 0x18, 0x80, 0x61, 0x80, 0xC6, 0x06, 0x04, 0x04, 0x30,
  0x30, 0x30, 0x61, 0x81, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0xC0,
  0x20, 0x81, 0x86, 0x01, 0x8C, 0x04, 0x30, 0x0C, 0x60, 0x31, 0x80, 0x62,
  0x01, 0x98, 0x01, 0x30, 0x0C, 0xC0, 0x0D, 0x80, 0x26, 0x00, 0x6C, 0x01,
  0xB0, 0x03, 0x40, 0x0D, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x98, 0x00,
  0xE7, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x06, 0x06, 0x03, 0x00, 0xC1, 0x80,
  0x38, 0x60, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x01, 0x86,
  0x00, 0xC1, 0x80, 0x70, 0x30, 0x18, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x71,
  0x80, 0x0C, 0xE0, 0x01, 0xB0, 0x00, 0x60, 0xC0, 0x00, 0x6C, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x10, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x00, 0x04, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0xF0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x0F,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x16, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38,
  0x0E, 0x00, 0x70, 0x68, 0x00, 0xFF, 0x00, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 36, 10, 4, -36 },
  { 10, 7, 10, 13, 4, -38 },
  { 19, 23, 36, 25, 2, -36 },
  { 123, 18, 46, 24, 3, -41 },
  { 227, 27, 36, 32, 3, -36 },
  { 349, 23, 37, 27, 3, -36 },
  { 456, 2, 10, 8, 3, -38 },
  { 459, 10, 51, 14, 3, -40 },
  { 523, 10, 51, 14, 1, -40 },
  { 587, 19, 20, 21, 1, -36 },
  { 635, 21, 26, 25, 2, -30 },
  { 704, 4, 11, 9, 2, -4 },
  { 710, 9, 2, 13, 2, -17 },
  { 713, 3, 3, 11, 4, -3 },
  { 715, 15, 39, 17, 1, -36 },
  { 789, 18, 36, 24, 3, -36 },
  { 870, 10, 36, 24, 4, -36 },
  { 915, 19, 36, 24, 3, -36 },
  { 1001, 18, 36, 24, 3, -36 },
  { 1082, 21, 36, 24, 2, -36 },
  { 1177, 18, 36, 24, 4, -36 },
  { 1258, 19, 36, 24, 3, -36 },
  { 1344, 20, 36, 24, 2, -36 },
  { 1434, 19, 36, 24, 3, -36 },
  { 1520, 18, 36, 24, 3, -36 },
  { 1601, 4, 26, 9, 3, -26 },
  { 1614, 4, 33, 9, 2, -26 },
  { 1631, 17, 20, 23, 2, -26 },
  { 1674, 17, 12, 24, 4, -22 },
  { 1700, 17, 20, 23, 3, -26 },
  { 1743, 15, 36, 20, 2, -36 },
  { 1811, 34, 46, 40, 3, -35 },
  { 2007, 25, 36, 27, 1, -36 },
  { 2120, 20, 36, 27, 4, -36 },
  { 2210, 22, 36, 28, 3, -36 },
  { 2309, 21, 36, 29, 4, -36 },
  { 2404, 19, 36, 25, 4, -36 },
  { 2490, 19, 36, 25, 4, -36 },
  { 2576, 22, 36, 30, 4, -36 },
  { 2675, 22, 36, 31, 4, -36 },
  { 2774, 2, 36, 12, 5, -36 },
  { 2783, 18, 36, 24, 2, -36 },
  { 2864, 22, 36, 28, 4, -36 },
  { 2963, 17, 36, 23, 4, -36 },
  { 3040, 29, 36, 37, 4, -36 },
  { 3171, 22, 36, 31, 4, -36 },
  { 3270, 23, 36, 29, 3, -36 },
  { 3374, 20, 36, 27, 4, -36 },
  { 3464, 23, 42, 29, 3, -36 },
  { 3585, 21, 36, 28, 4, -36 },
  { 3680, 22, 36, 26, 2, -36 },
  { 3779, 23, 36, 26, 2, -36 },
  { 3883, 21, 36, 29, 4, -36 },
  { 3978, 24, 36, 27, 1, -36 },
  { 4086, 35, 36, 39, 2, -36 },
  { 4244, 23, 36, 27, 2, -36 },
  { 4348, 24, 36, 26, 1, -36 },
  { 4456, 22, 36, 26, 2, -36 },
  { 4555, 6, 49, 11, 4, -41 },
  { 4592, 14, 39, 17, 2, -36 },
  { 4661, 7, 49, 11, 0, -41 },
  { 4704, 14, 18, 19, 2, -36 },
  { 4736, 18, 2, 19, 0, 0 },
  { 4741, 7, 7, 14, 3, -38 },
  { 4748, 18, 26, 23, 2, -26 },
  { 4807, 17, 38, 24, 4, -38 },
  { 4888, 18, 26, 23, 2, -26 },
  { 4947, 17, 38, 24, 3, -38 },
  { 5028, 18, 26, 23, 2, -26 },
  { 5087, 12, 39, 15, 2, -39 },
  { 5146, 17, 36, 24, 3, -26 },
  { 5223, 16, 38, 24, 4, -38 },
  { 5299, 3, 35, 10, 4, -35 },
  { 5313, 9, 45, 10, -2, -35 },
  { 5364, 17, 38, 21, 4, -38 },
  { 5445, 2, 38, 10, 4, -38 },
  { 5455, 31, 26, 39, 4, -26 },
  { 5556, 16, 26, 24, 4, -26 },
  { 5608, 19, 26, 24, 3, -26 },
  { 5670, 17, 36, 24, 4, -26 },
  { 5747, 17, 36, 24, 3, -26 },
  { 5824, 10, 26, 15, 4, -26 },
  { 5857, 16, 26, 22, 3, -26 },
  { 5909, 11, 33, 14, 1, -33 },
  { 5955, 16, 26, 24, 4, -26 },
  { 6007, 19, 26, 21, 1, -26 },
  { 6069, 29, 26, 33, 2, -26 },
  { 6164, 18, 26, 21, 2, -26 },
  { 6223, 19, 36, 21, 1, -26 },
  { 6309, 18, 26, 21, 2, -26 },
  { 6368, 12, 49, 15, 2, -39 },
  { 6442, 2, 43, 10, 4, -36 },
  { 6453, 12, 49, 15, 1, -39 },
  { 6527, 22, 8, 30, 4, -19 },
};

const GFXfont RobotoCondensed_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT50PT7B_H_
