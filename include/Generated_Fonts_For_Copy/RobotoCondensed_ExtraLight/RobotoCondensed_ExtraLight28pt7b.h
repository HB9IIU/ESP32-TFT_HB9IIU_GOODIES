#ifndef _ROBOTOCONDENSED_EXTRALIGHT28PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x0B, 0x99, 0x99, 0x99, 0x04, 0x20, 0x21,
  0x01, 0x08, 0x08, 0x40, 0x44, 0x04, 0x21, 0xFF, 0xE1, 0x08, 0x08, 0x40,
  0x42, 0x02, 0x20, 0x11, 0x01, 0x08, 0x7F, 0xF8, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x88, 0x08, 0x40, 0x42, 0x00, 0x04, 0x01, 0x00, 0x40, 0x78, 0x61,
  0x10, 0x28, 0x0E, 0x01, 0x80, 0x70, 0x04, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x98, 0x61, 0xE0, 0x10,
  0x04, 0x01, 0x00, 0x70, 0x01, 0x10, 0x02, 0x10, 0x04, 0x21, 0x08, 0x42,
  0x10, 0x88, 0x21, 0x20, 0x44, 0x40, 0x71, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x11, 0xC0, 0x44, 0x40, 0x90, 0x82, 0x20, 0x84, 0x41, 0x10, 0x82, 0x01,
  0x08, 0x01, 0x10, 0x01, 0xC0, 0x1E, 0x02, 0x30, 0x61, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x22, 0x02, 0x40, 0x18, 0x01, 0x80, 0x28, 0x04, 0x41, 0x82,
  0x28, 0x32, 0x81, 0x28, 0x0A, 0x80, 0xC8, 0x0C, 0x61, 0x23, 0xE1, 0xFC,
  0x08, 0x84, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x84, 0x21, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x42, 0x10, 0x42, 0x10,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x46, 0x21, 0x08, 0x84, 0x22, 0x21, 0x00,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x0E, 0x4E, 0x3E, 0x01, 0x80, 0x48, 0x19,
  0x02, 0x10, 0x81, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x55, 0x60, 0xF8, 0xF0, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x1E, 0x18, 0x44, 0x0A, 0x02, 0x80, 0xA0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x80, 0x90, 0x26, 0x10, 0x78, 0x04, 0xFE, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3E, 0x18, 0x4C,
  0x0A, 0x02, 0x80, 0xA0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x03, 0xFF, 0x0F, 0x06,
  0x10, 0x81, 0x20, 0x24, 0x02, 0x80, 0x40, 0x10, 0x02, 0x00, 0x81, 0xE0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0A, 0x01, 0x40, 0x2C, 0x08, 0xC3,
  0x07, 0x80, 0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C,
  0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x84, 0x08, 0xFF,
  0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x3F, 0xC8, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x78, 0x61, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x07, 0x01, 0x40, 0x50, 0x22, 0x18, 0x7C, 0x07, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x78, 0xA1, 0xB0, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xD0, 0x22, 0x10, 0x78, 0xFF, 0xE0,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x00, 0x1F, 0x06, 0x11, 0x81, 0x20, 0x34, 0x02, 0x80, 0x50, 0x1B,
  0x02, 0x30, 0x81, 0xE0, 0xC2, 0x20, 0x24, 0x02, 0x80, 0x60, 0x0A, 0x01,
  0x40, 0x28, 0x08, 0xC3, 0x0F, 0x80, 0x1F, 0x06, 0x31, 0x83, 0x20, 0x24,
  0x05, 0x80, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x0D, 0x83, 0x98, 0xD1, 0xE2,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x0E, 0x00, 0xB0, 0x00,
  0x00, 0x2C, 0x4C, 0x00, 0x00, 0x00, 0x00, 0x92, 0x4A, 0x00, 0x00, 0x40,
  0x60, 0x70, 0x30, 0x30, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x10, 0x00, 0x1E,
  0x31, 0x90, 0x58, 0x18, 0x08, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x00, 0x01, 0xF8,
  0x00, 0xC0, 0xC0, 0x60, 0x04, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x00,
  0x90, 0x3C, 0x12, 0x08, 0x42, 0x82, 0x08, 0x30, 0x41, 0x06, 0x10, 0x20,
  0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x20, 0xA1, 0x04, 0x14, 0x20, 0x82,
  0x84, 0x30, 0x50, 0xC5, 0x12, 0x0F, 0x1C, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x40, 0x03, 0xF0, 0x00, 0x02, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x1F, 0xF1, 0x00, 0x48, 0x02,
  0x40, 0x16, 0x00, 0xE0, 0x03, 0x00, 0x10, 0xFF, 0x18, 0x1B, 0x01, 0x60,
  0x3C, 0x03, 0x80, 0x70, 0x1E, 0x02, 0xC0, 0x9F, 0xE3, 0x03, 0x60, 0x3C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0x7F, 0x80, 0x0F,
  0x83, 0x04, 0x60, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x1C, 0x01, 0x40,
  0x16, 0x02, 0x30, 0x40, 0xF8, 0xFF, 0x0C, 0x0C, 0xC0, 0x6C, 0x02, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x2C, 0x06, 0xC0, 0xCF, 0xF0, 0xFF,
  0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F,
  0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1F, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x0F, 0x83, 0x06, 0x60, 0x24,
  0x01, 0x40, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x1F, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x01, 0x30, 0x70,
  0xFC, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x10, 0xFF, 0xFF,
  0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0xC0, 0x50, 0x22,
  0x18, 0x78, 0xC0, 0x36, 0x03, 0x30, 0x11, 0x81, 0x0C, 0x10, 0x61, 0x83,
  0x18, 0x18, 0x80, 0xC8, 0x06, 0xC0, 0x39, 0x01, 0x8C, 0x0C, 0x20, 0x60,
  0x83, 0x06, 0x18, 0x10, 0xC0, 0x46, 0x01, 0x30, 0x0D, 0x80, 0x20, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0xC0, 0x01, 0xC0, 0x03, 0xA0, 0x03, 0xA0, 0x03, 0xA0, 0x05, 0x90, 0x05,
  0xD0, 0x05, 0xC8, 0x09, 0x88, 0x09, 0xC8, 0x09, 0xC4, 0x11, 0xC4, 0x11,
  0xC4, 0x11, 0xC2, 0x21, 0xC2, 0x21, 0xC2, 0x41, 0xC1, 0x41, 0xC1, 0x41,
  0xC1, 0x81, 0xC0, 0x81, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x1D, 0x00,
  0xE4, 0x07, 0x20, 0x38, 0x81, 0xC4, 0x0E, 0x10, 0x70, 0xC3, 0x82, 0x1C,
  0x08, 0xE0, 0x47, 0x01, 0x38, 0x09, 0xC0, 0x2E, 0x01, 0xF0, 0x07, 0x80,
  0x30, 0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x50, 0x02, 0x40, 0x13, 0x01, 0x0C, 0x10, 0x1F, 0x00, 0xFF, 0x8C,
  0x0C, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x02, 0xC0, 0x2C,
  0x06, 0xC0, 0xCF, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x81, 0x82, 0x10, 0x08, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x40, 0x13, 0x01, 0x0C, 0x10, 0x1F,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0xFF, 0x08, 0x0C, 0x80, 0x68,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0xCF,
  0xF8, 0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x28,
  0x01, 0x0F, 0x83, 0x04, 0x60, 0x24, 0x01, 0x40, 0x14, 0x01, 0x40, 0x02,
  0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x01, 0x40, 0x16, 0x03, 0x30, 0x60, 0xF8, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x34, 0x02, 0x30, 0x41, 0xF8, 0x80, 0x0C,
  0x00, 0x70, 0x06, 0x80, 0x24, 0x01, 0x20, 0x18, 0x80, 0x84, 0x04, 0x20,
  0x20, 0x82, 0x04, 0x10, 0x20, 0x80, 0x88, 0x04, 0x40, 0x22, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x01, 0x80, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0x60, 0x24, 0x06, 0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90,
  0x62, 0x09, 0x04, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x41, 0x10,
  0x88, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x58, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC0, 0x12, 0x00,
  0x88, 0x08, 0x40, 0xC1, 0x04, 0x08, 0x60, 0x22, 0x01, 0xA0, 0x05, 0x00,
  0x10, 0x01, 0x80, 0x0A, 0x00, 0x98, 0x04, 0x40, 0x41, 0x02, 0x08, 0x20,
  0x23, 0x01, 0x90, 0x05, 0x00, 0x30, 0x80, 0x0E, 0x00, 0x90, 0x04, 0xC0,
  0x42, 0x02, 0x10, 0x20, 0x41, 0x02, 0x10, 0x08, 0x80, 0x48, 0x01, 0x40,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xFF, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18,
  0x18, 0x18, 0x24, 0x24, 0x24, 0x42, 0x42, 0x42, 0x81, 0xFF, 0xC0, 0x84,
  0x22, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x00, 0x40, 0x10, 0x04, 0x7F, 0x60,
  0x50, 0x18, 0x06, 0x01, 0x40, 0xD8, 0x53, 0xE4, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xE2, 0x86, 0xC0, 0xA0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3C, 0x0A, 0x86, 0x9E, 0x00, 0x1F,
  0x08, 0x24, 0x05, 0x01, 0x40, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x05, 0x01, 0x40, 0x48, 0x21, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0xFA, 0xC3, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x70, 0x2C, 0x33, 0xE8, 0x1F, 0x0C, 0x24, 0x05, 0x01, 0xC0,
  0x60, 0x1F, 0xFE, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x4C, 0x31,
  0xF0, 0x0E, 0x20, 0xC1, 0x02, 0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3E, 0xB0, 0xF0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0B, 0x0C,
  0xFA, 0x01, 0x00, 0x80, 0x40, 0x2C, 0x23, 0xE0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x79, 0x43, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0xB0, 0x0A, 0xAA, 0xAA,
  0xAA, 0x80, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0xB8, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x1A, 0x0C, 0x82, 0x21, 0x08, 0x82, 0x40, 0xB0, 0x3C,
  0x0C, 0x82, 0x10, 0x84, 0x20, 0x88, 0x12, 0x06, 0x80, 0x80, 0xFF, 0xFF,
  0xF8, 0x9E, 0x1F, 0x28, 0x4C, 0x6C, 0x0C, 0x0B, 0x03, 0x02, 0x80, 0x80,
  0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18,
  0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x04, 0x9E,
  0x50, 0xF0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x1E, 0x18, 0x4C, 0x0A, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xC0, 0x98, 0x41, 0xE0, 0x9E,
  0x28, 0x6C, 0x0A, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0xC0, 0xA8, 0x69, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x3E, 0xB0, 0xF0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x1C, 0x0B, 0x0C, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x9E, 0x8C, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x1F, 0x18, 0x64, 0x09, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x20, 0x07, 0x01, 0x40, 0xD8, 0x61, 0xF0, 0x20, 0x82, 0x08,
  0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0xC0,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x14, 0x0B, 0x1C, 0xFA, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x90,
  0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0,
  0x80, 0x81, 0xC1, 0x81, 0x41, 0x83, 0x41, 0xC2, 0x42, 0x42, 0x62, 0x42,
  0x22, 0x42, 0x22, 0x24, 0x24, 0x24, 0x24, 0x24, 0x14, 0x24, 0x14, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x18, 0xC0, 0xD0, 0x22, 0x10, 0x84, 0x12,
  0x05, 0x80, 0xC0, 0x30, 0x0C, 0x04, 0x83, 0x20, 0x84, 0x61, 0x90, 0x28,
  0x04, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x98, 0x42, 0x10, 0x84, 0x33,
  0x04, 0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0xE0, 0x00, 0x7F, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x0F, 0xFC, 0x02,
  0x18, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x30,
  0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x30, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0xC0, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x80, 0x86, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x86, 0x00, 0x38, 0x0A, 0x20, 0x60, 0x85,
  0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 4, 6, 8, 2, -21 },
  { 9, 13, 20, 14, 1, -20 },
  { 42, 10, 26, 14, 2, -23 },
  { 75, 15, 20, 18, 2, -20 },
  { 113, 12, 20, 15, 2, -20 },
  { 143, 1, 6, 5, 2, -21 },
  { 144, 5, 28, 8, 2, -22 },
  { 162, 5, 28, 8, 1, -22 },
  { 180, 11, 11, 12, 0, -20 },
  { 196, 12, 15, 14, 1, -17 },
  { 219, 2, 6, 5, 1, -2 },
  { 221, 5, 1, 7, 1, -10 },
  { 222, 2, 2, 6, 2, -2 },
  { 223, 8, 22, 10, 1, -20 },
  { 245, 10, 20, 14, 2, -20 },
  { 270, 6, 20, 14, 2, -20 },
  { 285, 10, 20, 14, 2, -20 },
  { 310, 11, 20, 14, 1, -20 },
  { 338, 12, 20, 14, 1, -20 },
  { 368, 10, 20, 14, 2, -20 },
  { 393, 10, 20, 14, 2, -20 },
  { 418, 11, 20, 14, 1, -20 },
  { 446, 11, 20, 14, 1, -20 },
  { 474, 11, 20, 14, 1, -20 },
  { 502, 2, 15, 5, 2, -15 },
  { 506, 3, 19, 5, 1, -15 },
  { 514, 10, 12, 13, 1, -15 },
  { 529, 10, 6, 14, 2, -12 },
  { 537, 9, 12, 13, 2, -15 },
  { 551, 9, 20, 11, 1, -20 },
  { 574, 19, 25, 22, 2, -19 },
  { 634, 13, 20, 15, 1, -20 },
  { 667, 11, 20, 15, 2, -20 },
  { 695, 12, 20, 16, 2, -20 },
  { 725, 12, 20, 16, 2, -20 },
  { 755, 11, 20, 14, 2, -20 },
  { 783, 11, 20, 14, 2, -20 },
  { 811, 12, 20, 17, 2, -20 },
  { 841, 13, 20, 17, 2, -20 },
  { 874, 1, 20, 7, 3, -20 },
  { 877, 10, 20, 14, 1, -20 },
  { 902, 13, 20, 15, 2, -20 },
  { 935, 10, 20, 13, 2, -20 },
  { 960, 16, 20, 21, 2, -20 },
  { 1000, 13, 20, 17, 2, -20 },
  { 1033, 13, 20, 16, 2, -20 },
  { 1066, 12, 20, 15, 2, -20 },
  { 1096, 13, 24, 16, 2, -20 },
  { 1135, 12, 20, 16, 2, -20 },
  { 1165, 12, 20, 15, 1, -20 },
  { 1195, 13, 20, 15, 1, -20 },
  { 1228, 12, 20, 16, 2, -20 },
  { 1258, 13, 20, 15, 1, -20 },
  { 1291, 20, 20, 22, 1, -20 },
  { 1341, 13, 20, 15, 1, -20 },
  { 1374, 13, 20, 15, 1, -20 },
  { 1407, 12, 20, 15, 1, -20 },
  { 1437, 4, 27, 6, 2, -23 },
  { 1451, 8, 22, 10, 1, -20 },
  { 1473, 4, 27, 6, 0, -23 },
  { 1487, 8, 10, 10, 1, -20 },
  { 1497, 10, 1, 11, 0, 0 },
  { 1499, 4, 4, 8, 2, -21 },
  { 1501, 10, 15, 13, 1, -15 },
  { 1520, 10, 21, 14, 2, -21 },
  { 1547, 10, 15, 13, 1, -15 },
  { 1566, 9, 21, 14, 2, -21 },
  { 1590, 10, 15, 13, 1, -15 },
  { 1609, 7, 21, 8, 1, -21 },
  { 1628, 9, 21, 14, 2, -15 },
  { 1652, 9, 21, 14, 2, -21 },
  { 1676, 2, 21, 6, 2, -21 },
  { 1682, 5, 27, 6, -1, -21 },
  { 1699, 10, 21, 12, 2, -21 },
  { 1726, 1, 21, 6, 2, -21 },
  { 1729, 18, 15, 22, 2, -15 },
  { 1763, 9, 15, 14, 2, -15 },
  { 1780, 10, 15, 14, 2, -15 },
  { 1799, 10, 21, 14, 2, -15 },
  { 1826, 9, 21, 14, 2, -15 },
  { 1850, 6, 15, 8, 2, -15 },
  { 1862, 10, 15, 12, 1, -15 },
  { 1881, 6, 19, 8, 1, -19 },
  { 1896, 9, 15, 14, 2, -15 },
  { 1913, 10, 15, 12, 1, -15 },
  { 1932, 16, 15, 18, 1, -15 },
  { 1962, 10, 15, 12, 1, -15 },
  { 1981, 10, 21, 12, 1, -15 },
  { 2008, 10, 15, 12, 1, -15 },
  { 2027, 7, 28, 8, 1, -22 },
  { 2052, 2, 24, 6, 2, -20 },
  { 2058, 7, 28, 8, 0, -22 },
  { 2083, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT28PT7B_H_
