#ifndef _ROBOTOCONDENSED_EXTRALIGHT7PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0x00, 0x1D, 0xF0, 0x1E, 0x22, 0xC0, 0xCE, 0x27, 0x30, 0x4A,
  0x4A, 0xE0, 0x80, 0x1A, 0xA4, 0x7E, 0x4A, 0x00, 0x09, 0x00, 0x40, 0x00,
  0x00, 0x16, 0x80, 0xF6, 0xDE, 0xF0, 0x64, 0xA4, 0x65, 0x16, 0x2E, 0xF2,
  0xA5, 0x40, 0x52, 0xDE, 0x64, 0xA0, 0xF5, 0x5E, 0xF6, 0xB2, 0x80, 0x88,
  0x39, 0x00, 0x5C, 0x8D, 0x00, 0xD4, 0x00, 0x33, 0x67, 0xBF, 0xC1, 0x80,
  0x44, 0x66, 0x80, 0xFF, 0x40, 0x79, 0x89, 0x70, 0x56, 0xD4, 0x2E, 0x00,
  0x2E, 0x00, 0xD2, 0x5E, 0x37, 0xD2, 0x70, 0x04, 0x9E, 0x1A, 0x60, 0x2A,
  0x00, 0x19, 0xBB, 0x50, 0x36, 0xF2, 0x79, 0x99, 0x70, 0xFE, 0x00, 0x79,
  0x99, 0xF0, 0xD7, 0x40, 0xD1, 0x16, 0x49, 0x20, 0x3F, 0xC0, 0x8A, 0x64,
  0x00, 0x85, 0x6A, 0xA4, 0x00, 0x0D, 0x30, 0x86, 0x44, 0x00, 0x65, 0x2C,
  0x7C, 0xA5, 0x00, 0xFC, 0x78, 0x40, 0x00, 0x47, 0xF0, 0x3F, 0xC0, 0x52,
  0x70, 0x0E, 0xDE, 0x5E, 0x60, 0x3A, 0x00, 0x56, 0xF0, 0x3F, 0x00, 0x30,
  0x3C, 0x3A, 0x40, 0x70, 0xFD, 0xD0, 0xFC, 0x56, 0xF0, 0xFF, 0x00, 0x56,
  0xF0, 0xE0, 0x51, 0xF0, 0x3A, 0x00, 0x3F, 0xB5, 0x20, 0x8B, 0xD5, 0xA9,
  0x00, 0xB5, 0x24, 0x00, 0xE9, 0x60, 0x10, 0x40, 0x78, 0x20, 0x80, 0x52,
};

const GFXglyph RobotoCondensed_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 2, 1, 2, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 7, 3, 0, -6 },
  { 8, 4, 5, 5, 0, -5 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 1, 1, 1, 0, -5 },
  { 15, 2, 8, 2, 0, -6 },
  { 17, 1, 8, 2, 0, -6 },
  { 18, 3, 3, 3, 0, -5 },
  { 20, 3, 4, 3, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -3 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 2, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 1, 5, 3, 1, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 2, 5, 3, 1, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 1, 4, 1, 0, -4 },
  { 47, 1, 5, 1, 0, -4 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 2, 5, 3, 0, -5 },
  { 55, 5, 7, 6, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 5, 4, 1, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 2, 5, 4, 1, -5 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 1, 5, 2, 0, -5 },
  { 79, 3, 5, 3, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 2, 5, 3, 1, -5 },
  { 85, 4, 5, 5, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 2, 5, 4, 1, -5 },
  { 95, 4, 6, 4, 0, -5 },
  { 98, 3, 5, 4, 1, -5 },
  { 100, 3, 5, 4, 0, -5 },
  { 102, 3, 5, 4, 0, -5 },
  { 104, 2, 5, 4, 1, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 5, 5, 5, 0, -5 },
  { 113, 3, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 1, 7, 1, 1, -6 },
  { 121, 2, 5, 2, 0, -5 },
  { 123, 1, 7, 1, 0, -6 },
  { 124, 2, 3, 3, 0, -5 },
  { 125, 3, 1, 3, 0, 0 },
  { 126, 1, 1, 2, 0, -5 },
  { 127, 3, 4, 3, 0, -4 },
  { 129, 2, 5, 3, 1, -5 },
  { 131, 3, 4, 3, 0, -4 },
  { 133, 3, 5, 3, 0, -5 },
  { 135, 3, 4, 3, 0, -4 },
  { 137, 2, 5, 2, 0, -5 },
  { 139, 3, 5, 3, 0, -4 },
  { 141, 2, 5, 3, 1, -5 },
  { 143, 1, 5, 1, 0, -5 },
  { 144, 1, 7, 1, 0, -5 },
  { 145, 2, 5, 3, 1, -5 },
  { 147, 1, 5, 1, 0, -5 },
  { 148, 4, 4, 5, 1, -4 },
  { 150, 2, 4, 3, 1, -4 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 2, 5, 3, 1, -4 },
  { 155, 3, 5, 3, 0, -4 },
  { 157, 1, 4, 2, 1, -4 },
  { 158, 3, 4, 3, 0, -4 },
  { 160, 2, 5, 2, 0, -5 },
  { 162, 2, 4, 3, 1, -4 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 4, 4, 5, 0, -4 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 3, 6, 3, 0, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 2, 6, 2, 0, -5 },
  { 176, 1, 6, 1, 0, -5 },
  { 177, 2, 6, 2, 0, -5 },
  { 179, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT7PT7B_H_
