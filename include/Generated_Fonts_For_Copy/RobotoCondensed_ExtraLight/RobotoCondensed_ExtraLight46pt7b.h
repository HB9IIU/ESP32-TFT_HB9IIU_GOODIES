#ifndef _ROBOTOCONDENSED_EXTRALIGHT46PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0x1F, 0x60, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08,
  0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x83, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x02, 0x02, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x04, 0x04, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0x60, 0x30, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x90,
  0x00, 0xC8, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x50,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0x60, 0x03,
  0x38, 0x03, 0x0E, 0x03, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x41, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x20, 0x80, 0x40, 0x60,
  0x80, 0x40, 0xC0, 0x80, 0x40, 0xC0, 0x80, 0x41, 0x80, 0x80, 0x41, 0x00,
  0x80, 0xC3, 0x00, 0xC0, 0xC2, 0x00, 0x41, 0x86, 0x00, 0x7F, 0x04, 0x00,
  0x1E, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x78, 0x00, 0x60, 0xFC, 0x00, 0x61, 0x86, 0x00, 0xC3, 0x03,
  0x00, 0x82, 0x03, 0x01, 0x82, 0x01, 0x01, 0x02, 0x01, 0x03, 0x02, 0x01,
  0x02, 0x02, 0x01, 0x06, 0x02, 0x01, 0x04, 0x02, 0x03, 0x04, 0x03, 0x03,
  0x00, 0x01, 0x86, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x03, 0x01, 0x80, 0x18, 0x30,
  0x01, 0x86, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x26, 0x06, 0x02, 0x40,
  0x60, 0x6C, 0x03, 0x06, 0xC0, 0x18, 0x68, 0x00, 0xC6, 0x80, 0x0C, 0xC8,
  0x00, 0x6C, 0x80, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0x6C,
  0x30, 0x1C, 0x61, 0xFF, 0x86, 0x07, 0xE0, 0x30, 0xFF, 0xFF, 0xE0, 0x00,
  0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x60,
  0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x03, 0x03, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x0C, 0x1F, 0xE3, 0x3E, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x0D, 0x80, 0x03, 0x30, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x18,
  0x06, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x33, 0x33, 0x32, 0x66, 0xC8, 0xFF, 0xFF, 0xC0, 0x7D, 0x80, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x06, 0x07, 0x06, 0x01, 0x86, 0x00, 0x63, 0x00, 0x11, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x05, 0x80,
  0x02, 0xC0, 0x03, 0x60, 0x01, 0x90, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x61,
  0x80, 0x60, 0x60, 0x70, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x81, 0xC7,
  0xAF, 0x1E, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x07,
  0xE0, 0x0F, 0xFC, 0x0E, 0x07, 0x0E, 0x01, 0x86, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09, 0x80,
  0x06, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0x60, 0x3F, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03,
  0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x3F, 0xFF,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x67, 0xE0, 0x7F, 0xF8,
  0x70, 0x1C, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x0C, 0x38, 0x1C, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x7E, 0x0C, 0xFF, 0x86, 0xC0, 0x63, 0xC0, 0x19, 0xC0, 0x06,
  0xC0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x90, 0x00, 0xCC,
  0x00, 0x67, 0x00, 0x61, 0x80, 0x30, 0x70, 0x30, 0x1F, 0xF0, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0,
  0x0C, 0x30, 0x03, 0x08, 0x00, 0x66, 0x00, 0x19, 0x80, 0x02, 0x60, 0x00,
  0x98, 0x00, 0x26, 0x00, 0x18, 0x80, 0x06, 0x30, 0x01, 0x06, 0x00, 0xC1,
  0xC0, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0x03, 0x83, 0x80, 0x30, 0xC0,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00, 0xE1,
  0x80, 0x70, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0x03, 0x87, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03,
  0x40, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x01, 0x4C, 0x01, 0xA3,
  0x81, 0x90, 0xFF, 0x98, 0x1F, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x01,
  0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xBF, 0x67, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x33, 0x26, 0x66, 0xC8, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x03, 0x18,
  0x06, 0x60, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x0F, 0x80, 0x31, 0x00,
  0x3F, 0x80, 0x26, 0x00, 0xC1, 0x80, 0x4C, 0x03, 0x01, 0x00, 0xD0, 0x0C,
  0x02, 0x01, 0xE0, 0x10, 0x04, 0x03, 0xC0, 0x60, 0x08, 0x07, 0x80, 0xC0,
  0x10, 0x0F, 0x01, 0x00, 0x60, 0x1C, 0x02, 0x00, 0xC0, 0x38, 0x0C, 0x01,
  0x80, 0x70, 0x18, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x01, 0xC0, 0x60, 0x0C,
  0x02, 0x80, 0xC0, 0x18, 0x05, 0x01, 0x80, 0x20, 0x0B, 0x03, 0x00, 0xC0,
  0x36, 0x02, 0x01, 0xC0, 0x4C, 0x06, 0x05, 0x81, 0x98, 0x0C, 0x19, 0x06,
  0x10, 0x0F, 0xE3, 0xB8, 0x30, 0x0F, 0x03, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0x63, 0x00, 0x00, 0x86,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x80,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x04, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC,
  0x30, 0x03, 0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x73, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0E, 0x03, 0x81, 0x80, 0x0C, 0x30,
  0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x06, 0x30,
  0x00, 0x61, 0x80, 0x0C, 0x0E, 0x01, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x00, 0x38, 0x60, 0x01, 0x8C, 0x00, 0x19,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x03, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1C, 0x03,
  0x83, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00,
  0x36, 0x00, 0x03, 0x30, 0x00, 0x33, 0x80, 0x06, 0x1C, 0x01, 0xC0, 0x7F,
  0xF8, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0E, 0x38, 0x1C, 0x1F, 0xF8,
  0x07, 0xE0, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x30,
  0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30,
  0x00, 0xC6, 0x00, 0x0C, 0xF0, 0x00, 0xDF, 0x00, 0x0D, 0x98, 0x00, 0xF0,
  0xC0, 0x0E, 0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0C,
  0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30,
  0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x05, 0xF0, 0x00, 0x03, 0x74,
  0x00, 0x00, 0xDD, 0x80, 0x00, 0x27, 0x60, 0x00, 0x19, 0xC8, 0x00, 0x06,
  0x73, 0x00, 0x01, 0x1C, 0xC0, 0x00, 0xC7, 0x10, 0x00, 0x31, 0xC6, 0x00,
  0x18, 0x71, 0x80, 0x06, 0x1C, 0x30, 0x01, 0x07, 0x0C, 0x00, 0xC1, 0xC1,
  0x00, 0x30, 0x70, 0x60, 0x08, 0x1C, 0x18, 0x06, 0x07, 0x02, 0x01, 0x81,
  0xC0, 0xC0, 0x40, 0x70, 0x30, 0x30, 0x1C, 0x04, 0x0C, 0x07, 0x01, 0x82,
  0x01, 0xC0, 0x61, 0x80, 0x70, 0x08, 0x60, 0x1C, 0x03, 0x30, 0x07, 0x00,
  0x4C, 0x01, 0xC0, 0x1A, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0x80, 0x01, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00, 0x1C, 0x30,
  0x01, 0xC1, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x01, 0xC0,
  0x60, 0x1C, 0x03, 0x01, 0xC0, 0x30, 0x1C, 0x01, 0x81, 0xC0, 0x08, 0x1C,
  0x00, 0xC1, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00, 0x31,
  0xC0, 0x01, 0x9C, 0x00, 0x09, 0xC0, 0x00, 0xDC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0x80, 0xE0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xC8, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1B,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00,
  0x60, 0x38, 0x0E, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x07, 0x3F,
  0xFF, 0x8F, 0xFF, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00,
  0x06, 0x30, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x12, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x38, 0x0E, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0x00, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x30, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x07, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1C, 0x03, 0x83, 0x80, 0x0C,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00,
  0x36, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03,
  0x70, 0x00, 0x63, 0x80, 0x0C, 0x1C, 0x03, 0xC0, 0x7F, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0x60, 0x00, 0x66, 0x00, 0x0C, 0xE0, 0x03, 0x0E, 0x01, 0xC0, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x03,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x00, 0x86, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0xC0, 0x02, 0x60, 0x02, 0x40, 0x06, 0x60, 0x02,
  0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04,
  0x20, 0x04, 0x30, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x18, 0x08, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x18, 0x08, 0x10,
  0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20,
  0x04, 0x30, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x06, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x02, 0x60, 0x06, 0x40, 0x02, 0x60, 0x02, 0xC0,
  0x03, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0xCC, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x10,
  0x30, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00, 0x21,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x20, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xFF, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0xFF,
  0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xFF, 0x02, 0x00, 0x38, 0x01,
  0xC0, 0x1A, 0x00, 0xD8, 0x04, 0xC0, 0x62, 0x03, 0x18, 0x10, 0xC1, 0x82,
  0x0C, 0x18, 0x40, 0x46, 0x03, 0x30, 0x19, 0x00, 0x58, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE1, 0x83, 0x06, 0x18, 0x30, 0x03, 0xF0, 0x0F, 0xFC,
  0x18, 0x0E, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x03, 0xFF, 0x1F, 0xFF, 0x38, 0x03, 0x60, 0x03,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x07,
  0x60, 0x0F, 0x70, 0x1B, 0x3F, 0xF3, 0x0F, 0xC1, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x7E, 0x0C, 0xFF, 0xC6,
  0xC0, 0x73, 0xC0, 0x19, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x00, 0xB0, 0x00,
  0x58, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x1B,
  0x80, 0x0D, 0xE0, 0x0C, 0xD8, 0x0E, 0x67, 0xFE, 0x30, 0xFC, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x06, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19,
  0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xA0,
  0x00, 0x98, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x70, 0x3F, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x07, 0xC3, 0x1F, 0xF3, 0x30, 0x1B, 0x60, 0x0F, 0x60, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x1B, 0x1F, 0xF3, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xFE, 0x06, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x19, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x10, 0xE0, 0x38, 0x3F,
  0xF8, 0x07, 0xF0, 0x03, 0xE0, 0xFC, 0x38, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x7F, 0xEF, 0xFC, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x0F, 0xC3, 0x1F, 0xF3, 0x30, 0x1B, 0x60, 0x0F,
  0x40, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x1B,
  0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1F, 0xF8, 0x07, 0xE0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x1F, 0x08, 0xFF, 0x93, 0x03,
  0x2C, 0x03, 0x50, 0x06, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x7D, 0x80, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x0E, 0xFC, 0xF0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x68, 0x01, 0x90,
  0x06, 0x20, 0x18, 0x40, 0x60, 0x81, 0x81, 0x06, 0x02, 0x1C, 0x04, 0x30,
  0x08, 0xC0, 0x13, 0x00, 0x2F, 0x00, 0x73, 0x00, 0xC3, 0x01, 0x06, 0x02,
  0x06, 0x04, 0x06, 0x08, 0x0C, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x18, 0x80,
  0x19, 0x00, 0x1A, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC3, 0xF0, 0x0F, 0x86, 0x3F, 0xC1, 0xFF, 0x33, 0x03, 0x18,
  0x1D, 0xA0, 0x0D, 0x80, 0x6F, 0x00, 0x68, 0x01, 0xF0, 0x01, 0xC0, 0x0F,
  0x80, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x30,
  0x01, 0xE0, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x03,
  0xC0, 0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80,
  0x06, 0x00, 0x3C, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x80, 0x0F, 0x00, 0x0C,
  0x00, 0x78, 0x00, 0x60, 0x03, 0x83, 0xE1, 0x1F, 0xF2, 0x60, 0x65, 0x80,
  0x6A, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x07, 0xE0, 0x0F, 0xFC, 0x0E, 0x03, 0x0E, 0x00, 0xC6, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x61, 0xC0,
  0x60, 0x7F, 0xE0, 0x0F, 0xC0, 0xC3, 0xF0, 0x67, 0xFE, 0x36, 0x03, 0x9E,
  0x00, 0xCE, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0xDC, 0x00, 0x6F,
  0x00, 0x66, 0xC0, 0x73, 0x3F, 0xF1, 0x87, 0xE0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xC3, 0x1F, 0xF3, 0x30, 0x1B, 0x60, 0x0F,
  0x60, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x1B,
  0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x87, 0xCF,
  0xEE, 0x14, 0x0E, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x02, 0x60, 0x02, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x1F, 0xF8, 0x07,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF,
  0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0xF0, 0x3C, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60, 0x07, 0x60, 0x0F, 0x30, 0x1B,
  0x1F, 0xF3, 0x0F, 0xC3, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x62, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x06, 0x0C,
  0x02, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0x60,
  0x0C, 0x20, 0x02, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x2C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0x3C, 0x00, 0xC0, 0x0D, 0x00, 0x78, 0x02, 0x60, 0x1E, 0x01, 0x98,
  0x04, 0x80, 0x66, 0x03, 0x30, 0x18, 0x80, 0xCC, 0x04, 0x30, 0x33, 0x03,
  0x0C, 0x08, 0x40, 0xC3, 0x06, 0x18, 0x30, 0x41, 0x86, 0x08, 0x18, 0x40,
  0x86, 0x06, 0x10, 0x21, 0x81, 0x8C, 0x0C, 0x60, 0x23, 0x03, 0x10, 0x0C,
  0x80, 0x4C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x16, 0x01, 0xA0,
  0x05, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x08, 0x00,
  0x40, 0x60, 0x03, 0x98, 0x01, 0x8C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0,
  0x60, 0x60, 0x18, 0x60, 0x0C, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0C, 0x80, 0x04, 0x60, 0x06,
  0x18, 0x06, 0x0C, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0x61, 0x80, 0x19,
  0x80, 0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x62, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x06, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0x60,
  0x0C, 0x20, 0x02, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x2C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x60, 0x38, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x78, 0x07, 0x03, 0x80, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x0E, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x58, 0x30, 0x06, 0xC0, 0xC0, 0x34, 0x03, 0x01, 0xE0, 0x0C,
  0x1B, 0x00, 0x3F, 0x80, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 33, 9, 3, -33 },
  { 14, 7, 10, 12, 3, -35 },
  { 23, 21, 33, 23, 2, -33 },
  { 110, 17, 41, 22, 3, -37 },
  { 198, 24, 33, 30, 3, -33 },
  { 297, 20, 33, 25, 3, -33 },
  { 380, 2, 10, 8, 3, -35 },
  { 383, 9, 48, 13, 3, -37 },
  { 437, 9, 48, 13, 1, -37 },
  { 491, 18, 18, 19, 1, -33 },
  { 532, 19, 24, 23, 2, -27 },
  { 589, 4, 10, 9, 2, -4 },
  { 594, 9, 2, 12, 1, -16 },
  { 597, 3, 3, 10, 3, -3 },
  { 599, 13, 36, 16, 1, -33 },
  { 658, 17, 33, 22, 3, -33 },
  { 729, 9, 33, 22, 4, -33 },
  { 767, 17, 33, 22, 3, -33 },
  { 838, 18, 33, 22, 2, -33 },
  { 913, 19, 33, 22, 2, -33 },
  { 992, 16, 33, 22, 4, -33 },
  { 1058, 17, 33, 22, 3, -33 },
  { 1129, 18, 33, 22, 2, -33 },
  { 1204, 18, 33, 22, 2, -33 },
  { 1279, 17, 33, 22, 2, -33 },
  { 1350, 3, 24, 8, 3, -24 },
  { 1359, 4, 30, 8, 2, -24 },
  { 1374, 16, 18, 21, 2, -24 },
  { 1410, 16, 12, 22, 3, -21 },
  { 1434, 16, 18, 21, 3, -24 },
  { 1470, 14, 33, 18, 2, -33 },
  { 1528, 31, 42, 37, 3, -32 },
  { 1691, 23, 33, 25, 1, -33 },
  { 1786, 18, 33, 25, 4, -33 },
  { 1861, 20, 33, 26, 3, -33 },
  { 1944, 19, 33, 26, 4, -33 },
  { 2023, 17, 33, 23, 4, -33 },
  { 2094, 17, 33, 23, 4, -33 },
  { 2165, 20, 33, 28, 4, -33 },
  { 2248, 20, 33, 28, 4, -33 },
  { 2331, 1, 33, 11, 5, -33 },
  { 2336, 16, 33, 22, 2, -33 },
  { 2402, 20, 33, 25, 4, -33 },
  { 2485, 16, 33, 21, 4, -33 },
  { 2551, 26, 33, 34, 4, -33 },
  { 2659, 20, 33, 28, 4, -33 },
  { 2742, 21, 33, 27, 3, -33 },
  { 2829, 18, 33, 25, 4, -33 },
  { 2904, 21, 39, 27, 3, -33 },
  { 3007, 19, 33, 26, 4, -33 },
  { 3086, 20, 33, 24, 2, -33 },
  { 3169, 22, 33, 24, 1, -33 },
  { 3260, 19, 33, 27, 4, -33 },
  { 3339, 22, 33, 25, 1, -33 },
  { 3430, 32, 33, 36, 2, -33 },
  { 3562, 22, 33, 24, 1, -33 },
  { 3653, 22, 33, 24, 1, -33 },
  { 3744, 20, 33, 24, 2, -33 },
  { 3827, 6, 44, 10, 4, -37 },
  { 3860, 14, 36, 16, 1, -33 },
  { 3923, 6, 44, 10, 0, -37 },
  { 3956, 13, 16, 17, 2, -33 },
  { 3982, 17, 2, 17, 0, 0 },
  { 3987, 6, 6, 13, 3, -34 },
  { 3992, 16, 24, 22, 2, -24 },
  { 4040, 17, 35, 22, 3, -35 },
  { 4115, 17, 24, 21, 2, -24 },
  { 4166, 16, 35, 22, 3, -35 },
  { 4236, 17, 24, 21, 2, -24 },
  { 4287, 11, 35, 13, 2, -35 },
  { 4336, 16, 33, 22, 3, -24 },
  { 4402, 15, 35, 22, 4, -35 },
  { 4468, 3, 33, 9, 3, -33 },
  { 4481, 8, 42, 10, -2, -33 },
  { 4523, 15, 35, 20, 4, -35 },
  { 4589, 2, 35, 9, 4, -35 },
  { 4598, 29, 24, 36, 3, -24 },
  { 4685, 15, 24, 22, 4, -24 },
  { 4730, 17, 24, 22, 3, -24 },
  { 4781, 17, 33, 22, 3, -24 },
  { 4852, 16, 33, 22, 3, -24 },
  { 4918, 9, 24, 14, 4, -24 },
  { 4945, 16, 24, 20, 2, -24 },
  { 4993, 10, 31, 13, 1, -31 },
  { 5032, 16, 24, 22, 3, -24 },
  { 5080, 17, 24, 20, 1, -24 },
  { 5131, 26, 24, 30, 2, -24 },
  { 5209, 17, 24, 20, 1, -24 },
  { 5260, 17, 33, 19, 1, -24 },
  { 5331, 16, 24, 20, 2, -24 },
  { 5379, 11, 46, 14, 2, -36 },
  { 5443, 2, 39, 10, 4, -33 },
  { 5453, 11, 46, 14, 1, -36 },
  { 5517, 21, 8, 28, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT46PT7B_H_
