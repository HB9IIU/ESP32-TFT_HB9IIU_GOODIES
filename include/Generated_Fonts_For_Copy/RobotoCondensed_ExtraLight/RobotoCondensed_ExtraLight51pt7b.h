#ifndef _ROBOTOCONDENSED_EXTRALIGHT51PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00,
  0x00, 0x1B, 0xE0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x00, 0x06, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x08, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x80, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF8, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20,
  0x00, 0xC0, 0x40, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0xE0, 0x38, 0x18, 0x03, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00, 0x03, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00,
  0x1C, 0x70, 0x03, 0x07, 0x01, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0x40, 0x10, 0x20, 0x08, 0x06, 0x04, 0x01,
  0x81, 0x80, 0x80, 0x30, 0x30, 0x10, 0x06, 0x0C, 0x02, 0x00, 0xC1, 0x80,
  0x60, 0x10, 0x60, 0x0C, 0x06, 0x08, 0x00, 0x80, 0xC3, 0x00, 0x18, 0x30,
  0x40, 0x01, 0xFC, 0x18, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x0F, 0x80, 0x01, 0x83, 0xF8, 0x00, 0x20,
  0xC1, 0x80, 0x0C, 0x30, 0x10, 0x01, 0x06, 0x03, 0x00, 0x60, 0x80, 0x60,
  0x08, 0x10, 0x04, 0x03, 0x06, 0x00, 0x80, 0xC0, 0xC0, 0x10, 0x18, 0x18,
  0x02, 0x06, 0x01, 0x00, 0x40, 0xC0, 0x20, 0x18, 0x30, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x30, 0x00, 0x60, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0x86, 0x00, 0x01, 0x98, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x33, 0x00, 0x00, 0xC7, 0x00, 0x03, 0x86,
  0x00, 0xC6, 0x06, 0x01, 0x98, 0x06, 0x03, 0x30, 0x0E, 0x04, 0xC0, 0x0C,
  0x19, 0x80, 0x0C, 0x33, 0x00, 0x0C, 0x66, 0x00, 0x1D, 0x8C, 0x00, 0x1B,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x78, 0x70, 0x01, 0xB0,
  0x70, 0x0E, 0x30, 0x78, 0x78, 0x30, 0x7F, 0xE0, 0x70, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x2E, 0x06, 0x0F, 0x7C, 0x67, 0xC0,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x19, 0x80,
  0x03, 0x0C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03,
  0x80, 0x80, 0x10, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x33, 0x33, 0x33, 0x37, 0x6E, 0x40, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x38, 0x0C, 0x01, 0x83, 0x00,
  0x38, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x1C, 0x18, 0x03, 0x01, 0x81, 0xC0, 0x1F, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x9F, 0x3F, 0x07, 0x80, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70, 0x38,
  0x1C, 0x01, 0x87, 0x00, 0x38, 0xC0, 0x03, 0x10, 0x00, 0x66, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x70, 0x1C, 0x1C, 0x01, 0x87, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x33, 0x80, 0x0E, 0x38,
  0x01, 0x83, 0x80, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x66, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0xFC, 0x06, 0xFF, 0xC1, 0xE0, 0x38,
  0x70, 0x07, 0x08, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x18, 0xC0, 0x06,
  0x38, 0x03, 0x07, 0x01, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1E, 0x00,
  0x1F, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x1F, 0x80, 0x8F, 0xFC, 0x13, 0x81, 0xC6, 0xC0, 0x1C, 0xF0,
  0x01, 0x9C, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0xC0,
  0x0C, 0x18, 0x03, 0x81, 0xC0, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x3C,
  0x1C, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x32, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0x60, 0x03, 0x0E, 0x00, 0xE0, 0xE0, 0x38, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x70, 0x3C, 0x1C, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x33, 0x00, 0x06, 0x30, 0x01, 0x87,
  0x80, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x70, 0x38, 0x1C, 0x03, 0x83, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x66,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x28,
  0x00, 0x05, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1D, 0x80, 0x07, 0xB8, 0x01, 0xA3, 0x00, 0x64, 0x38, 0x1D, 0x83,
  0xFE, 0x30, 0x1F, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xEF, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xF6, 0x73, 0xCC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC6, 0x31, 0x8C, 0x63, 0x31, 0x98, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xF8, 0x18, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x7C,
  0x00, 0x43, 0x00, 0x1F, 0xE0, 0x0C, 0x60, 0x0E, 0x0E, 0x01, 0x98, 0x01,
  0x80, 0xC0, 0x13, 0x00, 0x60, 0x18, 0x02, 0x60, 0x18, 0x03, 0x00, 0x48,
  0x03, 0x00, 0x60, 0x09, 0x00, 0x40, 0x0C, 0x01, 0x60, 0x18, 0x01, 0x80,
  0x3C, 0x03, 0x00, 0x30, 0x07, 0x80, 0x60, 0x06, 0x00, 0xF0, 0x08, 0x00,
  0x80, 0x1E, 0x01, 0x00, 0x10, 0x02, 0xC0, 0x60, 0x02, 0x00, 0x58, 0x0C,
  0x00, 0x40, 0x0B, 0x01, 0x80, 0x18, 0x03, 0x60, 0x30, 0x03, 0x00, 0x6C,
  0x06, 0x00, 0x60, 0x0D, 0x80, 0x40, 0x1C, 0x01, 0x10, 0x0C, 0x03, 0x80,
  0x62, 0x01, 0x80, 0xD0, 0x08, 0x60, 0x38, 0x33, 0x03, 0x0C, 0x03, 0x8C,
  0x31, 0xC1, 0x80, 0x3F, 0x07, 0xF0, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30,
  0xFF, 0xF0, 0x1F, 0xFF, 0x82, 0x00, 0x3C, 0x40, 0x01, 0xC8, 0x00, 0x19,
  0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x1A,
  0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x03, 0x20, 0x00, 0xC4,
  0x00, 0x78, 0xFF, 0xFC, 0x1F, 0xFF, 0xC2, 0x00, 0x1C, 0x40, 0x00, 0xC8,
  0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x06, 0x80, 0x01, 0x90, 0x00, 0xF3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0xB8, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x67, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x38, 0x07, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x20, 0x03,
  0xC1, 0x00, 0x07, 0x08, 0x00, 0x1C, 0x40, 0x00, 0x72, 0x00, 0x01, 0x90,
  0x00, 0x0E, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x07, 0x40, 0x00, 0x32,
  0x00, 0x03, 0x90, 0x00, 0x38, 0x80, 0x03, 0x84, 0x00, 0x78, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC8, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF2, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xC0, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCE,
  0x00, 0x03, 0x1C, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x3F,
  0xC0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x19, 0x80,
  0x0E, 0x30, 0x03, 0x07, 0x03, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x80, 0x00,
  0x32, 0x00, 0x01, 0x88, 0x00, 0x0E, 0x20, 0x00, 0x70, 0x80, 0x03, 0x82,
  0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x03, 0x00, 0x80, 0x1C, 0x02, 0x00,
  0xE0, 0x08, 0x07, 0x00, 0x20, 0x18, 0x00, 0x80, 0xC0, 0x02, 0x06, 0x00,
  0x08, 0x38, 0x00, 0x21, 0xC0, 0x00, 0x8F, 0x00, 0x02, 0x3C, 0x00, 0x09,
  0x98, 0x00, 0x2C, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x20, 0x0E, 0x00, 0x80, 0x18, 0x02, 0x00, 0x30, 0x08, 0x00, 0xE0,
  0x20, 0x01, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x06, 0x08, 0x00, 0x1C, 0x20,
  0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x01, 0xC8, 0x00, 0x03, 0xA0, 0x00,
  0x06, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x0D,
  0xD8, 0x00, 0x00, 0x6E, 0x40, 0x00, 0x03, 0x73, 0x00, 0x00, 0x33, 0x98,
  0x00, 0x01, 0x9C, 0x60, 0x00, 0x08, 0xE3, 0x00, 0x00, 0xC7, 0x18, 0x00,
  0x06, 0x38, 0x60, 0x00, 0x61, 0xC3, 0x00, 0x03, 0x0E, 0x18, 0x00, 0x18,
  0x70, 0x60, 0x01, 0x83, 0x83, 0x00, 0x0C, 0x1C, 0x08, 0x00, 0x60, 0xE0,
  0x60, 0x06, 0x07, 0x03, 0x00, 0x30, 0x38, 0x0C, 0x01, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x0C, 0x03, 0x80, 0x60, 0x60,
  0x1C, 0x03, 0x03, 0x00, 0xE0, 0x0C, 0x30, 0x07, 0x00, 0x61, 0x80, 0x38,
  0x01, 0x0C, 0x01, 0xC0, 0x0C, 0xC0, 0x0E, 0x00, 0x66, 0x00, 0x70, 0x01,
  0xA0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80, 0x00,
  0xE3, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x70, 0x00, 0xE0,
  0xC0, 0x03, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x03,
  0x80, 0x18, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xE0, 0x01, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x00,
  0xCE, 0x00, 0x03, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07,
  0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x80, 0x07, 0x88, 0x00, 0x1C, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80,
  0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06,
  0x80, 0x00, 0xC8, 0x00, 0x1C, 0x80, 0x07, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00,
  0x00, 0xE6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x0E, 0x01, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x38, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x70, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x00, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x01, 0xCE, 0x00,
  0x06, 0x1C, 0x00, 0x30, 0x3C, 0x03, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xF0,
  0x0E, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x36, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x66, 0x00,
  0x09, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C,
  0x30, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x10, 0x80, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x81, 0x80,
  0x20, 0x40, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x18, 0x06, 0x06, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60,
  0x80, 0x10, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x08, 0x40, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32,
  0x00, 0x04, 0xC0, 0x01, 0x60, 0x00, 0x58, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x71, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x18, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x36, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x9C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xFE, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x01, 0xA0, 0x06, 0xC0, 0x13, 0x00, 0xC4, 0x03, 0x18, 0x08,
  0x60, 0x60, 0x81, 0x83, 0x0C, 0x0C, 0x30, 0x10, 0xC0, 0x66, 0x01, 0x98,
  0x02, 0x60, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0xE0,
  0xC0, 0xC0, 0xC1, 0x81, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0x80, 0xE1,
  0xC0, 0x0C, 0x60, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0x80, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1A,
  0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x7B, 0x80, 0x36, 0x70,
  0x39, 0x8F, 0xFC, 0x60, 0xFC, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x0F, 0xC0, 0xCF, 0xFC, 0x37,
  0x03, 0x8F, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB8, 0x00, 0xCF, 0x00,
  0x73, 0x60, 0x38, 0xCF, 0xFC, 0x30, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x70, 0x1C, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x30, 0xC0, 0x0C, 0x1C, 0x07, 0x00, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x0F, 0xC3, 0x0F, 0xFC, 0xCF, 0x03, 0xB3, 0x00, 0x2D, 0x80,
  0x07, 0x60, 0x01, 0xD8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0xD8, 0x00, 0x73, 0x00, 0x3C, 0x70, 0x3B, 0x0F, 0xFC,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0C, 0x00,
  0xC3, 0x00, 0x1C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC1,
  0xE2, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x0F, 0xFE, 0x7F, 0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x07, 0xF0, 0xC3, 0xFF, 0x33, 0xC0, 0xEC, 0xC0, 0x0B, 0x60, 0x01, 0xD8,
  0x00, 0x76, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x76, 0x00, 0x1C, 0xC0, 0x0F, 0x1C, 0x0E, 0xC3, 0xFF, 0x30, 0x7F,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x20, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0x70, 0x3F, 0xF8, 0x03, 0xF0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x3E, 0x0C, 0x7F, 0xC6, 0x60, 0x73, 0x60, 0x1D, 0xE0, 0x06, 0xE0, 0x03,
  0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C, 0xDF, 0x00, 0x00,
  0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x03,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0xE7, 0xE3, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0xEC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x61,
  0x80, 0x60, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x70, 0x18, 0x70, 0x0C, 0x70,
  0x06, 0x30, 0x03, 0x30, 0x01, 0xBC, 0x00, 0xF7, 0x00, 0x71, 0x80, 0x30,
  0x60, 0x18, 0x38, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x70,
  0xC0, 0x18, 0x60, 0x06, 0x30, 0x03, 0x98, 0x00, 0xCC, 0x00, 0x36, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1,
  0xF0, 0x07, 0xE0, 0xC7, 0xFC, 0x1F, 0xF8, 0xCC, 0x0E, 0x38, 0x1C, 0xD8,
  0x07, 0x70, 0x0E, 0xF0, 0x03, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x06, 0xE0,
  0x01, 0x80, 0x02, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC1,
  0xF0, 0x63, 0xFE, 0x33, 0x03, 0x9B, 0x00, 0xEF, 0x00, 0x37, 0x00, 0x1B,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x01, 0x98,
  0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x26, 0x00, 0x0C, 0xC0,
  0x01, 0x9C, 0x00, 0x61, 0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0xC3, 0xF0, 0x33, 0xFF, 0x0D, 0x80, 0xE3, 0xC0, 0x1C, 0xE0,
  0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6E, 0x00, 0x33, 0xC0, 0x1C, 0xD8, 0x0E, 0x33, 0xFF,
  0x0C, 0x3F, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0xC3, 0xFF, 0x33, 0xC0, 0xEC, 0xC0, 0x0F, 0x60,
  0x01, 0xD8, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x1C, 0xC0, 0x0F, 0x1C, 0x0E, 0xC3, 0xFF,
  0x30, 0x7F, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0xC3, 0xF3, 0xFD, 0xC3, 0x60, 0xF0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8C, 0x00, 0xC6, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00,
  0x0C, 0xC0, 0x0E, 0x78, 0x0E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFE, 0xFF, 0xE0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0xF0,
  0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1D,
  0x80, 0x1E, 0xE0, 0x1B, 0x38, 0x1D, 0x8F, 0xFC, 0xC3, 0xF8, 0x00, 0x40,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x19,
  0x80, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xD8,
  0x01, 0xC0, 0x06, 0xC0, 0x0E, 0x00, 0x66, 0x00, 0x58, 0x03, 0x30, 0x06,
  0xC0, 0x18, 0xC0, 0x36, 0x00, 0xC6, 0x01, 0x98, 0x06, 0x30, 0x08, 0xC0,
  0x61, 0x80, 0xC6, 0x03, 0x06, 0x06, 0x30, 0x18, 0x30, 0x30, 0xC0, 0xC1,
  0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x20, 0xC0, 0x83, 0x01, 0x84,
  0x06, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x01, 0x8C, 0x01, 0x18, 0x04,
  0x60, 0x0C, 0x80, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x03, 0x60, 0x0D, 0x80,
  0x0B, 0x00, 0x2C, 0x00, 0x50, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x98, 0x00, 0x67, 0x00,
  0x30, 0xC0, 0x1C, 0x18, 0x06, 0x06, 0x03, 0x80, 0xC0, 0xC0, 0x38, 0x60,
  0x06, 0x18, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x61,
  0x80, 0x30, 0x30, 0x1C, 0x0C, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x0C,
  0x60, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x04, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x01, 0x20, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x10, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x38, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x0D, 0x83, 0x80, 0x1B, 0x03, 0x80, 0x3C, 0x03, 0x00, 0xD8,
  0x03, 0x01, 0xB0, 0x03, 0x86, 0x40, 0x03, 0xFC, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 36, 10, 4, -36 },
  { 15, 7, 11, 14, 4, -38 },
  { 25, 23, 36, 25, 2, -36 },
  { 129, 19, 46, 25, 3, -41 },
  { 239, 27, 36, 33, 3, -36 },
  { 361, 23, 37, 27, 3, -36 },
  { 468, 2, 11, 9, 3, -38 },
  { 471, 10, 52, 14, 3, -40 },
  { 536, 10, 52, 15, 1, -40 },
  { 601, 20, 20, 21, 1, -36 },
  { 651, 21, 26, 25, 2, -30 },
  { 720, 4, 11, 10, 2, -4 },
  { 726, 10, 2, 14, 2, -17 },
  { 729, 3, 3, 11, 4, -3 },
  { 731, 15, 39, 18, 1, -36 },
  { 805, 19, 36, 25, 3, -36 },
  { 891, 11, 36, 25, 4, -36 },
  { 941, 19, 36, 25, 3, -36 },
  { 1027, 19, 36, 25, 3, -36 },
  { 1113, 22, 36, 25, 2, -36 },
  { 1212, 18, 36, 25, 4, -36 },
  { 1293, 19, 36, 25, 3, -36 },
  { 1379, 20, 36, 25, 2, -36 },
  { 1469, 19, 36, 25, 3, -36 },
  { 1555, 19, 36, 25, 3, -36 },
  { 1641, 4, 26, 9, 3, -26 },
  { 1654, 5, 33, 9, 2, -26 },
  { 1675, 18, 21, 23, 2, -27 },
  { 1723, 17, 12, 25, 4, -23 },
  { 1749, 18, 21, 23, 3, -27 },
  { 1797, 16, 36, 20, 2, -36 },
  { 1869, 35, 46, 41, 3, -35 },
  { 2071, 25, 36, 27, 1, -36 },
  { 2184, 19, 36, 27, 5, -36 },
  { 2270, 22, 36, 29, 4, -36 },
  { 2369, 21, 36, 29, 5, -36 },
  { 2464, 18, 36, 26, 5, -36 },
  { 2545, 18, 36, 25, 5, -36 },
  { 2626, 22, 36, 31, 4, -36 },
  { 2725, 22, 36, 31, 5, -36 },
  { 2824, 2, 36, 12, 5, -36 },
  { 2833, 18, 36, 25, 2, -36 },
  { 2914, 22, 36, 28, 5, -36 },
  { 3013, 17, 36, 23, 5, -36 },
  { 3090, 29, 36, 38, 5, -36 },
  { 3221, 22, 36, 32, 5, -36 },
  { 3320, 24, 36, 30, 3, -36 },
  { 3428, 20, 36, 27, 5, -36 },
  { 3518, 23, 43, 30, 3, -36 },
  { 3642, 22, 36, 29, 4, -36 },
  { 3741, 22, 36, 26, 2, -36 },
  { 3840, 23, 36, 27, 2, -36 },
  { 3944, 21, 36, 29, 4, -36 },
  { 4039, 25, 36, 27, 1, -36 },
  { 4152, 36, 36, 40, 2, -36 },
  { 4314, 23, 36, 27, 2, -36 },
  { 4418, 25, 36, 27, 1, -36 },
  { 4531, 22, 36, 27, 2, -36 },
  { 4630, 7, 49, 11, 4, -41 },
  { 4673, 14, 39, 18, 2, -36 },
  { 4742, 7, 49, 11, 0, -41 },
  { 4785, 14, 18, 19, 2, -36 },
  { 4817, 19, 2, 19, 0, 0 },
  { 4822, 7, 7, 14, 3, -39 },
  { 4829, 18, 27, 24, 3, -27 },
  { 4890, 18, 38, 25, 4, -38 },
  { 4976, 19, 27, 23, 2, -27 },
  { 5041, 18, 38, 25, 3, -38 },
  { 5127, 19, 27, 23, 2, -27 },
  { 5192, 13, 39, 15, 2, -39 },
  { 5256, 18, 37, 25, 3, -27 },
  { 5340, 17, 38, 25, 4, -38 },
  { 5421, 3, 37, 10, 4, -37 },
  { 5435, 9, 47, 11, -2, -37 },
  { 5488, 17, 38, 22, 4, -38 },
  { 5569, 2, 38, 10, 4, -38 },
  { 5579, 32, 27, 39, 4, -27 },
  { 5687, 17, 27, 25, 4, -27 },
  { 5745, 19, 27, 25, 3, -27 },
  { 5810, 18, 37, 25, 4, -27 },
  { 5894, 18, 37, 25, 3, -27 },
  { 5978, 10, 27, 15, 4, -27 },
  { 6012, 17, 27, 23, 3, -27 },
  { 6070, 12, 34, 15, 1, -34 },
  { 6121, 17, 27, 25, 4, -27 },
  { 6179, 19, 27, 22, 1, -27 },
  { 6244, 29, 27, 34, 2, -27 },
  { 6342, 18, 27, 22, 2, -27 },
  { 6403, 19, 37, 21, 1, -27 },
  { 6491, 18, 27, 22, 2, -27 },
  { 6552, 12, 51, 15, 2, -40 },
  { 6629, 2, 43, 11, 4, -36 },
  { 6640, 12, 51, 15, 1, -40 },
  { 6717, 23, 9, 31, 4, -20 },
};

const GFXfont RobotoCondensed_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT51PT7B_H_
