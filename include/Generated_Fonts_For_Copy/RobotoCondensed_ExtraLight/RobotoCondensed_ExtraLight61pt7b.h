#ifndef _ROBOTOCONDENSED_EXTRALIGHT61PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x70, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x38, 0x07,
  0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xE6,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00,
  0x39, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0x80, 0x60,
  0x06, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x0C,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0x30, 0x30, 0x00,
  0xC0, 0x18, 0x38, 0x00, 0x70, 0x18, 0x18, 0x00, 0x1C, 0x1C, 0x1C, 0x00,
  0x07, 0xFC, 0x0C, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x00, 0xC0,
  0xFF, 0x80, 0x00, 0xC0, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x30, 0x00, 0x60,
  0x60, 0x18, 0x00, 0x70, 0x60, 0x06, 0x00, 0x30, 0x30, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x60, 0x06, 0x01, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x0E,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x0E, 0x18,
  0x0E, 0x00, 0xC3, 0x80, 0x70, 0x0C, 0x70, 0x03, 0x80, 0xC6, 0x00, 0x18,
  0x0C, 0x60, 0x01, 0xC0, 0xCE, 0x00, 0x0E, 0x0C, 0xE0, 0x00, 0x71, 0xCE,
  0x00, 0x03, 0x18, 0xE0, 0x00, 0x3B, 0x8E, 0x00, 0x01, 0xF0, 0x60, 0x00,
  0x0F, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xF8,
  0x38, 0x00, 0x39, 0xC1, 0xE0, 0x0F, 0x0C, 0x0F, 0xEF, 0xC0, 0xE0, 0x3F,
  0xF8, 0x07, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x40, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x18, 0x07, 0xFC, 0x18, 0x3F, 0x3F, 0x18,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0x81,
  0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0C, 0x00,
  0x38, 0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x1C, 0x71, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xC7, 0x18, 0x40, 0xFF, 0xFF,
  0xFF, 0x7F, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0xF0,
  0x1C, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x39, 0xC0, 0x00, 0xC3, 0x00, 0x07,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x0F, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0x73,
  0xE3, 0xFC, 0x1F, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x30, 0x30, 0x00, 0x38,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x78, 0x07, 0x01, 0xE0, 0x07, 0x03, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x18,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x76, 0x00,
  0x00, 0xCE, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C,
  0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x31, 0xFC, 0x01, 0xDF, 0xFC, 0x07, 0xF0,
  0x7C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x0E,
  0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x1F, 0x80, 0xE3, 0xFF, 0x83, 0x1E, 0x0F, 0x0C,
  0xE0, 0x0E, 0x36, 0x00, 0x1C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x01, 0xD8, 0x00,
  0x06, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0x80, 0x07, 0x07, 0x00, 0x38,
  0x0F, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x18,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60,
  0x00, 0x0C, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x83, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x70, 0x18,
  0x00, 0x38, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0,
  0x0E, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x98, 0x00, 0x0F, 0x38, 0x00, 0x3E, 0x38,
  0x00, 0xDC, 0x38, 0x03, 0x30, 0x7C, 0x3C, 0x60, 0x3F, 0xF0, 0xC0, 0x1F,
  0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x38, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0x61, 0x86, 0x18, 0xE3,
  0x8C, 0x73, 0x84, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x1C, 0x38,
  0x03, 0x9C, 0x00, 0x66, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0xFC, 0x00, 0x10, 0xE0, 0x01, 0xFF, 0x00,
  0x0C, 0x60, 0x01, 0xE1, 0xE0, 0x06, 0x30, 0x01, 0xC0, 0x30, 0x03, 0x30,
  0x00, 0xC0, 0x18, 0x01, 0x98, 0x00, 0xC0, 0x0C, 0x00, 0x6C, 0x00, 0xE0,
  0x06, 0x00, 0x36, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0x60, 0x03, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0xF0, 0x06, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0x00, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x03, 0x00,
  0x1E, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x60, 0x01, 0x80, 0x07, 0x80,
  0x30, 0x00, 0xC0, 0x06, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x60, 0x0C, 0x00,
  0x30, 0x01, 0xB0, 0x06, 0x00, 0x18, 0x00, 0xD8, 0x03, 0x00, 0x1C, 0x00,
  0xCC, 0x01, 0x80, 0x0E, 0x00, 0x66, 0x00, 0x60, 0x0F, 0x00, 0x63, 0x80,
  0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x1C, 0x0E, 0x70, 0x30, 0x60, 0x07, 0x9E,
  0x1C, 0x70, 0x30, 0x01, 0xFC, 0x07, 0xF0, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xE0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x38, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x18, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x0E, 0x00, 0x3E, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x1F, 0x00,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0x30, 0x00, 0x39, 0xC0, 0x03, 0x87, 0x00, 0x3C, 0x1C, 0x03,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3E, 0x00, 0x01, 0xCE, 0xC0, 0x00, 0x3B,
  0x9C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x1E, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x06, 0xFB, 0x00, 0x00, 0x00, 0xDF, 0x60,
  0x00, 0x00, 0x3B, 0xEE, 0x00, 0x00, 0x06, 0x7C, 0xC0, 0x00, 0x00, 0xCF,
  0x98, 0x00, 0x00, 0x31, 0xF3, 0x80, 0x00, 0x06, 0x3E, 0x30, 0x00, 0x01,
  0xC7, 0xC6, 0x00, 0x00, 0x30, 0xF8, 0xE0, 0x00, 0x06, 0x1F, 0x0C, 0x00,
  0x01, 0xC3, 0xE1, 0x80, 0x00, 0x30, 0x7C, 0x18, 0x00, 0x06, 0x0F, 0x83,
  0x00, 0x01, 0xC1, 0xF0, 0x70, 0x00, 0x30, 0x3E, 0x06, 0x00, 0x06, 0x07,
  0xC0, 0xC0, 0x01, 0x80, 0xF8, 0x1C, 0x00, 0x30, 0x1F, 0x01, 0x80, 0x0E,
  0x03, 0xE0, 0x30, 0x01, 0x80, 0x7C, 0x07, 0x00, 0x30, 0x0F, 0x80, 0x60,
  0x0E, 0x01, 0xF0, 0x0C, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x30, 0x07, 0xC0,
  0x18, 0x0E, 0x00, 0xF8, 0x03, 0x81, 0x80, 0x1F, 0x00, 0x30, 0x30, 0x03,
  0xE0, 0x06, 0x0C, 0x00, 0x7C, 0x00, 0xE1, 0x80, 0x0F, 0x80, 0x0C, 0x30,
  0x01, 0xF0, 0x01, 0x8C, 0x00, 0x3E, 0x00, 0x19, 0x80, 0x07, 0xC0, 0x03,
  0x70, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFB, 0x00, 0x00,
  0x1F, 0x30, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x7C, 0x60, 0x00, 0x0F, 0x8E,
  0x00, 0x01, 0xF0, 0xC0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00,
  0xF8, 0x18, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xE0, 0x30, 0x00, 0x7C, 0x07,
  0x00, 0x0F, 0x80, 0x60, 0x01, 0xF0, 0x0E, 0x00, 0x3E, 0x00, 0xE0, 0x07,
  0xC0, 0x0C, 0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x18, 0x03, 0xE0, 0x03,
  0x80, 0x7C, 0x00, 0x30, 0x0F, 0x80, 0x07, 0x01, 0xF0, 0x00, 0x70, 0x3E,
  0x00, 0x06, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00, 0x0C, 0x1F, 0x00, 0x01,
  0xC3, 0xE0, 0x00, 0x18, 0x7C, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x39, 0xF0,
  0x00, 0x03, 0x3E, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x06, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x38,
  0x00, 0x7C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0xE3, 0x80, 0x07, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x0E, 0x00, 0x1F, 0x03, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x0C, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x0C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x18, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x06, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x7C,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0x30, 0x00, 0x19, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60,
  0x60, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x70,
  0x18, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x30, 0x00,
  0xC1, 0x80, 0x03, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80,
  0x01, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0E,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0x80,
  0x78, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0E,
  0x60, 0x00, 0x39, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFE, 0x07, 0xFF,
  0xF8, 0x7C, 0x00, 0x63, 0xC0, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0x60, 0x00, 0xD9, 0xC0, 0x06,
  0x63, 0x80, 0x71, 0x87, 0xFF, 0x86, 0x0F, 0xFC, 0x18, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x0F, 0xF8, 0x18, 0xFF, 0xF0, 0xCC, 0x03, 0xC6, 0xC0, 0x07, 0x3C,
  0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xE0, 0x00, 0x77,
  0x80, 0x03, 0x3E, 0x00, 0x39, 0xB8, 0x07, 0x8C, 0xFF, 0xF8, 0x61, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x30,
  0x70, 0x01, 0xC1, 0xE0, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x3F, 0xE0, 0xC1, 0xFF, 0xE3, 0x0E, 0x01,
  0xCC, 0x70, 0x01, 0xB3, 0x80, 0x02, 0xCC, 0x00, 0x0F, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x76, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x37, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0xF1, 0xC0, 0x06,
  0xC3, 0x80, 0x73, 0x07, 0xFF, 0x8C, 0x0F, 0xFC, 0x30, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0x80, 0x78, 0x1C,
  0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x60, 0x00,
  0x1B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x10, 0x70, 0x00, 0xE0, 0xF0,
  0x0F, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0x01, 0xF2, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x30, 0x7F, 0xF8, 0xC3, 0x80, 0x73, 0x1C, 0x00, 0x6C, 0xE0, 0x00,
  0xB3, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00,
  0x07, 0x38, 0x00, 0x3C, 0x70, 0x01, 0xB0, 0xE0, 0x1C, 0xC1, 0xFF, 0xE3,
  0x03, 0xFF, 0x0C, 0x00, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x84, 0x00, 0x0E, 0x38, 0x00,
  0x30, 0x70, 0x01, 0xC0, 0xF8, 0x3E, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1,
  0xFF, 0x0C, 0x3F, 0xF8, 0xCE, 0x03, 0xCC, 0xC0, 0x0C, 0xD8, 0x00, 0xEF,
  0x00, 0x06, 0xF0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x6F, 0xF6, 0x00, 0x00, 0x00,
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x07, 0x03,
  0xCF, 0xE3, 0xE0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x70,
  0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x70,
  0x0C, 0x0E, 0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C, 0xE0,
  0x00, 0xCF, 0x00, 0x0D, 0xB8, 0x00, 0xF1, 0x80, 0x0E, 0x1C, 0x00, 0xC0,
  0xE0, 0x0C, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x38,
  0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0x8F, 0xFF, 0x03, 0xFF,
  0xC7, 0x38, 0x0F, 0x0E, 0x03, 0xCE, 0xE0, 0x0E, 0x30, 0x03, 0x9D, 0x80,
  0x0E, 0xC0, 0x03, 0xBE, 0x00, 0x0D, 0x80, 0x03, 0x78, 0x00, 0x1E, 0x00,
  0x06, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x1F, 0xF0, 0xC3, 0xFF, 0x8C, 0xE0,
  0x3C, 0xCC, 0x00, 0xCD, 0x80, 0x0E, 0xF0, 0x00, 0x6F, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78,
  0x07, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x07, 0x18, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0xE1, 0x80,
  0x03, 0x83, 0x80, 0x0E, 0x03, 0xC0, 0x38, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x1F, 0xF0, 0x31, 0xFF, 0xE1,
  0xB8, 0x07, 0x8D, 0x80, 0x0E, 0x78, 0x00, 0x33, 0x80, 0x01, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0xC0, 0x00, 0xEF, 0x00, 0x06, 0x7C, 0x00, 0x73, 0x70,
  0x0F, 0x19, 0xFF, 0xF0, 0xC3, 0xFE, 0x06, 0x01, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x30, 0x7F, 0xF8, 0xC3,
  0x80, 0x73, 0x1C, 0x00, 0x6C, 0xE0, 0x00, 0xF3, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x38, 0x00, 0x3C, 0x70,
  0x01, 0xB0, 0xE0, 0x1C, 0xC1, 0xFF, 0xE3, 0x03, 0xFF, 0x0C, 0x00, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x3F, 0xC7, 0xFC,
  0xE0, 0xD8, 0x0D, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xC0, 0x3C, 0x38, 0x00, 0xE7, 0x00, 0x06,
  0x60, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x73, 0x80, 0x0E,
  0x3C, 0x01, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xF6, 0x00, 0x1B, 0x70, 0x03,
  0xB3, 0x80, 0x73, 0x1F, 0xFE, 0x30, 0xFF, 0x83, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0x19, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x70,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x1C, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x00, 0x0D,
  0x80, 0x03, 0xC0, 0x03, 0xB8, 0x00, 0x78, 0x00, 0x73, 0x00, 0x0F, 0x00,
  0x0C, 0x60, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x6E, 0x00, 0x71, 0xC0, 0x0C,
  0xC0, 0x0E, 0x38, 0x01, 0x98, 0x01, 0x83, 0x00, 0x63, 0x80, 0x30, 0x60,
  0x0C, 0x30, 0x06, 0x0E, 0x01, 0x86, 0x01, 0xC1, 0xC0, 0x30, 0xC0, 0x30,
  0x18, 0x0C, 0x1C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x70, 0x30, 0x30,
  0x38, 0x0E, 0x0E, 0x06, 0x06, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x18, 0x30,
  0x0C, 0x18, 0x03, 0x86, 0x01, 0x87, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x06,
  0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x1C, 0xC0, 0x0C, 0xE0,
  0x03, 0xB0, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x19, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x30, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x07, 0x03, 0x80,
  0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0xC0, 0x00, 0x73, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x1C, 0x00,
  0x30, 0x30, 0x01, 0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0x30, 0x03, 0x01, 0xC0,
  0x0E, 0x06, 0x00, 0x18, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x01,
  0xB8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xD8,
  0x00, 0x06, 0x60, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x38, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06, 0x07, 0x00, 0x38,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x06,
  0x01, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x87,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x3C, 0x78, 0x00,
  0x33, 0x01, 0xC0, 0x03, 0x70, 0x0E, 0x00, 0x76, 0x00, 0x70, 0x06, 0x60,
  0x03, 0x80, 0xEE, 0x00, 0x1E, 0x1C, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF0,
};

const GFXglyph RobotoCondensed_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 44, 12, 4, -43 },
  { 23, 9, 13, 16, 4, -46 },
  { 38, 28, 43, 30, 2, -43 },
  { 189, 22, 57, 30, 4, -50 },
  { 346, 33, 45, 39, 3, -44 },
  { 532, 28, 45, 33, 3, -44 },
  { 690, 2, 13, 10, 4, -46 },
  { 694, 12, 62, 17, 4, -48 },
  { 787, 12, 62, 17, 1, -48 },
  { 880, 24, 24, 26, 1, -43 },
  { 952, 26, 32, 30, 2, -36 },
  { 1056, 6, 13, 12, 2, -5 },
  { 1066, 12, 2, 16, 2, -21 },
  { 1069, 4, 4, 14, 4, -3 },
  { 1071, 18, 47, 21, 1, -43 },
  { 1177, 22, 45, 30, 4, -44 },
  { 1301, 13, 43, 30, 5, -43 },
  { 1371, 24, 44, 30, 3, -44 },
  { 1503, 23, 45, 30, 3, -44 },
  { 1633, 26, 43, 30, 2, -43 },
  { 1773, 22, 44, 30, 5, -43 },
  { 1894, 22, 44, 30, 4, -43 },
  { 2015, 24, 43, 30, 2, -43 },
  { 2144, 24, 45, 30, 3, -44 },
  { 2279, 23, 44, 30, 3, -44 },
  { 2406, 4, 32, 11, 4, -31 },
  { 2422, 6, 39, 11, 2, -31 },
  { 2452, 21, 25, 28, 3, -32 },
  { 2518, 21, 14, 30, 4, -27 },
  { 2555, 21, 24, 28, 4, -32 },
  { 2618, 18, 45, 24, 3, -44 },
  { 2720, 41, 56, 49, 4, -42 },
  { 3007, 30, 43, 33, 1, -43 },
  { 3169, 24, 43, 33, 5, -43 },
  { 3298, 27, 45, 35, 4, -44 },
  { 3450, 26, 43, 35, 5, -43 },
  { 3590, 23, 43, 31, 5, -43 },
  { 3714, 23, 43, 30, 5, -43 },
  { 3838, 27, 45, 36, 5, -44 },
  { 3990, 27, 43, 37, 5, -43 },
  { 4136, 3, 43, 15, 6, -43 },
  { 4153, 21, 44, 30, 3, -43 },
  { 4269, 27, 43, 34, 5, -43 },
  { 4415, 21, 43, 28, 5, -43 },
  { 4528, 35, 43, 46, 5, -43 },
  { 4717, 27, 43, 38, 5, -43 },
  { 4863, 28, 45, 36, 4, -44 },
  { 5021, 25, 43, 33, 5, -43 },
  { 5156, 28, 52, 36, 4, -44 },
  { 5338, 26, 43, 34, 5, -43 },
  { 5478, 26, 45, 32, 3, -44 },
  { 5625, 28, 43, 32, 2, -43 },
  { 5776, 25, 44, 35, 5, -43 },
  { 5914, 30, 43, 33, 1, -43 },
  { 6076, 44, 43, 48, 2, -43 },
  { 6313, 28, 43, 32, 2, -43 },
  { 6464, 30, 43, 32, 1, -43 },
  { 6626, 26, 43, 32, 3, -43 },
  { 6766, 8, 59, 13, 5, -50 },
  { 6825, 17, 47, 21, 2, -43 },
  { 6925, 8, 59, 13, 0, -50 },
  { 6984, 17, 22, 23, 3, -43 },
  { 7031, 21, 2, 23, 1, 0 },
  { 7037, 9, 8, 17, 4, -46 },
  { 7046, 22, 34, 29, 3, -33 },
  { 7140, 21, 47, 30, 5, -46 },
  { 7264, 22, 34, 28, 3, -33 },
  { 7358, 22, 47, 30, 3, -46 },
  { 7488, 22, 34, 28, 3, -33 },
  { 7582, 16, 47, 18, 2, -47 },
  { 7676, 22, 45, 30, 3, -33 },
  { 7800, 20, 46, 29, 5, -46 },
  { 7915, 4, 44, 12, 4, -44 },
  { 7937, 10, 56, 13, -2, -44 },
  { 8007, 20, 46, 26, 5, -46 },
  { 8122, 2, 46, 12, 5, -46 },
  { 8134, 39, 33, 47, 4, -33 },
  { 8295, 20, 33, 29, 5, -33 },
  { 8378, 23, 34, 30, 3, -33 },
  { 8476, 21, 45, 30, 5, -33 },
  { 8595, 22, 45, 30, 3, -33 },
  { 8719, 12, 33, 18, 5, -33 },
  { 8769, 20, 34, 27, 3, -33 },
  { 8854, 14, 42, 18, 1, -41 },
  { 8928, 20, 33, 29, 5, -32 },
  { 9011, 22, 32, 26, 2, -32 },
  { 9099, 35, 32, 40, 2, -32 },
  { 9239, 22, 32, 26, 2, -32 },
  { 9327, 22, 44, 26, 2, -32 },
  { 9448, 21, 32, 26, 3, -32 },
  { 9532, 15, 61, 18, 2, -48 },
  { 9647, 3, 51, 13, 5, -43 },
  { 9667, 15, 61, 18, 1, -48 },
  { 9782, 28, 10, 37, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT61PT7B_H_
