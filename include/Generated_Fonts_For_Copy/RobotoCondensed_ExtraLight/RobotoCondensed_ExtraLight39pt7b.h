#ifndef _ROBOTOCONDENSED_EXTRALIGHT39PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEA, 0xAA, 0x80, 0x0F, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x00, 0x83, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x18, 0x3F, 0xFF, 0xC0, 0xC1, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20, 0xC0, 0x18,
  0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x40, 0x83, 0xFF, 0xFE, 0x04, 0x18,
  0x03, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x83, 0x00, 0x20, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x7E, 0x03, 0xCE, 0x0C, 0x06, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x09, 0x80,
  0x13, 0x00, 0x26, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1A, 0x00, 0x26, 0x00, 0xC6, 0x03,
  0x07, 0x9C, 0x03, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1E, 0x00, 0x01, 0x98, 0x00, 0x10, 0x40, 0x01, 0x83, 0x00, 0x0C, 0x08,
  0x10, 0x40, 0x40, 0x82, 0x02, 0x08, 0x10, 0x10, 0xC0, 0x80, 0x84, 0x06,
  0x0C, 0x60, 0x10, 0x42, 0x00, 0x66, 0x30, 0x01, 0xE1, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x43, 0x30, 0x04, 0x20, 0x80,
  0x23, 0x06, 0x02, 0x10, 0x10, 0x30, 0x80, 0x81, 0x04, 0x04, 0x18, 0x20,
  0x20, 0x81, 0x01, 0x0C, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x03, 0xB8, 0x01, 0x83, 0x00, 0x40, 0x40, 0x30,
  0x10, 0x0C, 0x04, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x60, 0x06, 0x10,
  0x00, 0x98, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xB0, 0x00,
  0xC6, 0x06, 0x20, 0xC1, 0x98, 0x10, 0x64, 0x06, 0x1B, 0x00, 0xC4, 0xC0,
  0x11, 0x30, 0x06, 0xCC, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x0E, 0x0C, 0x06,
  0xC1, 0xCF, 0x18, 0x3F, 0x03, 0x55, 0x5F, 0x02, 0x0C, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x06, 0x04, 0x08, 0x18, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x03, 0x02, 0x06,
  0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x30,
  0x41, 0x82, 0x0C, 0x30, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x18, 0x21, 0xDE, 0x4E, 0x07, 0xF0, 0x03, 0x00, 0x0D, 0x00,
  0x13, 0x00, 0x63, 0x01, 0x83, 0x06, 0x06, 0x08, 0x04, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x33, 0x33, 0x32, 0x64, 0xFF, 0x3C, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x00,
  0x07, 0xC0, 0x3D, 0xC0, 0x40, 0xC1, 0x80, 0xC6, 0x00, 0x8C, 0x01, 0x90,
  0x01, 0x20, 0x02, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x98, 0x03, 0x30, 0x04, 0x30, 0x18, 0x20,
  0x60, 0x79, 0xC0, 0x3E, 0x00, 0x01, 0x07, 0x3D, 0xE1, 0x81, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xC0, 0x39,
  0xE0, 0xC0, 0xE3, 0x00, 0xC4, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0xFF, 0xF0, 0x07, 0xC0, 0x39, 0xE0, 0xC0, 0x63, 0x00, 0x46, 0x00, 0xC8,
  0x00, 0xB0, 0x01, 0x60, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x0E, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x20, 0x02, 0x60,
  0x0C, 0x60, 0x30, 0x71, 0xC0, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02,
  0x10, 0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x10, 0x20, 0x10, 0x60, 0x10, 0xC0, 0x10, 0xC0, 0x10, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x3F, 0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0xFC, 0x1F, 0x38,
  0x60, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0xC0, 0x07, 0x00, 0x34, 0x00, 0xD0, 0x02, 0x60, 0x18, 0xC0,
  0xC1, 0xC6, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x0F,
  0x82, 0x73, 0x85, 0x81, 0x9C, 0x01, 0xB8, 0x01, 0x60, 0x02, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x34, 0x00, 0x68, 0x00, 0xD8, 0x01, 0x30,
  0x06, 0x30, 0x0C, 0x30, 0x30, 0x39, 0xC0, 0x3E, 0x00, 0xFF, 0xFE, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0x39, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xC8,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0xC0, 0x19, 0x80, 0x21, 0x80,
  0xC1, 0xC7, 0x01, 0xFC, 0x06, 0x0C, 0x10, 0x0C, 0x60, 0x0D, 0x80, 0x0B,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x02, 0x60,
  0x0C, 0x60, 0x30, 0x71, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x73, 0x83, 0x03,
  0x18, 0x06, 0x60, 0x09, 0x00, 0x3C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x34, 0x00, 0xD8, 0x07, 0x30,
  0x34, 0x73, 0x90, 0xF8, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x03, 0x80, 0x7C, 0x07, 0x80, 0x0D, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x76, 0x07, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x33, 0x26, 0x64, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x10, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x1F,
  0x03, 0x9C, 0x60, 0x6C, 0x06, 0xC0, 0x28, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x1F, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x0F, 0x80, 0x44,
  0x03, 0x38, 0x08, 0x80, 0xC1, 0x81, 0x30, 0x30, 0x30, 0x24, 0x04, 0x06,
  0x06, 0x80, 0x80, 0xC0, 0xD0, 0x30, 0x10, 0x1A, 0x04, 0x02, 0x03, 0xC0,
  0x80, 0x40, 0x78, 0x10, 0x08, 0x0F, 0x02, 0x01, 0x01, 0xE0, 0xC0, 0x20,
  0x2C, 0x18, 0x04, 0x05, 0x81, 0x01, 0x80, 0x90, 0x20, 0x30, 0x32, 0x04,
  0x0A, 0x04, 0x40, 0xC1, 0x61, 0x88, 0x0C, 0xC6, 0x61, 0x80, 0xF0, 0x78,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x1B, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x18, 0xC0, 0x02, 0x18, 0x00, 0x41, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x40, 0x40, 0x18, 0x08, 0x03, 0x01, 0x80, 0x40, 0x10, 0x18, 0x02, 0x03,
  0x00, 0x60, 0x40, 0x04, 0x0F, 0xFF, 0x83, 0x00, 0x18, 0x40, 0x03, 0x08,
  0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x01, 0xE0,
  0x00, 0x30, 0xFF, 0xC0, 0xC0, 0xF0, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xF0, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x78, 0xFF, 0xE0, 0x07, 0xF0,
  0x0F, 0x1E, 0x0C, 0x03, 0x84, 0x00, 0x46, 0x00, 0x32, 0x00, 0x0B, 0x00,
  0x05, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x09, 0x00, 0x04, 0xC0,
  0x06, 0x20, 0x02, 0x1C, 0x03, 0x07, 0x8F, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x60, 0x78, 0x30, 0x07, 0x18, 0x00, 0x8C, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x0E, 0x30, 0x3C, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x1E,
  0x06, 0x01, 0x86, 0x00, 0x66, 0x00, 0x12, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x30,
  0x01, 0x8C, 0x01, 0x83, 0xC7, 0x80, 0x7F, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xB0, 0x06, 0x40, 0x11, 0x80, 0xC3, 0xDE, 0x03,
  0xE0, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x86,
  0x01, 0x83, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xC0,
  0x18, 0xC0, 0x0C, 0x40, 0x06, 0x70, 0x03, 0x6C, 0x01, 0xE3, 0x00, 0xE1,
  0x80, 0x60, 0x60, 0x30, 0x18, 0x18, 0x04, 0x0C, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x58, 0x00,
  0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFD, 0x00, 0x01, 0xFA, 0x00, 0x02, 0xF6, 0x00, 0x0D, 0xE4, 0x00,
  0x13, 0xC8, 0x00, 0x27, 0x98, 0x00, 0xCF, 0x10, 0x01, 0x1E, 0x30, 0x02,
  0x3C, 0x60, 0x0C, 0x78, 0x40, 0x10, 0xF0, 0xC0, 0x21, 0xE1, 0x80, 0xC3,
  0xC1, 0x01, 0x07, 0x83, 0x06, 0x0F, 0x02, 0x0C, 0x1E, 0x04, 0x10, 0x3C,
  0x0C, 0x60, 0x78, 0x08, 0x80, 0xF0, 0x11, 0x01, 0xE0, 0x36, 0x03, 0xC0,
  0x28, 0x07, 0x80, 0x50, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0x80, 0x30, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xD8, 0x00, 0xF6, 0x00,
  0x3C, 0xC0, 0x0F, 0x10, 0x03, 0xC6, 0x00, 0xF0, 0x80, 0x3C, 0x30, 0x0F,
  0x04, 0x03, 0xC1, 0x80, 0xF0, 0x30, 0x3C, 0x04, 0x0F, 0x01, 0x83, 0xC0,
  0x20, 0xF0, 0x0C, 0x3C, 0x01, 0x0F, 0x00, 0x63, 0xC0, 0x0C, 0xF0, 0x01,
  0x3C, 0x00, 0x6F, 0x00, 0x0B, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0x07, 0xF0, 0x0F, 0x3E, 0x0C, 0x03, 0x8C, 0x00, 0x46, 0x00,
  0x36, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x04, 0xC0, 0x06, 0x60, 0x02, 0x1C, 0x07, 0x07, 0xDF, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0xC0, 0x78, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x78, 0xFF, 0xE0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0x3C, 0x0C, 0x03, 0x8C, 0x00, 0x44, 0x00, 0x36, 0x00, 0x0B, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x04, 0xC0,
  0x06, 0x60, 0x02, 0x18, 0x07, 0x07, 0xDF, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x60,
  0x3C, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x13, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x98, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x63, 0x01, 0xE1, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x31, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x30, 0x07, 0xE0, 0x0F,
  0x1C, 0x0C, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x32, 0x00, 0x19, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x06,
  0x60, 0x03, 0x18, 0x03, 0x07, 0xCF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03,
  0x60, 0x06, 0x30, 0x0E, 0x1E, 0x7C, 0x07, 0xF0, 0xC0, 0x00, 0x78, 0x00,
  0x09, 0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x61, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x00, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x20, 0x06, 0x0C,
  0x00, 0xC1, 0x00, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x31, 0x00, 0x02, 0x20,
  0x00, 0x4C, 0x00, 0x0D, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x34, 0x00, 0x60, 0x03, 0x40, 0x07,
  0x00, 0x36, 0x00, 0x50, 0x02, 0x60, 0x0D, 0x00, 0x22, 0x00, 0xD0, 0x06,
  0x20, 0x09, 0x80, 0x63, 0x00, 0x88, 0x06, 0x30, 0x18, 0x80, 0x43, 0x01,
  0x88, 0x04, 0x10, 0x10, 0xC0, 0xC1, 0x01, 0x04, 0x0C, 0x18, 0x30, 0x40,
  0x81, 0x83, 0x04, 0x08, 0x08, 0x20, 0x61, 0x80, 0x82, 0x06, 0x18, 0x08,
  0x60, 0x21, 0x80, 0xC6, 0x02, 0x10, 0x0C, 0x40, 0x31, 0x00, 0x44, 0x03,
  0x30, 0x04, 0xC0, 0x13, 0x00, 0x6C, 0x01, 0x20, 0x06, 0x80, 0x1A, 0x00,
  0x28, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xD8, 0x00, 0x23, 0x00, 0x18,
  0x40, 0x0C, 0x18, 0x03, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x18, 0x30, 0x06,
  0x08, 0x00, 0xC6, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0xC4, 0x00, 0x21, 0x80,
  0x18, 0x30, 0x04, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x20, 0x60, 0x0C, 0x30,
  0x01, 0x08, 0x00, 0x66, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0x48, 0x00,
  0x19, 0x80, 0x02, 0x10, 0x00, 0xC3, 0x00, 0x10, 0x20, 0x06, 0x06, 0x00,
  0x80, 0x40, 0x30, 0x0C, 0x04, 0x00, 0x81, 0x80, 0x18, 0x20, 0x01, 0x0C,
  0x00, 0x31, 0x00, 0x02, 0x60, 0x00, 0x68, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0xF0, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7C, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x0C, 0x01, 0x80,
  0x38, 0x0D, 0x01, 0x20, 0x26, 0x0C, 0x41, 0x08, 0x21, 0x8C, 0x11, 0x02,
  0x20, 0x6C, 0x05, 0x00, 0x80, 0xFF, 0xFC, 0x60, 0x83, 0x06, 0x0C, 0x0F,
  0xC0, 0x73, 0xC2, 0x01, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x3F, 0xE3, 0xC0, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x1B, 0x00, 0xE4, 0x06, 0x9E, 0xF2, 0x1F, 0x0C,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x8F, 0xC2, 0x73, 0x8A, 0x03, 0x30, 0x06, 0xC0, 0x1A, 0x00,
  0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xA0, 0x02, 0xC0, 0x1B, 0x00, 0x6A, 0x03, 0x27,
  0x38, 0x8F, 0xC0, 0x0F, 0xC0, 0x73, 0xC3, 0x01, 0x18, 0x06, 0x40, 0x0B,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0xF0, 0x03, 0x40, 0x09, 0x80, 0x63, 0x01,
  0x07, 0x3C, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0F, 0xCC, 0x73, 0xB3, 0x01, 0xD8,
  0x07, 0x40, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x40, 0x0D,
  0x80, 0x33, 0x01, 0xC7, 0x39, 0x0F, 0xC4, 0x07, 0xC0, 0x73, 0xC3, 0x03,
  0x18, 0x06, 0x40, 0x0B, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x87, 0xBC, 0x07, 0xE0, 0x03, 0xC1, 0x90, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x86, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0F, 0xC4, 0x73,
  0xB3, 0x03, 0xD8, 0x07, 0x40, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0,
  0x03, 0x40, 0x0D, 0x80, 0x33, 0x01, 0xC7, 0x3B, 0x0F, 0xCC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x80, 0x23, 0x01, 0x87, 0x1C, 0x07, 0xC0,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x87, 0xC4, 0xE7, 0x24, 0x0D, 0x40, 0x2C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04,
  0x1A, 0x67, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x34, 0x03, 0x20, 0x31, 0x01, 0x08, 0x18,
  0x41, 0x82, 0x18, 0x11, 0x80, 0x98, 0x05, 0xC0, 0x2B, 0x01, 0x8C, 0x08,
  0x20, 0x41, 0x82, 0x06, 0x10, 0x10, 0x80, 0xC4, 0x03, 0x20, 0x09, 0x00,
  0x68, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x87,
  0xC0, 0xF8, 0x9C, 0xE1, 0x8E, 0xB0, 0x32, 0x06, 0xA0, 0x14, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x87, 0xC4, 0xE7, 0x24, 0x0D, 0x40, 0x2C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x07, 0xC0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xC8, 0x00,
  0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x02, 0x60, 0x0C, 0xC0, 0x18, 0xC0,
  0x60, 0xF3, 0x80, 0x7C, 0x00, 0x8F, 0xC2, 0x73, 0x8A, 0x03, 0x30, 0x06,
  0xC0, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x02, 0xC0, 0x1B, 0x00,
  0x6A, 0x03, 0x27, 0x78, 0x8F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0xC4, 0x73, 0x93,
  0x03, 0xD8, 0x07, 0x40, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03,
  0x40, 0x0D, 0x80, 0x33, 0x01, 0xC7, 0x3B, 0x0F, 0xCC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x8F,
  0x9D, 0xB0, 0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x81, 0xC7, 0x18,
  0x0C, 0x80, 0x2C, 0x01, 0xE0, 0x0D, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0xD8, 0x0C, 0x79, 0xC0, 0xFC, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x87, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x83,
  0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x1A, 0x01, 0xD8, 0x1E, 0x73, 0xB1, 0xF9, 0x80,
  0xC0, 0x04, 0x80, 0x09, 0x00, 0x33, 0x00, 0x46, 0x00, 0x84, 0x03, 0x0C,
  0x04, 0x18, 0x08, 0x10, 0x30, 0x20, 0x60, 0x60, 0x80, 0x43, 0x00, 0x86,
  0x01, 0x88, 0x01, 0x10, 0x02, 0x60, 0x06, 0x80, 0x05, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x3C, 0x07, 0x00,
  0xB0, 0x14, 0x02, 0x40, 0x58, 0x19, 0x01, 0x60, 0x66, 0x0C, 0x81, 0x18,
  0x22, 0x04, 0x20, 0x8C, 0x30, 0x82, 0x30, 0xC3, 0x18, 0x42, 0x0C, 0x41,
  0x08, 0x11, 0x06, 0x60, 0x44, 0x09, 0x81, 0x30, 0x24, 0x06, 0x80, 0x90,
  0x0A, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x40, 0x0D, 0x80, 0x23, 0x01, 0x84, 0x0C, 0x18, 0x30, 0x21,
  0x80, 0xC4, 0x01, 0x30, 0x06, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x06,
  0x80, 0x13, 0x00, 0xC6, 0x06, 0x08, 0x10, 0x30, 0xC0, 0x42, 0x01, 0x98,
  0x03, 0xC0, 0x0C, 0xC0, 0x05, 0x80, 0x09, 0x00, 0x33, 0x00, 0x46, 0x00,
  0x84, 0x03, 0x0C, 0x06, 0x18, 0x08, 0x10, 0x30, 0x30, 0x60, 0x60, 0x80,
  0x43, 0x00, 0xC6, 0x01, 0x88, 0x01, 0x10, 0x02, 0x60, 0x06, 0x80, 0x05,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x40, 0x60,
  0x30, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x0F, 0x03, 0x80, 0x30, 0x02,
  0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x1C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x1C, 0x07, 0x03, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x40, 0x70, 0x10, 0x00, 0x1C, 0x00, 0xBB, 0x80, 0x50, 0x60,
  0x38, 0x18, 0x18, 0x06, 0x1C, 0x01, 0x9A, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 5, 8, 11, 3, -29 },
  { 13, 18, 28, 19, 1, -28 },
  { 76, 15, 36, 19, 2, -32 },
  { 144, 21, 28, 25, 2, -28 },
  { 218, 18, 28, 21, 2, -28 },
  { 281, 2, 8, 7, 2, -29 },
  { 283, 7, 40, 11, 3, -31 },
  { 318, 7, 40, 11, 1, -31 },
  { 353, 15, 15, 16, 1, -28 },
  { 382, 16, 19, 19, 2, -22 },
  { 420, 4, 8, 7, 1, -3 },
  { 424, 8, 1, 10, 1, -13 },
  { 425, 2, 3, 9, 3, -3 },
  { 426, 11, 30, 14, 1, -28 },
  { 468, 15, 28, 19, 2, -28 },
  { 521, 8, 28, 19, 3, -28 },
  { 549, 15, 28, 19, 2, -28 },
  { 602, 15, 28, 19, 2, -28 },
  { 655, 16, 28, 19, 2, -28 },
  { 711, 14, 28, 19, 3, -28 },
  { 760, 15, 28, 19, 2, -28 },
  { 813, 15, 28, 19, 2, -28 },
  { 866, 15, 28, 19, 2, -28 },
  { 919, 14, 28, 19, 2, -28 },
  { 968, 3, 21, 7, 2, -21 },
  { 976, 4, 26, 7, 1, -21 },
  { 989, 13, 15, 18, 2, -20 },
  { 1014, 13, 8, 19, 3, -17 },
  { 1027, 14, 16, 18, 2, -21 },
  { 1055, 12, 28, 15, 2, -28 },
  { 1097, 27, 36, 31, 2, -27 },
  { 1219, 19, 28, 21, 1, -28 },
  { 1286, 16, 28, 21, 3, -28 },
  { 1342, 17, 28, 22, 3, -28 },
  { 1402, 17, 28, 22, 3, -28 },
  { 1462, 15, 28, 20, 3, -28 },
  { 1515, 15, 28, 19, 3, -28 },
  { 1568, 17, 28, 23, 3, -28 },
  { 1628, 17, 28, 24, 3, -28 },
  { 1688, 1, 28, 9, 4, -28 },
  { 1692, 14, 28, 19, 2, -28 },
  { 1741, 17, 28, 22, 3, -28 },
  { 1801, 14, 28, 18, 3, -28 },
  { 1850, 23, 28, 29, 3, -28 },
  { 1931, 18, 28, 24, 3, -28 },
  { 1994, 17, 28, 23, 3, -28 },
  { 2054, 16, 28, 21, 3, -28 },
  { 2110, 17, 33, 23, 3, -28 },
  { 2181, 17, 28, 22, 3, -28 },
  { 2241, 17, 28, 20, 2, -28 },
  { 2301, 18, 28, 20, 1, -28 },
  { 2364, 16, 28, 23, 3, -28 },
  { 2420, 19, 28, 21, 1, -28 },
  { 2487, 28, 28, 30, 1, -28 },
  { 2585, 18, 28, 21, 1, -28 },
  { 2648, 19, 28, 20, 1, -28 },
  { 2715, 17, 28, 20, 2, -28 },
  { 2775, 5, 38, 8, 3, -32 },
  { 2799, 11, 30, 13, 1, -28 },
  { 2841, 5, 38, 8, 0, -32 },
  { 2865, 11, 14, 14, 2, -28 },
  { 2885, 14, 1, 15, 0, 0 },
  { 2887, 6, 5, 11, 2, -29 },
  { 2891, 14, 21, 18, 2, -21 },
  { 2928, 14, 29, 19, 3, -29 },
  { 2979, 14, 21, 18, 2, -21 },
  { 3016, 14, 29, 19, 2, -29 },
  { 3067, 14, 21, 18, 2, -21 },
  { 3104, 10, 29, 11, 1, -29 },
  { 3141, 14, 29, 19, 2, -21 },
  { 3192, 13, 29, 19, 3, -29 },
  { 3240, 2, 28, 8, 3, -28 },
  { 3247, 7, 36, 8, -2, -28 },
  { 3279, 13, 29, 17, 3, -29 },
  { 3327, 2, 29, 8, 3, -29 },
  { 3335, 24, 21, 30, 3, -21 },
  { 3398, 13, 21, 19, 3, -21 },
  { 3433, 15, 21, 19, 2, -21 },
  { 3473, 14, 29, 19, 3, -21 },
  { 3524, 14, 29, 19, 2, -21 },
  { 3575, 8, 21, 12, 3, -21 },
  { 3596, 13, 21, 17, 2, -21 },
  { 3631, 9, 26, 11, 1, -26 },
  { 3661, 13, 21, 19, 3, -21 },
  { 3696, 15, 21, 17, 1, -21 },
  { 3736, 22, 21, 26, 2, -21 },
  { 3794, 14, 21, 17, 1, -21 },
  { 3831, 15, 29, 16, 1, -21 },
  { 3886, 13, 21, 17, 2, -21 },
  { 3921, 10, 38, 11, 1, -30 },
  { 3969, 2, 33, 8, 3, -28 },
  { 3978, 10, 38, 11, 0, -30 },
  { 4026, 17, 7, 23, 3, -15 },
};

const GFXfont RobotoCondensed_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT39PT7B_H_
