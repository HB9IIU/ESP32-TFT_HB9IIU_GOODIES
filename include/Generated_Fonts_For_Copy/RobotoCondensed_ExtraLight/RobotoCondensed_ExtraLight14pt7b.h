#ifndef _ROBOTOCONDENSED_EXTRALIGHT14PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xF4, 0x28, 0xA3, 0x92, 0x49, 0x45, 0x1E, 0x50, 0x40,
  0x22, 0xA3, 0x18, 0x30, 0x41, 0x8C, 0x54, 0x40, 0xE1, 0x4A, 0xA5, 0x4F,
  0x02, 0xCA, 0x95, 0x4A, 0x0C, 0x72, 0x49, 0x1C, 0x42, 0x99, 0x65, 0x89,
  0xD0, 0xC0, 0x29, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x12, 0x49, 0x24,
  0xA5, 0x00, 0x20, 0x97, 0x8C, 0x48, 0x21, 0x09, 0xF2, 0x10, 0x80, 0xE0,
  0x40, 0x80, 0x01, 0x12, 0x22, 0x24, 0x44, 0x00, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x8B, 0x80, 0x74, 0x92, 0x49, 0x24, 0x74, 0x62, 0x11, 0x08, 0x88,
  0x47, 0xC0, 0x74, 0x62, 0x17, 0x04, 0x31, 0x8B, 0x80, 0x11, 0x8C, 0xA5,
  0x4B, 0xC2, 0x10, 0x80, 0x7C, 0x21, 0x0F, 0x04, 0x31, 0x8B, 0x80, 0x32,
  0x21, 0xE8, 0xC6, 0x31, 0x8B, 0x80, 0x78, 0x44, 0x21, 0x10, 0x84, 0x42,
  0x00, 0x74, 0x63, 0x17, 0x46, 0x31, 0x8B, 0x80, 0x74, 0x63, 0x18, 0xC5,
  0xE1, 0x13, 0x00, 0x82, 0x83, 0x80, 0x16, 0x86, 0x10, 0xF8, 0x00, 0x0F,
  0x80, 0x83, 0x82, 0xE8, 0x00, 0xE9, 0x11, 0x24, 0x40, 0x04, 0x3E, 0x20,
  0x90, 0x31, 0x99, 0x0D, 0x16, 0x8B, 0x49, 0xA4, 0xCD, 0xA0, 0x08, 0x03,
  0xC0, 0x10, 0x20, 0xA1, 0x42, 0x48, 0x97, 0x21, 0x43, 0x04, 0xF2, 0x28,
  0x62, 0xB2, 0x28, 0x61, 0x87, 0xE0, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x21,
  0x85, 0xE0, 0xBA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x87, 0xE0, 0xB4, 0x21,
  0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xB4, 0x21, 0x0F, 0xC2, 0x10, 0x84, 0x00,
  0x7A, 0x18, 0x60, 0x82, 0x78, 0x61, 0x85, 0xE0, 0x86, 0x18, 0x61, 0xFE,
  0x18, 0x61, 0x86, 0x10, 0xFF, 0xC0, 0x08, 0x42, 0x10, 0x84, 0x31, 0x93,
  0x80, 0x86, 0x29, 0x28, 0xA3, 0x89, 0x22, 0x8A, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x87, 0xC0, 0x81, 0x81, 0xC3, 0xC3, 0xA3, 0xA5, 0x95, 0x95,
  0x99, 0x89, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE3, 0x86, 0x10, 0x7A, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20,
  0x82, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x81, 0xFA,
  0x18, 0x61, 0x87, 0xE9, 0x22, 0x86, 0x10, 0x72, 0x28, 0x60, 0x60, 0x60,
  0x61, 0x85, 0xE0, 0x7C, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x82, 0x85, 0x0A, 0x24,
  0x44, 0x8A, 0x14, 0x10, 0x20, 0x84, 0x51, 0x14, 0xA5, 0x29, 0x4A, 0x52,
  0xA3, 0x18, 0xC6, 0x31, 0x80, 0x00, 0x42, 0x88, 0x91, 0x41, 0x02, 0x0A,
  0x12, 0x44, 0x84, 0x82, 0x89, 0x11, 0x42, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x74, 0x21, 0x04, 0x20, 0x84, 0x10, 0x83, 0xF0, 0xAA, 0xAA, 0xAA, 0xC0,
  0x84, 0x44, 0x22, 0x21, 0x11, 0x10, 0x55, 0x55, 0x55, 0xC0, 0x4A, 0xDA,
  0xF8, 0x90, 0x74, 0x42, 0xD8, 0xC6, 0x5D, 0x84, 0x21, 0xE8, 0xC6, 0x31,
  0x8C, 0x7C, 0x74, 0x63, 0x08, 0x42, 0x2E, 0x08, 0x42, 0xF8, 0xC6, 0x31,
  0x8C, 0x5E, 0x74, 0x63, 0xF8, 0x42, 0x0E, 0x24, 0x46, 0x44, 0x44, 0x44,
  0x40, 0x7C, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x5C, 0x84, 0x21, 0xE8, 0xC6,
  0x31, 0x8C, 0x62, 0x9F, 0xE0, 0x20, 0x12, 0x49, 0x24, 0x93, 0x80, 0x84,
  0x21, 0x2A, 0x53, 0x14, 0xA4, 0xA2, 0xFF, 0xE0, 0xF7, 0x44, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x23, 0x11, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x74, 0x63,
  0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x7C, 0x63,
  0x18, 0xC6, 0x2F, 0x08, 0x42, 0xF2, 0x49, 0x24, 0x79, 0x84, 0x31, 0x9F,
  0x49, 0x24, 0x92, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x85, 0x24, 0x92,
  0x50, 0xC3, 0x00, 0x91, 0x92, 0xAA, 0xAA, 0xAA, 0x4A, 0x44, 0x44, 0x49,
  0x23, 0x0C, 0x30, 0xC4, 0xA2, 0x85, 0x24, 0x92, 0x30, 0xC3, 0x04, 0x20,
  0x84, 0x00, 0xF0, 0x88, 0x44, 0x22, 0x1F, 0x29, 0x24, 0xA4, 0x49, 0x24,
  0x40, 0xFF, 0xF0, 0x84, 0x44, 0x42, 0x32, 0x44, 0x44, 0x48, 0xE2, 0x70,
};

const GFXglyph RobotoCondensed_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 3, 4, 1, -11 },
  { 4, 6, 10, 7, 1, -10 },
  { 12, 5, 12, 7, 1, -11 },
  { 20, 7, 10, 9, 1, -10 },
  { 29, 6, 10, 8, 1, -10 },
  { 37, 1, 3, 2, 1, -11 },
  { 38, 3, 14, 4, 1, -11 },
  { 44, 3, 14, 4, 0, -11 },
  { 50, 6, 5, 6, 0, -10 },
  { 54, 5, 7, 7, 1, -8 },
  { 59, 1, 3, 3, 1, -1 },
  { 60, 3, 1, 4, 0, -5 },
  { 61, 1, 1, 3, 1, -1 },
  { 62, 4, 11, 5, 0, -10 },
  { 68, 5, 10, 7, 1, -10 },
  { 75, 3, 10, 7, 1, -10 },
  { 79, 5, 10, 7, 1, -10 },
  { 86, 5, 10, 7, 1, -10 },
  { 93, 5, 10, 7, 1, -10 },
  { 100, 5, 10, 7, 1, -10 },
  { 107, 5, 10, 7, 1, -10 },
  { 114, 5, 10, 7, 1, -10 },
  { 121, 5, 10, 7, 1, -10 },
  { 128, 5, 10, 7, 1, -10 },
  { 135, 1, 7, 3, 1, -7 },
  { 136, 1, 9, 2, 1, -7 },
  { 138, 4, 5, 6, 1, -7 },
  { 141, 5, 5, 7, 1, -7 },
  { 145, 5, 5, 6, 1, -7 },
  { 149, 4, 10, 6, 1, -10 },
  { 154, 9, 13, 11, 1, -10 },
  { 169, 7, 10, 8, 0, -10 },
  { 178, 6, 10, 7, 1, -10 },
  { 186, 6, 10, 8, 1, -10 },
  { 194, 6, 10, 8, 1, -10 },
  { 202, 5, 10, 7, 1, -10 },
  { 209, 5, 10, 7, 1, -10 },
  { 216, 6, 10, 8, 1, -10 },
  { 224, 6, 10, 9, 1, -10 },
  { 232, 1, 10, 3, 1, -10 },
  { 234, 5, 10, 7, 1, -10 },
  { 241, 6, 10, 8, 1, -10 },
  { 249, 5, 10, 6, 1, -10 },
  { 256, 8, 10, 10, 1, -10 },
  { 266, 6, 10, 9, 1, -10 },
  { 274, 6, 10, 8, 1, -10 },
  { 282, 6, 10, 7, 1, -10 },
  { 290, 6, 12, 8, 1, -10 },
  { 299, 6, 10, 8, 1, -10 },
  { 307, 6, 10, 7, 1, -10 },
  { 315, 7, 10, 7, 0, -10 },
  { 324, 6, 10, 8, 1, -10 },
  { 332, 7, 10, 7, 0, -10 },
  { 341, 10, 10, 11, 0, -10 },
  { 354, 7, 10, 7, 0, -10 },
  { 363, 7, 10, 7, 0, -10 },
  { 372, 6, 10, 7, 1, -10 },
  { 380, 2, 13, 3, 1, -11 },
  { 384, 4, 11, 5, 0, -10 },
  { 390, 2, 13, 3, 0, -11 },
  { 394, 3, 5, 5, 1, -10 },
  { 396, 5, 1, 5, 0, 0 },
  { 397, 2, 2, 4, 1, -11 },
  { 398, 5, 8, 7, 1, -8 },
  { 403, 5, 11, 7, 1, -11 },
  { 410, 5, 8, 6, 1, -8 },
  { 415, 5, 11, 7, 1, -11 },
  { 422, 5, 8, 6, 1, -8 },
  { 427, 4, 11, 4, 0, -11 },
  { 433, 5, 11, 7, 1, -8 },
  { 440, 5, 11, 7, 1, -11 },
  { 447, 1, 11, 3, 1, -11 },
  { 449, 3, 14, 3, -1, -11 },
  { 455, 5, 11, 6, 1, -11 },
  { 462, 1, 11, 3, 1, -11 },
  { 464, 9, 8, 11, 1, -8 },
  { 473, 5, 8, 7, 1, -8 },
  { 478, 5, 8, 7, 1, -8 },
  { 483, 5, 11, 7, 1, -8 },
  { 490, 5, 11, 7, 1, -8 },
  { 497, 3, 8, 4, 1, -8 },
  { 500, 4, 8, 6, 1, -8 },
  { 504, 3, 9, 4, 0, -9 },
  { 508, 5, 8, 7, 1, -8 },
  { 513, 6, 8, 6, 0, -8 },
  { 519, 8, 8, 9, 1, -8 },
  { 527, 6, 8, 6, 0, -8 },
  { 533, 6, 11, 6, 0, -8 },
  { 542, 5, 8, 6, 1, -8 },
  { 547, 3, 14, 4, 1, -11 },
  { 553, 1, 12, 3, 1, -10 },
  { 555, 4, 14, 4, 0, -11 },
  { 562, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT14PT7B_H_
