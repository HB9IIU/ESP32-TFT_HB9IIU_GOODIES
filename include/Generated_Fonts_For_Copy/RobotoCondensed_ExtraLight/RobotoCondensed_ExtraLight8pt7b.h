#ifndef _ROBOTOCONDENSED_EXTRALIGHT8PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0xC0, 0x05, 0x66, 0x62, 0x0E, 0x23, 0x78, 0x45, 0xB8, 0x45,
  0xAC, 0x66, 0x44, 0xBF, 0x00, 0xFE, 0x15, 0x56, 0x19, 0x00, 0x04, 0xF0,
  0x00, 0xC0, 0x00, 0x15, 0x80, 0x76, 0xDA, 0xC0, 0x78, 0x69, 0x22, 0x46,
  0x64, 0x8B, 0xC0, 0x22, 0x62, 0x60, 0xD3, 0x13, 0xC0, 0x29, 0xDA, 0xC0,
  0xE4, 0x94, 0x80, 0x76, 0xFB, 0xC0, 0x76, 0xF2, 0xC0, 0x00, 0x00, 0x71,
  0x80, 0xC0, 0x45, 0x00, 0x54, 0x80, 0x00, 0x39, 0x1A, 0x69, 0xB6, 0xD4,
  0x0C, 0x02, 0x65, 0x98, 0xD6, 0x7A, 0x80, 0xD2, 0x49, 0xC0, 0xD6, 0xDA,
  0xC0, 0xF2, 0x48, 0x80, 0xF2, 0x48, 0x00, 0xD2, 0x7B, 0xC0, 0x16, 0xFA,
  0x00, 0x78, 0x04, 0x9B, 0xC0, 0x3A, 0x4C, 0x40, 0x2A, 0x80, 0x09, 0x9B,
  0xF4, 0x16, 0xFA, 0x40, 0xD6, 0xDB, 0xC0, 0xD6, 0xE8, 0x00, 0xD6, 0xDB,
  0xC8, 0xD6, 0xEA, 0x40, 0x69, 0x43, 0x9F, 0xF2, 0x22, 0x20, 0x16, 0xDB,
  0xC0, 0x89, 0x56, 0x20, 0x82, 0x5B, 0x55, 0x49, 0x20, 0x95, 0x22, 0x61,
  0x89, 0x64, 0x20, 0xF2, 0x24, 0x46, 0xFE, 0x91, 0x24, 0x00, 0xFE, 0x48,
  0x00, 0x40, 0x00, 0x6E, 0xF0, 0x2F, 0xF0, 0xD2, 0x60, 0x0E, 0xDB, 0xC0,
  0xF6, 0x60, 0x15, 0x40, 0xF6, 0xF2, 0xC0, 0x2F, 0xC0, 0x18, 0x1F, 0x2E,
  0x90, 0x78, 0xDD, 0x6A, 0x10, 0xFC, 0xF6, 0xF0, 0xFF, 0x80, 0xF6, 0xF2,
  0x00, 0xE0, 0xC8, 0xB0, 0x2A, 0x00, 0x3F, 0x95, 0x20, 0xAD, 0x54, 0xA0,
  0x29, 0x10, 0x95, 0x25, 0x00, 0x69, 0x20, 0x54, 0x14, 0x7C, 0x15, 0x16,
  0x40,
};

const GFXglyph RobotoCondensed_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 8, 4, 0, -7 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 0, -6 },
  { 17, 1, 8, 2, 1, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -6 },
  { 22, 4, 4, 4, 0, -5 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 6, 3, 0, -6 },
  { 29, 3, 6, 4, 0, -6 },
  { 32, 1, 6, 4, 1, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 1, -6 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 1, 4, 1, 0, -4 },
  { 58, 1, 5, 1, 0, -4 },
  { 59, 3, 3, 4, 0, -4 },
  { 61, 2, 2, 4, 1, -4 },
  { 62, 3, 3, 4, 0, -4 },
  { 64, 3, 6, 3, 0, -6 },
  { 67, 6, 8, 6, 0, -6 },
  { 73, 4, 6, 4, 0, -6 },
  { 76, 3, 6, 4, 1, -6 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 3, 6, 5, 1, -6 },
  { 85, 3, 6, 4, 1, -6 },
  { 88, 3, 6, 4, 1, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 1, 6, 2, 0, -6 },
  { 98, 3, 6, 4, 0, -6 },
  { 101, 3, 6, 4, 1, -6 },
  { 104, 2, 6, 4, 1, -6 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 3, 6, 4, 1, -6 },
  { 118, 3, 7, 5, 1, -6 },
  { 121, 3, 6, 5, 1, -6 },
  { 124, 4, 6, 4, 0, -6 },
  { 127, 4, 6, 4, 0, -6 },
  { 130, 3, 6, 5, 1, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 6, 6, 6, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 1, 8, 2, 1, -7 },
  { 151, 3, 6, 3, 0, -6 },
  { 154, 1, 8, 2, 0, -7 },
  { 155, 3, 3, 3, 0, -6 },
  { 157, 3, 1, 3, 0, 0 },
  { 158, 2, 1, 2, 0, -6 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 2, 6, 4, 1, -6 },
  { 163, 3, 4, 4, 0, -4 },
  { 165, 3, 6, 4, 0, -6 },
  { 168, 3, 4, 4, 0, -4 },
  { 170, 2, 6, 2, 0, -6 },
  { 172, 3, 6, 4, 0, -4 },
  { 175, 2, 6, 4, 1, -6 },
  { 177, 1, 6, 2, 0, -6 },
  { 178, 1, 8, 2, 0, -6 },
  { 179, 2, 6, 3, 1, -6 },
  { 181, 1, 6, 2, 0, -6 },
  { 182, 5, 4, 6, 1, -4 },
  { 185, 2, 4, 4, 1, -4 },
  { 186, 3, 4, 4, 0, -4 },
  { 188, 2, 6, 4, 1, -4 },
  { 190, 3, 6, 4, 0, -4 },
  { 193, 1, 4, 2, 1, -4 },
  { 194, 3, 4, 4, 0, -4 },
  { 196, 2, 5, 2, 0, -5 },
  { 198, 2, 4, 4, 1, -4 },
  { 199, 3, 4, 3, 0, -4 },
  { 201, 5, 4, 5, 0, -4 },
  { 204, 3, 4, 3, 0, -4 },
  { 206, 3, 6, 3, 0, -4 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 2, 8, 2, 0, -6 },
  { 213, 1, 7, 2, 0, -6 },
  { 214, 2, 8, 2, 0, -6 },
  { 216, 3, 1, 5, 1, -3 },
};

const GFXfont RobotoCondensed_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT8PT7B_H_
