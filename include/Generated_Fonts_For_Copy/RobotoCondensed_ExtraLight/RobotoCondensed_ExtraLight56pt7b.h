#ifndef _ROBOTOCONDENSED_EXTRALIGHT56PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0x40, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0,
  0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x03, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x00,
  0x03, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07,
  0x70, 0x00, 0x31, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x3C, 0x03, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0x40, 0x08, 0x0C, 0x01, 0x80, 0x30, 0x30, 0x06,
  0x01, 0x80, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0x60, 0xC0,
  0x04, 0x01, 0x03, 0x00, 0x18, 0x0C, 0x18, 0x00, 0x30, 0x70, 0x40, 0x00,
  0xF3, 0x83, 0x00, 0x01, 0xFC, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x81, 0xF8, 0x00, 0x0C, 0x1E, 0x70, 0x00, 0x30, 0x60, 0x60, 0x01, 0x83,
  0x01, 0x80, 0x06, 0x0C, 0x03, 0x00, 0x30, 0x20, 0x0C, 0x00, 0xC1, 0x80,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x03, 0x01, 0x80, 0x30, 0x18, 0x06, 0x00, 0xC0, 0x40, 0x08, 0x03, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x70, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0xE0, 0x0C, 0x38, 0x1C, 0x03, 0x0C, 0x03, 0x00, 0xC6, 0x00,
  0x60, 0x31, 0x80, 0x1C, 0x0C, 0xE0, 0x03, 0x03, 0x30, 0x00, 0x61, 0x8C,
  0x00, 0x1C, 0x63, 0x00, 0x03, 0x98, 0xC0, 0x00, 0x6C, 0x30, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x0E, 0x00,
  0x39, 0x81, 0xC0, 0x3C, 0x70, 0x3F, 0x7C, 0x0C, 0x07, 0xFE, 0x01, 0x80,
  0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFA, 0x00, 0x40, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x0C, 0x02, 0xF8,
  0x30, 0x7C, 0xF8, 0xC7, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x87, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x20,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x18, 0xC6, 0x31, 0x9C, 0xE6, 0x33, 0x38, 0x80, 0xFF, 0xFF,
  0xFC, 0xEF, 0xF0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x70, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1D,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x80, 0x01, 0x8C, 0x00,
  0x18, 0x60, 0x00, 0xC1, 0x80, 0x0C, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x00,
  0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x3C, 0x1F,
  0x8F, 0x3F, 0x87, 0xC0, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xC0, 0x03, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xF7, 0xE0, 0x1C, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x31,
  0xC0, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00,
  0x0D, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x06, 0x1C, 0x00, 0x70,
  0x70, 0x07, 0x01, 0xFB, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x1F,
  0xC0, 0x6F, 0xFE, 0x0F, 0x81, 0xE1, 0xC0, 0x0E, 0x30, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0x38, 0x00,
  0x63, 0x00, 0x18, 0x38, 0x07, 0x03, 0xEF, 0xC0, 0x3F, 0xE0, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC1, 0xFC, 0x0C, 0x7F, 0xE0, 0xCE, 0x07, 0x8D, 0xC0, 0x1C, 0xF0, 0x00,
  0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x66,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xE0, 0x38,
  0x0F, 0xDF, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xF7, 0xE0, 0x3C, 0x07, 0x81, 0x80, 0x0E, 0x1C,
  0x00, 0x30, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80,
  0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x70,
  0x1E, 0x07, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x38, 0x0E, 0x03, 0x80,
  0x1C, 0x30, 0x00, 0x63, 0x80, 0x01, 0x98, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x77, 0x00, 0x07, 0x1C,
  0x00, 0x30, 0x70, 0x07, 0x81, 0xFB, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x3C, 0x07, 0x01,
  0x80, 0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0x77, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x3C, 0xC0,
  0x03, 0x67, 0x00, 0x1F, 0x1C, 0x03, 0xB0, 0x70, 0x39, 0x81, 0xFF, 0x8C,
  0x03, 0xF0, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x70, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xC6,
  0x73, 0x38, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x07, 0xF8, 0x07, 0xDF, 0x07, 0x01, 0xC7, 0x00, 0x67, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x3F, 0x00, 0x18, 0x60, 0x03, 0xFE, 0x00,
  0x63, 0x00, 0x1C, 0x1C, 0x00, 0x8C, 0x00, 0x60, 0x18, 0x03, 0x30, 0x03,
  0x00, 0x60, 0x0D, 0x80, 0x18, 0x01, 0x80, 0x36, 0x00, 0x60, 0x06, 0x00,
  0xD8, 0x03, 0x00, 0x10, 0x03, 0x60, 0x0C, 0x00, 0x40, 0x0D, 0x80, 0x30,
  0x03, 0x00, 0x34, 0x01, 0x80, 0x0C, 0x00, 0xD0, 0x06, 0x00, 0x30, 0x03,
  0xC0, 0x18, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x80,
  0x0C, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x0F,
  0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x0C, 0x00, 0x90, 0x06, 0x00,
  0x70, 0x06, 0x60, 0x18, 0x01, 0xC0, 0x19, 0x80, 0x60, 0x0F, 0x00, 0x66,
  0x01, 0x80, 0x3C, 0x03, 0x18, 0x03, 0x01, 0xB0, 0x0C, 0x60, 0x0C, 0x0C,
  0x60, 0x60, 0xC0, 0x1D, 0xE1, 0xC7, 0x03, 0x00, 0x3F, 0x03, 0xF8, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0C, 0x00,
  0x7C, 0x30, 0x00, 0x70, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xC3, 0x00, 0x0E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xC0, 0x03, 0xC3, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00,
  0x0F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xF7, 0xF0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x0F, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00, 0x0F,
  0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0E,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x03, 0x8C, 0x00, 0x1E, 0x18,
  0x00, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0xE0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x06, 0x70, 0x00, 0x63, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x80,
  0x00, 0xC7, 0x80, 0x00, 0xCF, 0xC0, 0x00, 0xCC, 0xC0, 0x00, 0xD8, 0x60,
  0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00,
  0x00, 0x33, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x33, 0xCE, 0x00,
  0x00, 0x63, 0xC6, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0xE3, 0xC3, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x01, 0xC3, 0xC1, 0x80,
  0x01, 0x83, 0xC1, 0x80, 0x01, 0x83, 0xC1, 0x80, 0x03, 0x03, 0xC0, 0xC0,
  0x03, 0x03, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0xC0, 0x06, 0x03, 0xC0, 0x60,
  0x06, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0xC0, 0x30,
  0x0C, 0x03, 0xC0, 0x30, 0x1C, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18,
  0x18, 0x03, 0xC0, 0x18, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C,
  0x30, 0x03, 0xC0, 0x0C, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06,
  0x60, 0x03, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x98, 0x00, 0x03, 0xC6,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x3C,
  0x18, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x03,
  0xC0, 0x60, 0x01, 0xE0, 0x18, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0x00,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x18, 0x07, 0x80, 0x0C,
  0x03, 0xC0, 0x03, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x60, 0x78, 0x00,
  0x38, 0x3C, 0x00, 0x0C, 0x1E, 0x00, 0x03, 0x0F, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x63, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x07, 0x78,
  0x00, 0x01, 0xBC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x9C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x3E, 0x30,
  0x00, 0x3C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x03,
  0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x9C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x04, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x18, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x71, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x1E, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x1E, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x0E, 0x70, 0x00,
  0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x30, 0x00, 0x46, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x38,
  0x00, 0xC3, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x00, 0x83,
  0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x1C, 0x01, 0x81, 0x80, 0x30,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x01, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0xC0,
  0x60, 0x06, 0x02, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x88, 0x00, 0x31, 0x80, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19,
  0x80, 0x01, 0x90, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x0B, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x18, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x06, 0x00,
  0x06, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x18,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x1C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x30, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x70, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xBF, 0x01, 0xC0, 0x38, 0x30, 0x01, 0xC7, 0x00, 0x0C,
  0x60, 0x00, 0xE6, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x01, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1E, 0x00, 0x63, 0x80, 0x06, 0x70, 0x00, 0x6E, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC,
  0x00, 0x0E, 0xC0, 0x01, 0xE6, 0x00, 0x36, 0x70, 0x0E, 0x63, 0xFF, 0xC6,
  0x1F, 0xF0, 0x60, 0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00, 0xC3,
  0xFE, 0x0C, 0x7F, 0xF0, 0xCC, 0x03, 0x8D, 0x80, 0x1C, 0xF0, 0x00, 0xCE,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0,
  0x00, 0x6F, 0x00, 0x0C, 0xD8, 0x01, 0xCD, 0xC0, 0x38, 0xCF, 0xFF, 0x0C,
  0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00,
  0xE3, 0x80, 0x0C, 0x1C, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x07, 0xFC, 0x30, 0xFF, 0xF3,
  0x1C, 0x03, 0x33, 0x80, 0x1B, 0x30, 0x00, 0xF7, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x73, 0x00, 0x07,
  0x38, 0x00, 0xB1, 0xC0, 0x3B, 0x0F, 0xFF, 0x30, 0x7F, 0xC3, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xC0, 0x38, 0x38,
  0x01, 0xC3, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x06, 0x1E,
  0x01, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03,
  0xF0, 0x3E, 0xC0, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0xEF, 0xFF, 0x83,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0x0F, 0xFE, 0x31, 0xC0, 0x33, 0x38,
  0x01, 0xB3, 0x00, 0x0F, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x37, 0x00, 0x07, 0x30, 0x00, 0xF3, 0x80, 0x0B, 0x1C,
  0x03, 0xB0, 0xFF, 0xF3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x63, 0x00, 0x0E,
  0x38, 0x01, 0xC1, 0xE0, 0x38, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x1F, 0xE1, 0x8F, 0xBE, 0x33, 0x80, 0xE6, 0x60, 0x0E,
  0xD8, 0x00, 0xDE, 0x00, 0x1B, 0xC0, 0x03, 0x70, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0C, 0x5F, 0xF0, 0x00, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x01, 0x01, 0xC0, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x07, 0x3F, 0x1F, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1D,
  0x80, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0xE0, 0x60, 0x38, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x30, 0xE0, 0x06,
  0x18, 0x00, 0xC6, 0x00, 0x19, 0xE0, 0x03, 0x7C, 0x00, 0x7C, 0xC0, 0x0F,
  0x1C, 0x01, 0xC1, 0x80, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x38, 0x18,
  0x03, 0x03, 0x00, 0x70, 0x60, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x0E, 0x30,
  0x00, 0xE6, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x10,
  0x18, 0x3F, 0xC0, 0x3F, 0xC3, 0x1F, 0xFC, 0x1F, 0x7E, 0x67, 0x01, 0xC7,
  0x01, 0xCD, 0x80, 0x19, 0xC0, 0x1D, 0xB0, 0x01, 0xB0, 0x01, 0xBC, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00,
  0x1E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x3F, 0xC3, 0x1F, 0x7C, 0x67, 0x01, 0xCC, 0xC0, 0x1D,
  0xB0, 0x01, 0xBC, 0x00, 0x37, 0x80, 0x06, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xE0, 0x3C, 0x07,
  0x81, 0x80, 0x0E, 0x1C, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x03, 0x8E, 0x00,
  0x18, 0x30, 0x01, 0xC1, 0xE0, 0x1C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x0C, 0x3F, 0xE0, 0xC7, 0xFF, 0x0C, 0xC0, 0x38,
  0xD8, 0x01, 0xCF, 0x00, 0x0C, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0xF0, 0x00, 0xCD, 0x80, 0x1C,
  0xDC, 0x03, 0x8C, 0xFF, 0xF0, 0xC3, 0xFE, 0x0C, 0x02, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC3, 0x0F, 0xFF, 0x31, 0xC0, 0x3B, 0x38, 0x01, 0xB3,
  0x00, 0x0F, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x37, 0x00, 0x07, 0x30, 0x00, 0x73, 0x80, 0x0F, 0x1C, 0x03, 0xB0,
  0xFF, 0xF3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x3F, 0xC7,
  0xFC, 0xC0, 0xD8, 0x0D, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1C, 0x03, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x38,
  0x00, 0xE3, 0x80, 0x38, 0x3F, 0x7E, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xFE,
  0xFF, 0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00,
  0xEC, 0x00, 0x3C, 0xC0, 0x0D, 0x9C, 0x03, 0xB1, 0xFF, 0xE6, 0x1F, 0xF0,
  0xC0, 0x20, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xE0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x60, 0x01, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0x03, 0x60, 0x03,
  0xC0, 0x07, 0x60, 0x03, 0xC0, 0x06, 0x30, 0x03, 0x60, 0x06, 0x30, 0x03,
  0x60, 0x06, 0x30, 0x06, 0x60, 0x0E, 0x30, 0x06, 0x60, 0x0C, 0x38, 0x06,
  0x30, 0x0C, 0x18, 0x06, 0x30, 0x0C, 0x18, 0x0C, 0x30, 0x1C, 0x18, 0x0C,
  0x38, 0x18, 0x1C, 0x0C, 0x18, 0x18, 0x0C, 0x08, 0x18, 0x18, 0x0C, 0x18,
  0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0E, 0x18, 0x0C, 0x30, 0x06, 0x30,
  0x0C, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x07, 0x30,
  0x06, 0x60, 0x03, 0x60, 0x06, 0x60, 0x03, 0x60, 0x06, 0x60, 0x03, 0x60,
  0x03, 0x40, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00,
  0x66, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x30, 0xC0, 0x03,
  0x9C, 0x00, 0x19, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x03, 0x98, 0x00, 0x30, 0xC0,
  0x07, 0x0E, 0x00, 0x60, 0x60, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x01,
  0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6C, 0x00,
  0x07, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0xE0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x3C, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x07, 0x80, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x38, 0x03, 0x80, 0x10, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0xCE, 0x1C, 0x00, 0x6C, 0x07, 0x00, 0x36, 0x01,
  0xC0, 0x1E, 0x00, 0x70, 0x1B, 0x00, 0x1E, 0x1D, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 41, 11, 4, -40 },
  { 17, 8, 12, 15, 4, -42 },
  { 29, 26, 40, 28, 2, -40 },
  { 159, 21, 52, 27, 3, -46 },
  { 296, 30, 42, 36, 3, -41 },
  { 454, 26, 42, 30, 3, -41 },
  { 591, 2, 12, 9, 4, -42 },
  { 594, 10, 57, 16, 4, -44 },
  { 666, 11, 57, 16, 1, -44 },
  { 745, 22, 22, 24, 1, -40 },
  { 806, 23, 29, 28, 2, -33 },
  { 890, 5, 12, 11, 2, -5 },
  { 898, 11, 2, 15, 2, -19 },
  { 901, 4, 4, 13, 4, -3 },
  { 903, 16, 43, 20, 1, -40 },
  { 989, 21, 42, 27, 3, -41 },
  { 1100, 11, 40, 27, 5, -40 },
  { 1155, 22, 41, 27, 3, -41 },
  { 1268, 21, 42, 27, 3, -41 },
  { 1379, 24, 40, 27, 2, -40 },
  { 1499, 19, 41, 27, 5, -40 },
  { 1597, 20, 41, 27, 4, -40 },
  { 1700, 22, 40, 27, 2, -40 },
  { 1810, 21, 42, 27, 3, -41 },
  { 1921, 21, 41, 27, 3, -41 },
  { 2029, 4, 30, 10, 3, -29 },
  { 2044, 5, 36, 10, 2, -29 },
  { 2067, 20, 22, 25, 2, -29 },
  { 2122, 19, 13, 27, 4, -25 },
  { 2153, 20, 22, 26, 3, -29 },
  { 2208, 17, 42, 22, 3, -41 },
  { 2298, 38, 51, 45, 3, -39 },
  { 2541, 28, 40, 30, 1, -40 },
  { 2681, 22, 40, 30, 5, -40 },
  { 2791, 24, 42, 32, 4, -41 },
  { 2917, 23, 40, 32, 5, -40 },
  { 3032, 21, 40, 28, 5, -40 },
  { 3137, 21, 40, 28, 5, -40 },
  { 3242, 25, 42, 34, 4, -41 },
  { 3374, 24, 40, 34, 5, -40 },
  { 3494, 2, 40, 14, 6, -40 },
  { 3504, 20, 41, 27, 2, -40 },
  { 3607, 24, 40, 31, 5, -40 },
  { 3727, 19, 40, 26, 5, -40 },
  { 3822, 32, 40, 42, 5, -40 },
  { 3982, 25, 40, 35, 5, -40 },
  { 4107, 25, 42, 33, 4, -41 },
  { 4239, 22, 40, 30, 5, -40 },
  { 4349, 25, 48, 33, 4, -41 },
  { 4499, 23, 40, 32, 5, -40 },
  { 4614, 24, 42, 29, 3, -41 },
  { 4740, 26, 40, 29, 2, -40 },
  { 4870, 23, 41, 32, 5, -40 },
  { 4988, 28, 40, 30, 1, -40 },
  { 5128, 40, 40, 44, 2, -40 },
  { 5328, 26, 40, 30, 2, -40 },
  { 5458, 27, 40, 29, 1, -40 },
  { 5593, 24, 40, 29, 3, -40 },
  { 5713, 8, 55, 12, 4, -46 },
  { 5768, 16, 43, 19, 2, -40 },
  { 5854, 8, 55, 12, 0, -46 },
  { 5909, 16, 20, 21, 2, -40 },
  { 5949, 20, 2, 21, 1, 0 },
  { 5954, 8, 7, 15, 3, -42 },
  { 5961, 20, 32, 26, 3, -31 },
  { 6041, 20, 43, 27, 4, -42 },
  { 6149, 20, 32, 25, 3, -31 },
  { 6229, 20, 43, 27, 3, -42 },
  { 6337, 20, 32, 25, 3, -31 },
  { 6417, 14, 43, 16, 2, -43 },
  { 6493, 20, 42, 27, 3, -31 },
  { 6598, 19, 42, 27, 4, -42 },
  { 6698, 3, 41, 11, 4, -41 },
  { 6714, 9, 52, 12, -2, -41 },
  { 6773, 19, 42, 24, 4, -42 },
  { 6873, 2, 42, 11, 5, -42 },
  { 6884, 35, 31, 43, 4, -31 },
  { 7020, 19, 31, 27, 4, -31 },
  { 7094, 21, 32, 27, 3, -31 },
  { 7178, 20, 42, 27, 4, -31 },
  { 7283, 20, 42, 27, 3, -31 },
  { 7388, 12, 31, 17, 4, -31 },
  { 7435, 19, 32, 25, 3, -31 },
  { 7511, 13, 38, 16, 1, -37 },
  { 7573, 19, 31, 27, 4, -30 },
  { 7647, 21, 30, 24, 1, -30 },
  { 7726, 32, 30, 37, 2, -30 },
  { 7846, 20, 30, 24, 2, -30 },
  { 7921, 21, 41, 24, 1, -30 },
  { 8029, 19, 30, 24, 3, -30 },
  { 8101, 14, 56, 16, 2, -44 },
  { 8199, 2, 47, 12, 5, -40 },
  { 8211, 13, 56, 16, 1, -44 },
  { 8302, 25, 9, 34, 4, -21 },
};

const GFXfont RobotoCondensed_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT56PT7B_H_
