#ifndef _ROBOTOCONDENSED_EXTRALIGHT47PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0x1F, 0x60, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x00,
  0x40, 0x40, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x08, 0x0C,
  0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x30, 0x10, 0x01, 0x81, 0x83, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x18, 0x00, 0x80,
  0x80, 0x04, 0x04, 0x00, 0x60, 0x60, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x04, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F,
  0x00, 0x7F, 0xE0, 0x60, 0x38, 0x60, 0x0C, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0x68, 0x00, 0x34, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x60, 0x03,
  0x38, 0x03, 0x8E, 0x03, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x02, 0x04, 0x02, 0x03,
  0x02, 0x01, 0x01, 0x81, 0x00, 0x81, 0x80, 0x80, 0x40, 0x80, 0x40, 0x20,
  0xC0, 0x20, 0x10, 0x40, 0x10, 0x18, 0x60, 0x0C, 0x0C, 0x20, 0x03, 0x0C,
  0x30, 0x00, 0xFC, 0x30, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x3E, 0x00, 0x0C, 0x3F, 0x80, 0x04, 0x30, 0x60, 0x06, 0x10, 0x10,
  0x02, 0x18, 0x08, 0x03, 0x0C, 0x06, 0x03, 0x06, 0x03, 0x01, 0x83, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0x80, 0xC0, 0x60, 0xC0, 0x60, 0x30, 0x40, 0x30,
  0x10, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x06, 0x00, 0x30, 0x18,
  0x01, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0x80, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x00, 0xCE, 0x00,
  0x06, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xCC,
  0x00, 0x0C, 0x30, 0x0C, 0xC0, 0xC0, 0x66, 0x03, 0x03, 0x60, 0x18, 0x13,
  0x00, 0x60, 0x90, 0x01, 0x8C, 0x80, 0x06, 0x64, 0x00, 0x36, 0x30, 0x00,
  0xF1, 0x80, 0x03, 0x0C, 0x00, 0x3C, 0x30, 0x03, 0xE0, 0xE0, 0x39, 0x83,
  0xFF, 0x06, 0x07, 0xE0, 0x18, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0xC0, 0xC0,
  0x40, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04,
  0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x06, 0x02, 0x03, 0x03, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x0C, 0x1F,
  0xE3, 0x1E, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0x30, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x30, 0x38, 0x18, 0x06, 0x04, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x33, 0x33,
  0x33, 0x66, 0xC8, 0xFF, 0xFF, 0xC0, 0x6F, 0x60, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x03,
  0xE0, 0x07, 0xFC, 0x06, 0x07, 0x06, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x62, 0x00,
  0x61, 0x80, 0x30, 0x60, 0x70, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xC0,
  0xF1, 0xED, 0xE3, 0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0x81, 0xC1, 0xC0,
  0x18, 0x60, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03,
  0x20, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xC0, 0x60, 0xE0, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x02, 0x60, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x02, 0x30, 0x01,
  0x8E, 0x00, 0xC1, 0xC0, 0x70, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x16, 0x00, 0x03,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x01,
  0x86, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0xC0, 0x60, 0x08, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x7E,
  0x03, 0xFF, 0xC1, 0xC0, 0x70, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x23, 0x80,
  0x30, 0xE0, 0x30, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFE,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x7E, 0x0C, 0xFF, 0xC6,
  0xE0, 0x73, 0xC0, 0x19, 0xC0, 0x06, 0xE0, 0x01, 0x60, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30,
  0x70, 0x38, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xC0, 0x70, 0xE0, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x66,
  0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x08, 0x80,
  0x06, 0x30, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x60, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0x83, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x34,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0xCC, 0x00, 0x61, 0xC0, 0x70, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0x60, 0x1C, 0x30, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x07, 0x60, 0x01, 0xCC, 0x00, 0xF3, 0x80, 0x6C, 0x70, 0x33, 0x0F, 0xF8,
  0xC0, 0xF8, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x33, 0x33, 0x66, 0x6C, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0x83, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04,
  0x30, 0x01, 0xE0, 0x06, 0x20, 0x07, 0xF8, 0x06, 0x60, 0x0C, 0x0C, 0x02,
  0x60, 0x18, 0x0C, 0x02, 0x40, 0x10, 0x0C, 0x02, 0xC0, 0x30, 0x0C, 0x02,
  0xC0, 0x20, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03,
  0xC0, 0x40, 0x08, 0x03, 0x80, 0x40, 0x08, 0x03, 0x80, 0x40, 0x08, 0x02,
  0x80, 0xC0, 0x08, 0x02, 0x80, 0xC0, 0x08, 0x02, 0x80, 0xC0, 0x18, 0x06,
  0x80, 0xC0, 0x18, 0x06, 0xC0, 0x40, 0x18, 0x04, 0xC0, 0x40, 0x28, 0x0C,
  0xC0, 0x60, 0x68, 0x08, 0x40, 0x30, 0xCC, 0x18, 0x40, 0x3F, 0x87, 0xF0,
  0x60, 0x1F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0x80, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0x46, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C,
  0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0x30, 0x00, 0xCC, 0x00, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0x01, 0xCC,
  0x00, 0x3B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x6C, 0x00, 0x73, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0x80, 0x70, 0x30, 0x01, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x16, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x68, 0x00,
  0x03, 0x60, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x06, 0x0C, 0x00, 0x70, 0x38, 0x07, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0,
  0x01, 0x8C, 0x00, 0x38, 0xC0, 0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1C,
  0x03, 0x83, 0x80, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x60,
  0x00, 0x16, 0x00, 0x01, 0x30, 0x00, 0x33, 0x80, 0x07, 0x1E, 0x01, 0xE0,
  0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xB0, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x80, 0x30, 0xE0, 0x70, 0x3F,
  0xF0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x61,
  0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x30, 0x18, 0x01, 0x81, 0x80, 0x0C,
  0x18, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x19, 0xE0, 0x00, 0xCD, 0x80,
  0x06, 0xCC, 0x00, 0x3C, 0x30, 0x01, 0xC0, 0xC0, 0x0C, 0x07, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x00, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x02, 0xF6, 0x00, 0x00,
  0xDE, 0xC0, 0x00, 0x1B, 0xCC, 0x00, 0x06, 0x79, 0x80, 0x00, 0xCF, 0x10,
  0x00, 0x11, 0xE3, 0x00, 0x06, 0x3C, 0x60, 0x00, 0xC7, 0x84, 0x00, 0x10,
  0xF0, 0xC0, 0x06, 0x1E, 0x18, 0x00, 0xC3, 0xC1, 0x80, 0x10, 0x78, 0x30,
  0x06, 0x0F, 0x02, 0x00, 0xC1, 0xE0, 0x60, 0x30, 0x3C, 0x0C, 0x06, 0x07,
  0x80, 0x80, 0x80, 0xF0, 0x18, 0x30, 0x1E, 0x03, 0x06, 0x03, 0xC0, 0x20,
  0x80, 0x78, 0x06, 0x30, 0x0F, 0x00, 0xC6, 0x01, 0xE0, 0x0C, 0x80, 0x3C,
  0x01, 0xB0, 0x07, 0x80, 0x16, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x04, 0x00, 0x60, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEC, 0x00, 0x0F, 0x30, 0x00, 0x79,
  0x80, 0x03, 0xC6, 0x00, 0x1E, 0x10, 0x00, 0xF0, 0xC0, 0x07, 0x83, 0x00,
  0x3C, 0x18, 0x01, 0xE0, 0x60, 0x0F, 0x03, 0x00, 0x78, 0x0C, 0x03, 0xC0,
  0x30, 0x1E, 0x01, 0x80, 0xF0, 0x06, 0x07, 0x80, 0x30, 0x3C, 0x00, 0xC1,
  0xE0, 0x06, 0x0F, 0x00, 0x18, 0x78, 0x00, 0x63, 0xC0, 0x03, 0x1E, 0x00,
  0x0C, 0xF0, 0x00, 0x67, 0x80, 0x01, 0xBC, 0x00, 0x05, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x03, 0x80, 0x70, 0x30, 0x01, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x19,
  0x80, 0x00, 0x4C, 0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x40,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x0C, 0x00, 0x70, 0x38, 0x07, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x0C, 0xC0, 0x07, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0x80, 0x70, 0x30, 0x01, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00,
  0x4C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x0C, 0xE0, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00,
  0x70, 0x38, 0x07, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x40, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0,
  0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x30,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1C, 0x01, 0x83, 0x80, 0x0C, 0x30, 0x00,
  0x66, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00,
  0x73, 0x80, 0x0E, 0x1E, 0x01, 0xC0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00,
  0x36, 0x00, 0x0C, 0x60, 0x03, 0x8F, 0x00, 0xE0, 0x7F, 0xF8, 0x03, 0xF8,
  0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x62, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0xC0, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x04, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x10,
  0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x28, 0x00, 0x24, 0x00, 0x34, 0x00, 0x33, 0x00, 0x1B, 0x00,
  0x19, 0x80, 0x0D, 0x80, 0x0C, 0xC0, 0x04, 0x40, 0x04, 0x20, 0x06, 0x20,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x86, 0x00, 0x82,
  0x00, 0xC3, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x20,
  0x60, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x04, 0x0C,
  0x06, 0x0C, 0x03, 0x04, 0x03, 0x06, 0x01, 0x82, 0x00, 0x83, 0x00, 0xC3,
  0x00, 0x41, 0x80, 0x61, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0xC0, 0x0C,
  0x40, 0x04, 0x60, 0x06, 0x60, 0x03, 0x30, 0x03, 0x30, 0x01, 0x90, 0x00,
  0x90, 0x00, 0xD8, 0x00, 0x48, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x16, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0x60, 0x00, 0xC3, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x03, 0x00, 0x30, 0x38, 0x00, 0xC1, 0x80, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x36, 0x00, 0x03, 0x10, 0x00, 0x18, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x60,
  0x0C, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x31,
  0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x61, 0x80, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3F, 0xFC, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x7F, 0xFC, 0x02, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00,
  0xD8, 0x06, 0x40, 0x23, 0x03, 0x18, 0x18, 0x40, 0x83, 0x0C, 0x18, 0x60,
  0x42, 0x03, 0x30, 0x19, 0x80, 0x48, 0x03, 0xC0, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0x03, 0xF0, 0x07, 0xFE,
  0x06, 0x03, 0x86, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x7F, 0xE1, 0xFF, 0xF1,
  0xC0, 0x09, 0xC0, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x60, 0x00, 0xB0, 0x00,
  0x58, 0x00, 0x64, 0x00, 0x73, 0x00, 0x69, 0xC0, 0x64, 0x7F, 0xE3, 0x0F,
  0xC1, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0,
  0x9F, 0xF8, 0xB0, 0x1C, 0xA0, 0x0E, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x0C, 0xB0, 0x1C, 0x9F, 0xF8, 0x87, 0xE0,
  0x03, 0xF0, 0x07, 0xFE, 0x06, 0x03, 0x86, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x11, 0x80, 0x18, 0x60,
  0x18, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x60, 0x07, 0x60, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x05, 0x38, 0x1D,
  0x1F, 0xF9, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x86, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x08, 0x70, 0x1C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF0,
  0x7E, 0x0E, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0xFF, 0xCF, 0xFC, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x60, 0x07, 0x60,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x38,
  0x1F, 0x1F, 0xFB, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x60, 0x06, 0x38, 0x0C, 0x1F, 0xF8, 0x07,
  0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x0F, 0x84, 0x7F, 0xC9,
  0x81, 0xD6, 0x01, 0xA8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x7D, 0x80, 0x00, 0x0D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x03, 0x07, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x0E, 0xFC, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x34, 0x00, 0xC8, 0x03, 0x10, 0x0E, 0x20, 0x38, 0x40, 0x60, 0x81, 0x81,
  0x06, 0x02, 0x18, 0x04, 0x60, 0x09, 0x80, 0x17, 0x80, 0x2D, 0x80, 0x73,
  0x00, 0xC3, 0x01, 0x03, 0x02, 0x06, 0x04, 0x06, 0x08, 0x06, 0x10, 0x0E,
  0x20, 0x0C, 0x40, 0x0C, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0xF0, 0x0F, 0xC3, 0x1F,
  0xF0, 0xFF, 0xCC, 0xC0, 0xE7, 0x03, 0x36, 0x01, 0x90, 0x06, 0xD0, 0x02,
  0xC0, 0x1B, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x0C, 0x83, 0xE1, 0x1F, 0xF2, 0x60, 0x75, 0x80,
  0x6A, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x07, 0xF0, 0x0F, 0xFC, 0x0E, 0x03, 0x86, 0x00,
  0xC6, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x66, 0x00,
  0x31, 0x80, 0x30, 0xE0, 0x30, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x87, 0xE0,
  0x9F, 0xF8, 0xB0, 0x1C, 0xA0, 0x0E, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x02, 0xC0, 0x06, 0xE0, 0x0C, 0xB0, 0x1C, 0x9F, 0xF8, 0x87, 0xE0,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE1, 0x1F, 0xF1,
  0x38, 0x1B, 0x60, 0x07, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x60, 0x03, 0x60, 0x07, 0x38, 0x0F, 0x1F, 0xFB, 0x07, 0xE3, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x87, 0xC7, 0xE6, 0x16, 0x0A, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x06, 0x38, 0x0E, 0x1F, 0xFC, 0x07,
  0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xF7, 0xFE,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0F, 0xC0, 0xF8, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xEC,
  0x03, 0xDC, 0x0D, 0x9F, 0xF3, 0x0F, 0x86, 0xC0, 0x00, 0xD8, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x06, 0x20, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x40,
  0x08, 0x18, 0x06, 0x06, 0x01, 0x80, 0x80, 0x40, 0x30, 0x30, 0x0C, 0x0C,
  0x01, 0x02, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x03, 0x30, 0x07, 0x00, 0x66, 0x01, 0xA0, 0x0C, 0xC0, 0x36, 0x01,
  0x98, 0x04, 0xC0, 0x61, 0x00, 0x98, 0x0C, 0x30, 0x31, 0x01, 0x86, 0x06,
  0x30, 0x30, 0xC0, 0x86, 0x04, 0x08, 0x30, 0x41, 0x81, 0x86, 0x08, 0x30,
  0x30, 0xC1, 0x86, 0x06, 0x10, 0x30, 0x80, 0x46, 0x02, 0x30, 0x0C, 0xC0,
  0x66, 0x01, 0x98, 0x0C, 0xC0, 0x32, 0x01, 0x90, 0x02, 0xC0, 0x16, 0x00,
  0x58, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x18, 0x18, 0x06, 0x03, 0x03, 0x00, 0x61, 0x80, 0x18, 0x60, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x18, 0x06, 0x0E, 0x01, 0xC3, 0x00, 0x31, 0x80, 0x06, 0x60,
  0x01, 0x80, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x20,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x08, 0x18, 0x06, 0x06, 0x01,
  0x80, 0x80, 0x40, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x03, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01,
  0xA0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x20, 0x1C, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x38, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x07,
  0x00, 0x78, 0x07, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x01, 0xC0, 0x20, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x37, 0x0E, 0x00, 0xD8, 0x1C, 0x02, 0x40, 0x38,
  0x1B, 0x00, 0x70, 0xEC, 0x00, 0xFF, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 33, 9, 3, -33 },
  { 14, 7, 10, 13, 3, -35 },
  { 23, 21, 33, 23, 2, -33 },
  { 110, 17, 41, 23, 3, -37 },
  { 198, 25, 33, 30, 3, -33 },
  { 302, 21, 33, 25, 3, -33 },
  { 389, 2, 10, 8, 3, -35 },
  { 392, 9, 48, 13, 3, -37 },
  { 446, 9, 48, 13, 1, -37 },
  { 500, 18, 18, 20, 1, -33 },
  { 541, 19, 24, 23, 2, -28 },
  { 598, 4, 10, 9, 2, -4 },
  { 603, 9, 2, 12, 2, -16 },
  { 606, 4, 3, 11, 3, -3 },
  { 608, 14, 36, 16, 1, -33 },
  { 671, 17, 33, 23, 3, -33 },
  { 742, 10, 33, 23, 4, -33 },
  { 784, 18, 33, 23, 3, -33 },
  { 859, 18, 33, 23, 2, -33 },
  { 934, 20, 33, 23, 2, -33 },
  { 1017, 17, 33, 23, 4, -33 },
  { 1088, 17, 33, 23, 3, -33 },
  { 1159, 18, 33, 23, 2, -33 },
  { 1234, 18, 33, 23, 2, -33 },
  { 1309, 18, 33, 23, 2, -33 },
  { 1384, 3, 25, 9, 3, -25 },
  { 1394, 4, 31, 8, 2, -25 },
  { 1410, 16, 19, 21, 2, -25 },
  { 1448, 17, 11, 23, 3, -21 },
  { 1472, 16, 19, 21, 3, -25 },
  { 1510, 14, 33, 19, 2, -33 },
  { 1568, 32, 42, 37, 3, -32 },
  { 1736, 23, 33, 25, 1, -33 },
  { 1831, 18, 33, 25, 4, -33 },
  { 1906, 21, 33, 27, 3, -33 },
  { 1993, 20, 33, 27, 4, -33 },
  { 2076, 18, 33, 24, 4, -33 },
  { 2151, 18, 33, 23, 4, -33 },
  { 2226, 20, 33, 28, 4, -33 },
  { 2309, 21, 33, 29, 4, -33 },
  { 2396, 2, 33, 11, 5, -33 },
  { 2405, 17, 33, 23, 2, -33 },
  { 2476, 21, 33, 26, 4, -33 },
  { 2563, 16, 33, 22, 4, -33 },
  { 2629, 27, 33, 35, 4, -33 },
  { 2741, 21, 33, 29, 4, -33 },
  { 2828, 21, 33, 28, 3, -33 },
  { 2915, 19, 33, 25, 4, -33 },
  { 2994, 21, 39, 28, 3, -33 },
  { 3097, 20, 33, 26, 4, -33 },
  { 3180, 20, 33, 24, 2, -33 },
  { 3263, 22, 33, 25, 1, -33 },
  { 3354, 19, 33, 27, 4, -33 },
  { 3433, 23, 33, 25, 1, -33 },
  { 3528, 33, 33, 37, 2, -33 },
  { 3665, 21, 33, 25, 2, -33 },
  { 3752, 23, 33, 25, 1, -33 },
  { 3847, 20, 33, 25, 2, -33 },
  { 3930, 6, 45, 10, 4, -38 },
  { 3964, 14, 36, 16, 1, -33 },
  { 4027, 6, 45, 10, 0, -38 },
  { 4061, 13, 17, 17, 2, -33 },
  { 4089, 17, 2, 18, 0, 0 },
  { 4094, 7, 6, 13, 3, -35 },
  { 4100, 17, 25, 22, 2, -25 },
  { 4154, 16, 35, 23, 4, -35 },
  { 4224, 17, 25, 21, 2, -25 },
  { 4278, 16, 35, 23, 3, -35 },
  { 4348, 17, 25, 21, 2, -25 },
  { 4402, 12, 35, 14, 2, -35 },
  { 4455, 16, 35, 23, 3, -25 },
  { 4525, 15, 35, 23, 4, -35 },
  { 4591, 3, 34, 9, 3, -34 },
  { 4604, 8, 44, 10, -2, -34 },
  { 4648, 15, 35, 20, 4, -35 },
  { 4714, 2, 35, 9, 4, -35 },
  { 4723, 30, 25, 36, 3, -25 },
  { 4817, 15, 25, 23, 4, -25 },
  { 4864, 17, 25, 23, 3, -25 },
  { 4918, 16, 35, 23, 4, -25 },
  { 4988, 16, 35, 23, 3, -25 },
  { 5058, 9, 25, 14, 4, -25 },
  { 5087, 16, 25, 21, 2, -25 },
  { 5137, 11, 31, 14, 1, -31 },
  { 5180, 15, 25, 23, 4, -25 },
  { 5227, 18, 25, 20, 1, -25 },
  { 5284, 27, 25, 31, 2, -25 },
  { 5369, 18, 25, 20, 1, -25 },
  { 5426, 18, 35, 20, 1, -25 },
  { 5505, 17, 25, 20, 2, -25 },
  { 5559, 11, 47, 14, 2, -37 },
  { 5624, 2, 39, 10, 4, -33 },
  { 5634, 11, 47, 14, 1, -37 },
  { 5699, 22, 8, 28, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT47PT7B_H_
