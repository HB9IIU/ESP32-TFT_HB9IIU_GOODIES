#ifndef _ROBOTOCONDENSED_EXTRALIGHT17PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x14, 0x48, 0x97, 0xF2, 0x44, 0x89, 0x24,
  0xFE, 0x91, 0x22, 0x40, 0x10, 0x43, 0x91, 0x86, 0x14, 0x08, 0x18, 0x18,
  0x61, 0x85, 0xE1, 0x04, 0x60, 0x48, 0x24, 0x92, 0x89, 0x43, 0x40, 0x2C,
  0x29, 0x14, 0x92, 0x41, 0x20, 0x60, 0x38, 0x48, 0x48, 0x48, 0x50, 0x20,
  0x50, 0x92, 0x8A, 0x86, 0x86, 0x7A, 0xF0, 0x25, 0x25, 0x24, 0x92, 0x48,
  0x92, 0x24, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x22, 0x22, 0x48, 0x10,
  0x23, 0x49, 0xE1, 0x05, 0x11, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x10, 0xF0, 0xE0, 0x80, 0x08, 0x42, 0x21, 0x08, 0x84, 0x22, 0x10,
  0x88, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x14, 0x4E, 0x3D,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x7A, 0x18, 0x61, 0x04, 0x20, 0x84, 0x21,
  0x04, 0x3F, 0x7A, 0x18, 0x41, 0x04, 0xE0, 0x41, 0x86, 0x18, 0x5E, 0x08,
  0x30, 0x61, 0x42, 0x89, 0x12, 0x44, 0xFE, 0x10, 0x20, 0x40, 0x7D, 0x04,
  0x10, 0x78, 0x10, 0x41, 0x06, 0x14, 0x4E, 0x19, 0x84, 0x20, 0xBB, 0x18,
  0x61, 0x86, 0x14, 0x4E, 0xFC, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82,
  0x10, 0x7A, 0x18, 0x61, 0x85, 0xE4, 0x61, 0x86, 0x18, 0x5E, 0x7A, 0x18,
  0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0x9C, 0x80, 0x80, 0x80, 0xF0, 0x0C,
  0x46, 0x20, 0x60, 0x40, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81,
  0x19, 0x88, 0x00, 0x74, 0x62, 0x10, 0x88, 0x44, 0x20, 0x00, 0x40, 0x0F,
  0x83, 0x04, 0x40, 0x24, 0x02, 0x87, 0x18, 0x91, 0x91, 0x19, 0x11, 0x91,
  0x19, 0x12, 0x93, 0x28, 0xCC, 0x80, 0x04, 0x00, 0x20, 0x01, 0xF0, 0x08,
  0x04, 0x05, 0x02, 0x81, 0x21, 0x10, 0x88, 0x7C, 0x41, 0x20, 0x90, 0x50,
  0x10, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0xA1, 0x86, 0x18, 0x7E, 0x3C, 0x42,
  0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x42, 0x3C, 0xF9, 0x0A,
  0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x17, 0xC0, 0xFE, 0x08, 0x20,
  0x83, 0xE8, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20,
  0x82, 0x08, 0x20, 0x3C, 0x42, 0x81, 0x80, 0x80, 0x80, 0x8F, 0x81, 0x81,
  0x81, 0x41, 0x3E, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0xFF, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x86, 0x18,
  0x9C, 0x85, 0x12, 0x24, 0x8A, 0x18, 0x28, 0x48, 0x91, 0x12, 0x14, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x80, 0xC0, 0x60, 0x78,
  0x3C, 0x2D, 0x16, 0x8B, 0x49, 0x94, 0xCA, 0x66, 0x31, 0x10, 0x83, 0x07,
  0x0E, 0x1A, 0x34, 0x64, 0xC5, 0x8B, 0x0E, 0x1C, 0x10, 0x3C, 0x42, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFA, 0x18, 0x61,
  0x86, 0x1F, 0xA0, 0x82, 0x08, 0x20, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x02, 0x01, 0xFC, 0x82, 0x82, 0x82,
  0x82, 0x82, 0xFC, 0x88, 0x84, 0x84, 0x82, 0x81, 0x7D, 0x06, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x83, 0x06, 0x0B, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x05, 0x09, 0xE0, 0x80, 0xA0, 0x90, 0x48, 0x22, 0x21, 0x10,
  0x88, 0x28, 0x14, 0x0A, 0x02, 0x01, 0x00, 0x84, 0x18, 0x41, 0x8A, 0x28,
  0xA2, 0x8A, 0x24, 0x92, 0x51, 0x45, 0x14, 0x51, 0x43, 0x0C, 0x20, 0x82,
  0x08, 0x83, 0x05, 0x11, 0x42, 0x82, 0x04, 0x14, 0x44, 0x8A, 0x0C, 0x10,
  0x81, 0x20, 0x90, 0x84, 0x42, 0x40, 0xA0, 0x60, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFE, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x07,
  0xF0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x88, 0x88, 0x44, 0x42,
  0x22, 0x11, 0x10, 0xD5, 0x55, 0x55, 0x55, 0xC0, 0x26, 0x69, 0x99, 0xFC,
  0x90, 0x7A, 0x18, 0x41, 0x7E, 0x18, 0x63, 0x74, 0x82, 0x08, 0x20, 0xBB,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xF8, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x61,
  0x78, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x7A,
  0x18, 0x7F, 0x82, 0x08, 0x20, 0x78, 0x34, 0x44, 0xE4, 0x44, 0x44, 0x44,
  0x40, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x5E, 0x82, 0x08,
  0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x9F, 0xF0, 0x20, 0x12,
  0x49, 0x24, 0x92, 0x70, 0x82, 0x08, 0x20, 0x8A, 0x29, 0x28, 0xE2, 0x49,
  0x22, 0x84, 0xFF, 0xF8, 0xB9, 0xD8, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84,
  0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xBB, 0x18, 0x61, 0x86, 0x18,
  0x61, 0xFA, 0x08, 0x20, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10,
  0x41, 0xBC, 0x88, 0x88, 0x88, 0x80, 0x7A, 0x28, 0x10, 0x30, 0x20, 0x61,
  0x78, 0x22, 0xF2, 0x22, 0x22, 0x22, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x7C, 0x82, 0x89, 0x12, 0x22, 0x45, 0x0A, 0x08, 0x10, 0x88, 0xC4,
  0x65, 0x32, 0x95, 0x4A, 0x99, 0x8C, 0x46, 0x22, 0x00, 0x8A, 0x25, 0x0C,
  0x21, 0x45, 0x22, 0x84, 0x82, 0x89, 0x12, 0x22, 0x85, 0x0A, 0x08, 0x10,
  0x20, 0x83, 0x00, 0xF8, 0x21, 0x04, 0x21, 0x04, 0x20, 0xFC, 0x12, 0x44,
  0x44, 0x44, 0x84, 0x44, 0x44, 0x42, 0x10, 0xFF, 0xFC, 0x84, 0x22, 0x22,
  0x22, 0x12, 0x22, 0x22, 0x24, 0x80, 0x71, 0x89, 0x86,
};

const GFXglyph RobotoCondensed_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 3, 4, 5, 1, -13 },
  { 5, 7, 12, 8, 1, -12 },
  { 16, 6, 16, 8, 1, -14 },
  { 28, 9, 12, 11, 1, -12 },
  { 42, 8, 12, 9, 1, -12 },
  { 54, 1, 4, 3, 1, -13 },
  { 55, 3, 18, 5, 1, -14 },
  { 62, 4, 18, 5, 0, -14 },
  { 71, 7, 7, 7, 0, -12 },
  { 78, 7, 9, 8, 1, -10 },
  { 86, 1, 4, 3, 1, -1 },
  { 87, 3, 1, 5, 1, -6 },
  { 88, 1, 1, 4, 1, -1 },
  { 89, 5, 13, 6, 0, -12 },
  { 98, 6, 12, 8, 1, -12 },
  { 107, 4, 12, 8, 1, -12 },
  { 113, 6, 12, 8, 1, -12 },
  { 122, 6, 12, 8, 1, -12 },
  { 131, 7, 12, 8, 1, -12 },
  { 142, 6, 12, 8, 1, -12 },
  { 151, 6, 12, 8, 1, -12 },
  { 160, 6, 12, 8, 1, -12 },
  { 169, 6, 12, 8, 1, -12 },
  { 178, 6, 12, 8, 1, -12 },
  { 187, 1, 9, 3, 1, -9 },
  { 189, 1, 12, 3, 1, -9 },
  { 191, 6, 7, 8, 1, -9 },
  { 197, 6, 5, 8, 1, -8 },
  { 201, 6, 7, 8, 1, -9 },
  { 207, 5, 12, 7, 1, -12 },
  { 215, 12, 16, 14, 1, -12 },
  { 239, 9, 12, 9, 0, -12 },
  { 253, 6, 12, 9, 2, -12 },
  { 262, 8, 12, 10, 1, -12 },
  { 274, 7, 12, 10, 2, -12 },
  { 285, 6, 12, 9, 2, -12 },
  { 294, 6, 12, 8, 2, -12 },
  { 303, 8, 12, 10, 1, -12 },
  { 315, 7, 12, 10, 2, -12 },
  { 326, 1, 12, 4, 2, -12 },
  { 328, 6, 12, 8, 1, -12 },
  { 337, 7, 12, 9, 2, -12 },
  { 348, 5, 12, 8, 2, -12 },
  { 356, 9, 12, 13, 2, -12 },
  { 370, 7, 12, 11, 2, -12 },
  { 381, 8, 12, 10, 1, -12 },
  { 393, 6, 12, 9, 2, -12 },
  { 402, 8, 14, 10, 1, -12 },
  { 416, 8, 12, 10, 1, -12 },
  { 428, 7, 12, 9, 1, -12 },
  { 439, 7, 12, 9, 1, -12 },
  { 450, 7, 12, 10, 1, -12 },
  { 461, 9, 12, 9, 0, -12 },
  { 475, 12, 12, 13, 1, -12 },
  { 493, 7, 12, 9, 1, -12 },
  { 504, 9, 12, 9, 0, -12 },
  { 518, 7, 12, 9, 1, -12 },
  { 529, 3, 17, 4, 1, -14 },
  { 536, 4, 13, 6, 1, -12 },
  { 543, 2, 17, 4, 0, -14 },
  { 548, 4, 6, 6, 1, -12 },
  { 551, 6, 1, 6, 0, 0 },
  { 552, 2, 2, 5, 1, -13 },
  { 553, 6, 9, 8, 1, -9 },
  { 560, 6, 13, 8, 1, -13 },
  { 570, 6, 9, 8, 1, -9 },
  { 577, 6, 13, 8, 1, -13 },
  { 587, 6, 9, 8, 1, -9 },
  { 594, 4, 13, 5, 1, -13 },
  { 601, 6, 12, 8, 1, -9 },
  { 610, 6, 13, 8, 1, -13 },
  { 620, 1, 12, 3, 1, -12 },
  { 622, 3, 15, 4, -1, -12 },
  { 628, 6, 13, 7, 1, -13 },
  { 638, 1, 13, 3, 1, -13 },
  { 640, 11, 9, 13, 1, -9 },
  { 653, 6, 9, 8, 1, -9 },
  { 660, 6, 9, 8, 1, -9 },
  { 667, 6, 12, 8, 1, -9 },
  { 676, 6, 12, 8, 1, -9 },
  { 685, 4, 9, 5, 1, -9 },
  { 690, 6, 9, 8, 1, -9 },
  { 697, 4, 11, 5, 0, -11 },
  { 703, 6, 9, 8, 1, -9 },
  { 710, 7, 9, 7, 0, -9 },
  { 718, 9, 9, 11, 1, -9 },
  { 729, 6, 9, 7, 1, -9 },
  { 736, 7, 12, 7, 0, -9 },
  { 747, 6, 9, 7, 1, -9 },
  { 754, 4, 17, 5, 1, -13 },
  { 763, 1, 14, 4, 1, -12 },
  { 765, 4, 17, 5, 0, -13 },
  { 774, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT17PT7B_H_
