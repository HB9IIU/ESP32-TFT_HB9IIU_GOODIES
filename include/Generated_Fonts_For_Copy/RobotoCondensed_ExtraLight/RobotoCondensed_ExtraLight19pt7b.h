#ifndef _ROBOTOCONDENSED_EXTRALIGHT19PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x12, 0xFF, 0x22, 0x24,
  0x24, 0x24, 0xFF, 0x24, 0x44, 0x48, 0x48, 0x10, 0x20, 0xF2, 0x18, 0x30,
  0x60, 0x20, 0x30, 0x18, 0x08, 0x18, 0x30, 0x50, 0x9E, 0x10, 0x20, 0x70,
  0x24, 0x08, 0x92, 0x28, 0x92, 0x1D, 0x00, 0x40, 0x20, 0x09, 0x84, 0x91,
  0x24, 0x89, 0x22, 0x40, 0x60, 0x38, 0x22, 0x11, 0x08, 0x84, 0x81, 0x80,
  0x80, 0xA0, 0x89, 0x42, 0xA1, 0x50, 0x44, 0x31, 0xE8, 0xF0, 0x12, 0x24,
  0x44, 0x88, 0x88, 0x88, 0x84, 0x44, 0x22, 0x10, 0x84, 0x22, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x24, 0x80, 0x08, 0x08, 0xCB, 0x3C, 0x18, 0x24,
  0x42, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xF0, 0xE0, 0xC0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10,
  0x41, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x14, 0x47, 0x00, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x38,
  0x8A, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x1F, 0xC0,
  0x38, 0x8A, 0x0C, 0x10, 0x20, 0x8E, 0x02, 0x02, 0x06, 0x0C, 0x14, 0x27,
  0x80, 0x04, 0x0C, 0x0C, 0x14, 0x24, 0x24, 0x44, 0x44, 0x84, 0xFF, 0x04,
  0x04, 0x04, 0x04, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x41, 0x04, 0x18, 0x61,
  0x85, 0xE0, 0x1C, 0x41, 0x02, 0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0C,
  0x14, 0x47, 0x00, 0xFE, 0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x28, 0x8E, 0x22, 0x83,
  0x06, 0x0C, 0x14, 0x27, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xA3,
  0x3A, 0x04, 0x08, 0x20, 0x86, 0x00, 0x80, 0x40, 0x80, 0xF0, 0x04, 0x62,
  0x30, 0xC0, 0x81, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60,
  0x20, 0x43, 0x18, 0x40, 0x72, 0x28, 0x41, 0x04, 0x20, 0x84, 0x20, 0x80,
  0x00, 0x00, 0x80, 0x0F, 0xC0, 0x81, 0x08, 0x04, 0x80, 0x14, 0x38, 0xC2,
  0x46, 0x22, 0x31, 0x11, 0x88, 0x8C, 0x84, 0x64, 0x23, 0x13, 0x28, 0xE6,
  0x20, 0x01, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x04, 0x03, 0x00, 0xC0, 0x48,
  0x12, 0x04, 0x81, 0x10, 0x84, 0x21, 0x0F, 0xC4, 0x09, 0x02, 0x40, 0xA0,
  0x10, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x42, 0x83, 0x06, 0x0C, 0x18,
  0x3F, 0x80, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x28, 0x24, 0x11, 0xF0, 0xF8, 0x84, 0x82, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x1E, 0x30,
  0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x50, 0x28, 0x12,
  0x18, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x06, 0x0C, 0x28, 0x4F, 0x00, 0x82, 0x84, 0x84, 0x88, 0x90,
  0xA0, 0xE0, 0xD0, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x5C, 0x0B, 0x42, 0x68, 0x4D, 0x09, 0x92, 0x32, 0x46, 0x48, 0xC6,
  0x18, 0xC3, 0x08, 0x40, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89,
  0x89, 0x85, 0x85, 0x83, 0x81, 0x81, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x24, 0x11, 0xF0, 0xFD, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFE, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x3E,
  0x20, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28,
  0x24, 0x11, 0xF0, 0x04, 0x01, 0xF8, 0x86, 0x82, 0x82, 0x82, 0x82, 0x84,
  0xF8, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x3C, 0x42, 0x81, 0x81, 0x80,
  0x40, 0x38, 0x04, 0x02, 0x01, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x2F, 0x80,
  0x80, 0x50, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10, 0x44, 0x12, 0x04,
  0x81, 0x20, 0x30, 0x0C, 0x01, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x43, 0x0A,
  0x18, 0x51, 0x22, 0x89, 0x22, 0x49, 0x12, 0x48, 0x91, 0x45, 0x0C, 0x28,
  0x60, 0xC3, 0x06, 0x10, 0x20, 0x81, 0x41, 0x42, 0x24, 0x24, 0x18, 0x18,
  0x18, 0x18, 0x24, 0x42, 0x42, 0x81, 0x81, 0x40, 0x90, 0x22, 0x10, 0x84,
  0x22, 0x04, 0x81, 0x20, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x80, 0xFF, 0xEA, 0xAA, 0xAA, 0xAA, 0xB0, 0x84, 0x20, 0x84, 0x20,
  0x84, 0x21, 0x04, 0x21, 0x04, 0x20, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x3C, 0x23, 0x14, 0xA5, 0x46, 0x20, 0xFE, 0x88, 0x80, 0x79, 0x0A, 0x08,
  0x17, 0xD0, 0x60, 0xC1, 0x84, 0xF4, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x37, 0x80, 0x79, 0x0A, 0x0C, 0x18, 0x10,
  0x20, 0x41, 0x84, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x14, 0x67, 0x40, 0x38, 0x8A, 0x0C, 0x1F, 0xF0, 0x20, 0x40,
  0x40, 0x78, 0x32, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x3A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0x74, 0x08, 0x14, 0x47, 0x00,
  0x81, 0x02, 0x04, 0x0B, 0xD8, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x40, 0x9F, 0xF8, 0x20, 0x12, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x51, 0x24, 0x50, 0xA1, 0xA2, 0x44, 0x48, 0x50, 0x40, 0xFF,
  0xFC, 0xBC, 0xEC, 0x51, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18,
  0x21, 0x82, 0x18, 0x21, 0xBD, 0x8B, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x04, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0x78, 0xBD, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x7A, 0x04, 0x08, 0x10, 0x00, 0x3A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0x74, 0x08, 0x10, 0x20, 0x40,
  0xBC, 0x88, 0x88, 0x88, 0x88, 0x7A, 0x18, 0x70, 0x30, 0x20, 0x61, 0x85,
  0xE0, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x41, 0x80, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0x74, 0x41, 0x42, 0x42, 0x42, 0x24,
  0x24, 0x24, 0x18, 0x18, 0x10, 0x84, 0x31, 0x8A, 0x31, 0x45, 0x25, 0x24,
  0xA5, 0x14, 0xA2, 0x8C, 0x21, 0x84, 0x20, 0x84, 0x89, 0x21, 0x83, 0x06,
  0x0A, 0x24, 0x85, 0x08, 0x41, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18,
  0x18, 0x08, 0x10, 0x10, 0x10, 0x60, 0xFC, 0x08, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x81, 0xFC, 0x12, 0x22, 0x44, 0x44, 0x48, 0x44, 0x44, 0x44, 0x22,
  0x10, 0xFF, 0xFF, 0x80, 0x82, 0x08, 0x42, 0x10, 0x84, 0x10, 0x44, 0x42,
  0x10, 0x84, 0x22, 0x20, 0x70, 0xC4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 1, -14 },
  { 3, 3, 4, 5, 1, -14 },
  { 5, 8, 14, 9, 1, -14 },
  { 19, 7, 18, 9, 1, -16 },
  { 35, 10, 14, 12, 1, -14 },
  { 53, 9, 14, 10, 1, -14 },
  { 69, 1, 4, 3, 1, -14 },
  { 70, 4, 19, 5, 1, -15 },
  { 80, 4, 19, 5, 0, -15 },
  { 90, 8, 7, 8, 0, -14 },
  { 97, 8, 11, 9, 1, -12 },
  { 108, 1, 4, 4, 1, -2 },
  { 109, 3, 1, 5, 1, -7 },
  { 110, 2, 1, 4, 1, -1 },
  { 111, 6, 15, 7, 0, -14 },
  { 123, 7, 14, 9, 1, -14 },
  { 136, 4, 14, 9, 2, -14 },
  { 143, 7, 14, 9, 1, -14 },
  { 156, 7, 14, 9, 1, -14 },
  { 169, 8, 14, 9, 1, -14 },
  { 183, 6, 14, 9, 2, -14 },
  { 194, 7, 14, 9, 1, -14 },
  { 207, 7, 14, 9, 1, -14 },
  { 220, 7, 14, 9, 1, -14 },
  { 233, 7, 14, 9, 1, -14 },
  { 246, 1, 10, 4, 1, -10 },
  { 248, 1, 12, 3, 1, -10 },
  { 250, 6, 8, 9, 1, -10 },
  { 256, 7, 5, 9, 1, -9 },
  { 261, 7, 8, 9, 1, -10 },
  { 268, 6, 14, 8, 1, -14 },
  { 279, 13, 17, 15, 1, -13 },
  { 307, 10, 14, 10, 0, -14 },
  { 325, 7, 14, 10, 2, -14 },
  { 338, 9, 14, 11, 1, -14 },
  { 354, 8, 14, 11, 2, -14 },
  { 368, 7, 14, 10, 2, -14 },
  { 381, 7, 14, 9, 2, -14 },
  { 394, 9, 14, 11, 1, -14 },
  { 410, 8, 14, 12, 2, -14 },
  { 424, 1, 14, 5, 2, -14 },
  { 426, 7, 14, 9, 1, -14 },
  { 439, 8, 14, 11, 2, -14 },
  { 453, 6, 14, 9, 2, -14 },
  { 464, 11, 14, 14, 2, -14 },
  { 484, 8, 14, 12, 2, -14 },
  { 498, 9, 14, 11, 1, -14 },
  { 514, 7, 14, 10, 2, -14 },
  { 527, 9, 16, 11, 1, -14 },
  { 545, 8, 14, 11, 2, -14 },
  { 559, 8, 14, 10, 1, -14 },
  { 573, 8, 14, 10, 1, -14 },
  { 587, 7, 14, 11, 2, -14 },
  { 600, 10, 14, 10, 0, -14 },
  { 618, 13, 14, 15, 1, -14 },
  { 641, 8, 14, 10, 1, -14 },
  { 655, 10, 14, 10, 0, -14 },
  { 673, 8, 14, 10, 1, -14 },
  { 687, 2, 18, 4, 2, -15 },
  { 692, 5, 15, 7, 1, -14 },
  { 702, 3, 18, 4, 0, -15 },
  { 709, 5, 7, 7, 1, -14 },
  { 714, 7, 1, 7, 0, 0 },
  { 715, 3, 3, 5, 1, -15 },
  { 717, 7, 10, 9, 1, -10 },
  { 726, 7, 14, 9, 1, -14 },
  { 739, 7, 10, 9, 1, -10 },
  { 748, 7, 14, 9, 1, -14 },
  { 761, 7, 10, 9, 1, -10 },
  { 770, 5, 14, 6, 1, -14 },
  { 779, 7, 14, 9, 1, -10 },
  { 792, 7, 14, 9, 1, -14 },
  { 805, 1, 13, 4, 1, -13 },
  { 807, 3, 17, 4, -1, -13 },
  { 814, 7, 14, 8, 1, -14 },
  { 827, 1, 14, 4, 1, -14 },
  { 829, 12, 10, 15, 1, -10 },
  { 844, 7, 10, 9, 1, -10 },
  { 853, 7, 10, 9, 1, -10 },
  { 862, 7, 14, 9, 1, -10 },
  { 875, 7, 14, 9, 1, -10 },
  { 888, 4, 10, 6, 1, -10 },
  { 893, 6, 10, 8, 1, -10 },
  { 901, 5, 13, 5, 0, -13 },
  { 910, 7, 10, 9, 1, -10 },
  { 919, 8, 10, 8, 0, -10 },
  { 929, 11, 10, 13, 1, -10 },
  { 943, 7, 10, 8, 1, -10 },
  { 952, 8, 14, 8, 0, -10 },
  { 966, 7, 10, 8, 1, -10 },
  { 975, 4, 19, 6, 1, -15 },
  { 985, 1, 17, 4, 2, -14 },
  { 988, 5, 19, 6, 0, -15 },
  { 1000, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT19PT7B_H_
