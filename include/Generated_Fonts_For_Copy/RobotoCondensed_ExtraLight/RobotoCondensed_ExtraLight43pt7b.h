#ifndef _ROBOTOCONDENSED_EXTRALIGHT43PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x00, 0x0D,
  0xF0, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x84, 0x00, 0x81, 0x00, 0x30,
  0x20, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40,
  0xC0, 0x08, 0x10, 0x03, 0x02, 0x0F, 0xFF, 0xFC, 0x0C, 0x08, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x04, 0x08, 0x01, 0x81, 0x00, 0x30, 0x20, 0x06, 0x04,
  0x00, 0x81, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40, 0x81, 0xFF, 0xFF,
  0x83, 0x02, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x01, 0x03, 0x00, 0x20, 0x40,
  0x0C, 0x08, 0x01, 0x81, 0x00, 0x30, 0x20, 0x04, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x18, 0x0C,
  0x30, 0x06, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x60, 0x01, 0x60, 0x01,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x03, 0x60, 0x03,
  0x30, 0x06, 0x18, 0x0E, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x01, 0x82, 0x00,
  0x02, 0x06, 0x00, 0x04, 0x04, 0x06, 0x18, 0x08, 0x08, 0x30, 0x10, 0x30,
  0x60, 0x20, 0xC0, 0xC0, 0x41, 0x00, 0x80, 0x86, 0x01, 0x03, 0x08, 0x03,
  0x04, 0x30, 0x03, 0xB8, 0x40, 0x03, 0xC1, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x87, 0x70, 0x03,
  0x18, 0x30, 0x0C, 0x20, 0x20, 0x10, 0x40, 0x40, 0x60, 0x80, 0x80, 0x81,
  0x01, 0x03, 0x02, 0x02, 0x04, 0x04, 0x04, 0x18, 0x08, 0x08, 0x20, 0x10,
  0x10, 0x00, 0x30, 0x60, 0x00, 0x3B, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x00,
  0xC0, 0x10, 0x0C, 0x01, 0x00, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x08,
  0x30, 0x00, 0xC6, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xD8, 0x00, 0x18, 0x80, 0x03, 0x0C, 0x06, 0x30, 0x60, 0x66, 0x03, 0x06,
  0x40, 0x30, 0x64, 0x01, 0x84, 0xC0, 0x0C, 0xCC, 0x00, 0x6C, 0xC0, 0x06,
  0x84, 0x00, 0x38, 0x60, 0x03, 0x86, 0x00, 0x68, 0x38, 0x0C, 0xC1, 0xFF,
  0x86, 0x07, 0xE0, 0x30, 0xFF, 0x80, 0x01, 0x03, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40,
  0x40, 0x60, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x86,
  0x1C, 0xFB, 0x3C, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0x63, 0x00, 0x61, 0x80, 0x60, 0x60, 0x30, 0x18, 0x10, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x24, 0x96,
  0xDE, 0x80, 0xFF, 0x80, 0x5F, 0x80, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xC0, 0xE1, 0x00, 0xC6, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x80, 0x09, 0x80, 0x31,
  0x00, 0xC3, 0x03, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0x07, 0x3D, 0xF1,
  0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x07, 0xE0, 0x07, 0xFC, 0x06, 0x07, 0x06, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x31, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0x03, 0xE0, 0x0F,
  0xF8, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x1C, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x03, 0x60, 0x03, 0x30, 0x06, 0x38, 0x0C, 0x0F, 0xF8, 0x03, 0xE0, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x13,
  0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0,
  0x08, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1F, 0xFE, 0x3F,
  0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x27, 0xE0, 0x2F, 0xF8, 0x70,
  0x1C, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60,
  0x02, 0x60, 0x06, 0x30, 0x04, 0x38, 0x0C, 0x0F, 0xF8, 0x07, 0xE0, 0x00,
  0xF0, 0x03, 0xF0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC7, 0xE0, 0xCF,
  0xF0, 0x98, 0x18, 0xA0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0x40, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x38, 0x18, 0x0F, 0xF0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x06,
  0x03, 0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x60, 0xC0,
  0x60, 0x3F, 0xE0, 0x0F, 0xE0, 0x1C, 0x1C, 0x18, 0x03, 0x18, 0x00, 0xCC,
  0x00, 0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xA0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0xC3, 0x80, 0xE0, 0xFF, 0xE0, 0x1F,
  0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x18, 0x1C, 0x30, 0x0C, 0x20, 0x06, 0x60,
  0x06, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x07, 0x30,
  0x0F, 0x18, 0x1B, 0x0F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x0F,
  0xC0, 0x0F, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xF0,
  0x67, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66,
  0x64, 0xC8, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0x0C, 0x0C, 0xC0, 0x64,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x40, 0x0F, 0x80, 0x63, 0x00, 0x77,
  0x00, 0x8C, 0x03, 0x06, 0x02, 0x20, 0x18, 0x18, 0x09, 0x80, 0xC0, 0x60,
  0x26, 0x02, 0x01, 0x80, 0xD8, 0x18, 0x06, 0x03, 0x40, 0x60, 0x18, 0x0D,
  0x01, 0x00, 0x40, 0x34, 0x04, 0x01, 0x00, 0xD0, 0x10, 0x04, 0x03, 0x40,
  0x40, 0x10, 0x0D, 0x03, 0x00, 0x40, 0x24, 0x0C, 0x01, 0x00, 0x90, 0x30,
  0x0C, 0x02, 0x40, 0x40, 0x30, 0x19, 0x01, 0x00, 0xC0, 0x44, 0x06, 0x05,
  0x03, 0x18, 0x18, 0x36, 0x08, 0x60, 0x3F, 0x8C, 0xC0, 0x80, 0x78, 0x1E,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x0D, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x20,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x40, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x01, 0x18, 0x00,
  0x0C, 0xC0, 0x00, 0x64, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0xFF, 0xE0, 0x7F, 0xFC, 0x20, 0x07, 0x10, 0x01, 0x88, 0x00, 0x64, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90,
  0x00, 0xC8, 0x00, 0x44, 0x00, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0x80, 0x1C,
  0x40, 0x03, 0x20, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x14, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0xC8,
  0x00, 0xE7, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70,
  0x0C, 0x18, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x16, 0x00,
  0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00,
  0x1A, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00,
  0xC1, 0xC0, 0x30, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFE,
  0x08, 0x01, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x1A,
  0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x18, 0x80,
  0x1C, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x70, 0x0E, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x00,
  0xD8, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x50, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00, 0x04,
  0xC0, 0x00, 0x8C, 0x00, 0x70, 0xC0, 0x1C, 0x0F, 0xFE, 0x00, 0x7F, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00,
  0x33, 0x00, 0x63, 0x01, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x80, 0x01, 0xA0,
  0x00, 0xC8, 0x00, 0x72, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x03,
  0x02, 0x01, 0xC0, 0x80, 0x60, 0x20, 0x30, 0x08, 0x18, 0x02, 0x0C, 0x00,
  0x86, 0x00, 0x21, 0x80, 0x08, 0xE0, 0x02, 0x6C, 0x00, 0xB3, 0x00, 0x38,
  0x60, 0x0C, 0x0C, 0x02, 0x03, 0x00, 0x80, 0x60, 0x20, 0x0C, 0x08, 0x03,
  0x02, 0x00, 0x60, 0x80, 0x0C, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x0C,
  0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xA0,
  0x00, 0x05, 0xB0, 0x00, 0x0D, 0xB0, 0x00, 0x0D, 0x90, 0x00, 0x09, 0x98,
  0x00, 0x19, 0x98, 0x00, 0x19, 0x88, 0x00, 0x11, 0x8C, 0x00, 0x31, 0x8C,
  0x00, 0x31, 0x84, 0x00, 0x21, 0x86, 0x00, 0x61, 0x82, 0x00, 0x61, 0x82,
  0x00, 0x41, 0x83, 0x00, 0xC1, 0x81, 0x00, 0xC1, 0x81, 0x80, 0x81, 0x81,
  0x81, 0x81, 0x80, 0x81, 0x01, 0x80, 0xC3, 0x01, 0x80, 0xC3, 0x01, 0x80,
  0x42, 0x01, 0x80, 0x66, 0x01, 0x80, 0x66, 0x01, 0x80, 0x24, 0x01, 0x80,
  0x3C, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD0, 0x00, 0x3B, 0x00, 0x07, 0x30,
  0x00, 0xE6, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x08,
  0x01, 0xC1, 0x80, 0x38, 0x18, 0x07, 0x03, 0x00, 0xE0, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0x60, 0x70, 0x04, 0x0E, 0x00, 0xC1, 0xC0, 0x08, 0x38, 0x01,
  0x87, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x33, 0x80, 0x06, 0x70, 0x00,
  0x6E, 0x00, 0x05, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x18, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x0C, 0x18, 0x00, 0xC6, 0x00,
  0x0C, 0xC0, 0x01, 0x90, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00,
  0x6C, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0xC1, 0xC0, 0x30, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x20, 0x03, 0x90, 0x00, 0xC8,
  0x00, 0x34, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x1D, 0x00,
  0x1C, 0xFF, 0xFC, 0x7F, 0xF8, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x70, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x90,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x19, 0x80,
  0x03, 0x18, 0x00, 0xC1, 0xC0, 0x30, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x20, 0xFF,
  0xE0, 0x3F, 0xFE, 0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00,
  0xC8, 0x00, 0x12, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x1A,
  0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x62, 0x00, 0x30, 0xFF,
  0xF8, 0x3F, 0xF8, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x06,
  0x08, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0x32,
  0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0C, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0x80, 0x70, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x34, 0x00,
  0x0D, 0x00, 0x03, 0x40, 0x00, 0x58, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x06,
  0x18, 0x03, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x08, 0xC0, 0x06, 0x18, 0x07, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x10, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x40, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x04, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x10, 0x00, 0x80,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x80, 0x03, 0x00, 0x0D, 0x80, 0x0E, 0x00, 0x1B, 0x00, 0x1E, 0x00,
  0x26, 0x00, 0x2C, 0x00, 0xC4, 0x00, 0x48, 0x01, 0x8C, 0x01, 0x90, 0x03,
  0x18, 0x03, 0x20, 0x06, 0x30, 0x04, 0x60, 0x08, 0x20, 0x08, 0x40, 0x30,
  0x40, 0x30, 0x80, 0x60, 0xC0, 0x61, 0x00, 0xC1, 0x80, 0x83, 0x01, 0x03,
  0x01, 0x02, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x06, 0x0C, 0x08, 0x18, 0x0C,
  0x10, 0x18, 0x30, 0x18, 0x20, 0x30, 0x40, 0x10, 0xC0, 0x21, 0x80, 0x21,
  0x80, 0x43, 0x00, 0x62, 0x00, 0xC6, 0x00, 0xC4, 0x01, 0x88, 0x01, 0x98,
  0x01, 0x10, 0x01, 0x30, 0x02, 0x60, 0x02, 0x60, 0x06, 0xC0, 0x06, 0x80,
  0x0D, 0x80, 0x0D, 0x00, 0x0A, 0x00, 0x1E, 0x00, 0x14, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x32, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0xC0,
  0x18, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x02, 0x06, 0x00, 0x30, 0x60, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x00, 0xD8, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x98, 0x00, 0x18, 0xC0,
  0x03, 0x04, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01,
  0x80, 0x80, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x66, 0x00,
  0x03, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x60, 0x02, 0x01, 0x00,
  0x30, 0x0C, 0x01, 0x00, 0x20, 0x18, 0x01, 0x80, 0x80, 0x04, 0x0C, 0x00,
  0x30, 0x40, 0x00, 0x86, 0x00, 0x06, 0x20, 0x00, 0x13, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0xFF, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xB0, 0x09, 0x01,
  0x90, 0x11, 0x81, 0x08, 0x30, 0x82, 0x0C, 0x60, 0x46, 0x06, 0x40, 0x6C,
  0x02, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x82, 0x0C, 0x18, 0x20,
  0x07, 0xE0, 0x3F, 0xF0, 0xC0, 0x73, 0x00, 0x66, 0x00, 0x68, 0x00, 0xD0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x1F, 0xF8, 0xF8, 0x33, 0x00,
  0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3A,
  0x00, 0xF6, 0x03, 0x67, 0xFC, 0xC7, 0xE1, 0x80, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x8F, 0xC3, 0x3F, 0xE6, 0x80, 0xEE, 0x00, 0xDC, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x2E, 0x00, 0xDE, 0x03, 0x37, 0xFE, 0x63, 0xF0, 0x07, 0xE0, 0x3F, 0xF0,
  0xC0, 0x31, 0x00, 0x26, 0x00, 0x68, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x02, 0x80, 0x05, 0x80, 0x19, 0x00, 0x33, 0x80, 0xC3,
  0xFF, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3,
  0x1F, 0xF3, 0x38, 0x1B, 0x30, 0x07, 0x60, 0x07, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x07,
  0x30, 0x07, 0x38, 0x0B, 0x1F, 0xF3, 0x07, 0xE3, 0x07, 0xE0, 0x1F, 0xF8,
  0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x0E, 0x0F, 0xFC, 0x03, 0xF0, 0x03, 0xC3, 0xF0, 0xC0, 0x60, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x07, 0xE3,
  0x1F, 0xF3, 0x38, 0x1B, 0x30, 0x07, 0x60, 0x07, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x07,
  0x30, 0x07, 0x38, 0x0B, 0x1F, 0xF3, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x20, 0x06, 0x38, 0x0C, 0x1F, 0xF8,
  0x07, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x87, 0xC3, 0x3F, 0xC6, 0xC0,
  0xCD, 0x00, 0xDC, 0x01, 0xB8, 0x01, 0x60, 0x02, 0xC0, 0x05, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x5F, 0x00, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x02, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0xFC, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x1B, 0x00, 0x66, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x30, 0x60, 0x61,
  0x80, 0xC3, 0x01, 0x8C, 0x03, 0x30, 0x06, 0xE0, 0x0F, 0x60, 0x1C, 0x40,
  0x30, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x86, 0x01, 0x8C,
  0x03, 0x18, 0x03, 0x30, 0x03, 0x60, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xE0, 0x3F, 0x19, 0xFE, 0x1F, 0xF3, 0x60, 0x66, 0x03, 0x78, 0x06, 0x80,
  0x2E, 0x00, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00,
  0x20, 0x03, 0xC0, 0x04, 0x00, 0x38, 0x00, 0x80, 0x07, 0x00, 0x10, 0x00,
  0xE0, 0x02, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x80, 0x08, 0x00, 0x70, 0x01,
  0x00, 0x0E, 0x00, 0x20, 0x01, 0xC0, 0x04, 0x00, 0x38, 0x00, 0x80, 0x07,
  0x00, 0x10, 0x00, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x80, 0x08,
  0x00, 0x70, 0x01, 0x00, 0x08, 0xC3, 0xE1, 0x9F, 0xE3, 0x60, 0x66, 0x80,
  0x6E, 0x00, 0xDC, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0x80, 0x03, 0xE0, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x23,
  0x00, 0x19, 0x00, 0x0C, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x03, 0x30, 0x01, 0x98, 0x00, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0xC7, 0xE1, 0x9F, 0xF3, 0x40, 0x77, 0x00, 0x6E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x17, 0x00, 0x6F, 0x01, 0x9B, 0xFF, 0x31, 0xF8, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x30, 0x07, 0x60, 0x07,
  0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x30, 0x07, 0x38, 0x0B, 0x1F, 0xF3, 0x07, 0xE3,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7, 0xE7, 0xF6, 0x1E, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0xC0, 0x63, 0x00, 0x64, 0x00, 0xC8, 0x00, 0x90, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x05, 0x80, 0x0B, 0x00, 0x13, 0x00, 0x67, 0x01, 0x87,
  0xFE, 0x03, 0xF8, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F,
  0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x3F, 0x07, 0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x34, 0x00, 0xD8, 0x07, 0x30, 0x34, 0xFF, 0x90, 0xFC, 0x40, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20, 0x06, 0x30, 0x04, 0x30, 0x0C,
  0x10, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x10,
  0x0C, 0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x03, 0x40,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80, 0x18, 0x01, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0x40, 0x3C, 0x03, 0x40, 0x3C, 0x02, 0x60,
  0x24, 0x06, 0x60, 0x24, 0x06, 0x20, 0x66, 0x06, 0x20, 0x66, 0x04, 0x30,
  0x42, 0x0C, 0x30, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0xC1, 0x08, 0x18,
  0x81, 0x08, 0x19, 0x81, 0x98, 0x19, 0x81, 0x98, 0x09, 0x00, 0x90, 0x0D,
  0x00, 0x90, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x18,
  0x0C, 0x18, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x60, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x04,
  0x30, 0x0C, 0x30, 0x08, 0x18, 0x18, 0x08, 0x30, 0x0C, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20,
  0x06, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x18, 0x08, 0x08,
  0x18, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x30, 0x06, 0x20, 0x02,
  0x60, 0x02, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x40, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x70, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x40, 0x0E, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x1E, 0x01, 0xC0, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x01,
  0x00, 0x00, 0x1E, 0x00, 0x33, 0xF8, 0x02, 0x60, 0xC0, 0x2C, 0x06, 0x06,
  0xC0, 0x30, 0x6C, 0x01, 0xFC, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 8, 3, -31 },
  { 13, 6, 9, 12, 3, -32 },
  { 20, 19, 31, 21, 2, -31 },
  { 94, 16, 39, 21, 2, -35 },
  { 172, 23, 31, 28, 2, -31 },
  { 262, 20, 31, 23, 2, -31 },
  { 340, 1, 9, 7, 3, -32 },
  { 342, 8, 44, 12, 3, -34 },
  { 386, 8, 44, 12, 1, -34 },
  { 430, 17, 17, 18, 1, -31 },
  { 467, 17, 22, 21, 2, -25 },
  { 514, 3, 9, 8, 2, -4 },
  { 518, 9, 1, 11, 1, -14 },
  { 520, 3, 3, 10, 3, -3 },
  { 522, 12, 34, 15, 1, -31 },
  { 573, 15, 31, 21, 3, -31 },
  { 632, 8, 31, 21, 4, -31 },
  { 663, 17, 31, 21, 2, -31 },
  { 729, 16, 31, 21, 2, -31 },
  { 791, 18, 31, 21, 2, -31 },
  { 861, 16, 31, 21, 3, -31 },
  { 923, 16, 31, 21, 3, -31 },
  { 985, 17, 31, 21, 2, -31 },
  { 1051, 17, 31, 21, 2, -31 },
  { 1117, 16, 31, 21, 2, -31 },
  { 1179, 3, 23, 8, 3, -23 },
  { 1188, 4, 28, 8, 2, -23 },
  { 1202, 15, 18, 19, 2, -23 },
  { 1236, 15, 11, 21, 3, -20 },
  { 1257, 14, 18, 20, 3, -23 },
  { 1289, 13, 31, 17, 2, -31 },
  { 1340, 30, 40, 34, 2, -30 },
  { 1490, 21, 31, 23, 1, -31 },
  { 1572, 17, 31, 23, 4, -31 },
  { 1638, 19, 31, 24, 3, -31 },
  { 1712, 18, 31, 25, 4, -31 },
  { 1782, 16, 31, 22, 4, -31 },
  { 1844, 16, 31, 21, 4, -31 },
  { 1906, 19, 31, 26, 3, -31 },
  { 1980, 19, 31, 26, 4, -31 },
  { 2054, 2, 31, 10, 4, -31 },
  { 2062, 15, 31, 21, 2, -31 },
  { 2121, 18, 31, 24, 4, -31 },
  { 2191, 14, 31, 20, 4, -31 },
  { 2246, 24, 31, 32, 4, -31 },
  { 2339, 19, 31, 27, 4, -31 },
  { 2413, 19, 31, 25, 3, -31 },
  { 2487, 17, 31, 23, 4, -31 },
  { 2553, 19, 36, 25, 3, -31 },
  { 2639, 18, 31, 24, 4, -31 },
  { 2709, 18, 31, 22, 2, -31 },
  { 2779, 20, 31, 23, 1, -31 },
  { 2857, 18, 31, 25, 3, -31 },
  { 2927, 21, 31, 23, 1, -31 },
  { 3009, 31, 31, 34, 1, -31 },
  { 3130, 20, 31, 23, 1, -31 },
  { 3208, 21, 31, 23, 1, -31 },
  { 3290, 19, 31, 23, 2, -31 },
  { 3364, 6, 42, 9, 3, -35 },
  { 3396, 13, 34, 15, 1, -31 },
  { 3452, 6, 42, 9, 0, -35 },
  { 3484, 12, 15, 16, 2, -31 },
  { 3507, 16, 2, 16, 0, 0 },
  { 3511, 6, 6, 12, 3, -33 },
  { 3516, 15, 23, 20, 2, -23 },
  { 3560, 15, 32, 21, 3, -32 },
  { 3620, 15, 23, 19, 2, -23 },
  { 3664, 16, 32, 21, 2, -32 },
  { 3728, 16, 23, 20, 2, -23 },
  { 3774, 10, 32, 13, 2, -32 },
  { 3814, 16, 32, 21, 2, -23 },
  { 3878, 15, 32, 21, 3, -32 },
  { 3938, 3, 32, 9, 3, -32 },
  { 3950, 8, 41, 9, -2, -32 },
  { 3991, 15, 32, 18, 3, -32 },
  { 4051, 1, 32, 9, 4, -32 },
  { 4055, 27, 23, 33, 3, -23 },
  { 4133, 15, 23, 21, 3, -23 },
  { 4177, 17, 23, 21, 2, -23 },
  { 4226, 15, 32, 21, 3, -23 },
  { 4286, 16, 32, 21, 2, -23 },
  { 4350, 9, 23, 13, 3, -23 },
  { 4376, 15, 23, 19, 2, -23 },
  { 4420, 10, 29, 12, 1, -29 },
  { 4457, 14, 23, 21, 3, -23 },
  { 4498, 16, 23, 18, 1, -23 },
  { 4544, 24, 23, 28, 2, -23 },
  { 4613, 16, 23, 18, 1, -23 },
  { 4659, 16, 32, 18, 1, -23 },
  { 4723, 15, 23, 18, 2, -23 },
  { 4767, 10, 43, 13, 2, -34 },
  { 4821, 1, 37, 9, 4, -31 },
  { 4826, 11, 43, 13, 0, -34 },
  { 4886, 20, 7, 26, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT43PT7B_H_
