#ifndef _ROBOTOCONDENSED_EXTRALIGHT35PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x02, 0x80, 0x4D, 0x34, 0xD2, 0x49,
  0x24, 0x80, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x03, 0x0C, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x7F, 0xFF, 0x02, 0x08, 0x06, 0x18, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x0C, 0x30,
  0xFF, 0xFE, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x18, 0x60,
  0x10, 0x40, 0x10, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x01, 0x8E,
  0x10, 0x19, 0x80, 0x48, 0x03, 0x40, 0x1A, 0x00, 0x50, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x40, 0x13, 0x01, 0x8E, 0x38,
  0x1F, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x03,
  0x08, 0x00, 0x40, 0x81, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x42, 0x04,
  0x08, 0xC0, 0x81, 0x10, 0x18, 0x46, 0x01, 0x98, 0x80, 0x1E, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x0E, 0x00, 0x22, 0x30, 0x08, 0x82, 0x01, 0x10, 0x40,
  0x42, 0x04, 0x18, 0x40, 0x82, 0x08, 0x10, 0xC1, 0x02, 0x10, 0x20, 0xC0,
  0x04, 0x10, 0x00, 0x46, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x18, 0xC0, 0x30,
  0x40, 0x30, 0x60, 0x20, 0x20, 0x20, 0x60, 0x20, 0x40, 0x30, 0xC0, 0x11,
  0x80, 0x1B, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x32, 0x00, 0x61,
  0x02, 0x41, 0x82, 0xC0, 0xC6, 0x80, 0x46, 0x80, 0x24, 0x80, 0x3C, 0xC0,
  0x18, 0xC0, 0x18, 0x60, 0x34, 0x38, 0xE6, 0x1F, 0x83, 0xFF, 0xE8, 0x02,
  0x0C, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x83, 0x04, 0x08, 0x20, 0x41,
  0x06, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x30, 0x82, 0x18, 0x41, 0x0C, 0x21, 0x0C, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x71, 0x1C, 0xEB, 0x80, 0xE0, 0x07,
  0x00, 0x6C, 0x02, 0x20, 0x20, 0x83, 0x06, 0x10, 0x10, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x24, 0x96, 0xB0, 0xFE, 0xF0, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x00, 0x0F, 0x80, 0xC6, 0x0C,
  0x18, 0xC0, 0x64, 0x01, 0x20, 0x0B, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1E,
  0x00, 0xF0, 0x06, 0x80, 0x24, 0x01, 0x30, 0x18, 0xC1, 0x83, 0x18, 0x0F,
  0x80, 0x02, 0x3D, 0xCE, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0F,
  0x81, 0xC6, 0x18, 0x18, 0x80, 0x6C, 0x01, 0x40, 0x0A, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x08, 0x00, 0xFF, 0xF8, 0x0F, 0x81, 0xC7, 0x18, 0x08, 0x80, 0x6C, 0x01,
  0x60, 0x0A, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x01, 0x80,
  0xF8, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x01, 0xA0, 0x09, 0x80, 0xC7, 0x1C, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x26, 0x00, 0x4C, 0x01, 0x18,
  0x06, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x41, 0x81, 0x83, 0x02, 0x06, 0x08,
  0x0C, 0x30, 0x18, 0x40, 0x31, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x3F, 0xF6, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0xF8, 0x71,
  0xC4, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x14, 0x02, 0x60, 0x63, 0x9C, 0x0F, 0x80, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x3C, 0x36, 0x39, 0xE0, 0x6E, 0x01, 0x60, 0x0F, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x34, 0x01, 0xB0, 0x08, 0xC0, 0xC3,
  0x1C, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x0F,
  0x81, 0xC7, 0x18, 0x08, 0x80, 0x24, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x03,
  0x40, 0x12, 0x00, 0x88, 0x08, 0x31, 0x80, 0xF8, 0x18, 0x31, 0x80, 0xD8,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0D, 0x80,
  0xC7, 0x1C, 0x0F, 0x80, 0x0F, 0x81, 0xC6, 0x08, 0x18, 0x80, 0x64, 0x01,
  0x60, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xA0, 0x1D, 0x81, 0xE7, 0x1B, 0x0F, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0xF0, 0x1C, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xD8, 0x66, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x22, 0x26, 0x4C, 0x00, 0x08, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x1E,
  0x1C, 0xEC, 0x0A, 0x03, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC1,
  0xE0, 0x03, 0x00, 0x30, 0x04, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x06, 0x20, 0x1E, 0x02, 0x20, 0x33, 0x02, 0x40, 0x41,
  0x82, 0x40, 0x81, 0x83, 0x40, 0x81, 0x01, 0xC1, 0x81, 0x01, 0xC1, 0x01,
  0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x83, 0x01,
  0x02, 0x81, 0x01, 0x02, 0x81, 0x03, 0x02, 0x81, 0x03, 0x06, 0xC1, 0x05,
  0x04, 0x40, 0xC9, 0x88, 0x40, 0x70, 0xF0, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40,
  0x04, 0x30, 0x02, 0x08, 0x03, 0x04, 0x01, 0x03, 0x00, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x30, 0x20, 0x08, 0x30, 0x04, 0x1F, 0xFF, 0x08, 0x00, 0x84,
  0x00, 0x46, 0x00, 0x32, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01,
  0x80, 0xFF, 0x82, 0x03, 0x88, 0x03, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x68,
  0x00, 0xA0, 0x06, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x20, 0x38, 0xFF, 0xC2,
  0x00, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x1C, 0xFF, 0xC0, 0x07, 0xE0, 0x0C,
  0x38, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x40, 0x03, 0x40,
  0x02, 0x60, 0x02, 0x20, 0x06, 0x10, 0x0C, 0x0C, 0x38, 0x07, 0xE0, 0xFF,
  0x81, 0x01, 0xC2, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xD0, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0xD0, 0x03, 0x20, 0x0C, 0x40, 0x70, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x38, 0x70,
  0xC0, 0x33, 0x00, 0x24, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x3F,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x2C,
  0x00, 0x4C, 0x01, 0x8E, 0x1C, 0x07, 0xE0, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x70, 0x02, 0x80, 0x34, 0x01, 0x30, 0x08, 0x80, 0x87,
  0x1C, 0x0F, 0x80, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x64, 0x01, 0x88, 0x06,
  0x10, 0x18, 0x20, 0x20, 0x40, 0x80, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x04,
  0xE0, 0x09, 0x40, 0x14, 0x40, 0x30, 0xC0, 0x60, 0xC0, 0x80, 0x81, 0x01,
  0x82, 0x01, 0x84, 0x01, 0x08, 0x03, 0x10, 0x03, 0x20, 0x03, 0x40, 0x02,
  0x80, 0x06, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7A,
  0x00, 0x05, 0xA0, 0x00, 0x59, 0x00, 0x0D, 0x90, 0x00, 0x99, 0x80, 0x09,
  0x88, 0x01, 0x98, 0x80, 0x11, 0x8C, 0x03, 0x18, 0x40, 0x21, 0x84, 0x02,
  0x18, 0x60, 0x61, 0x82, 0x04, 0x18, 0x20, 0x41, 0x83, 0x0C, 0x18, 0x10,
  0x81, 0x81, 0x08, 0x18, 0x09, 0x81, 0x80, 0x90, 0x18, 0x0D, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xA0, 0x03, 0x90, 0x03, 0x98, 0x03, 0x88, 0x03, 0x8C, 0x03, 0x84,
  0x03, 0x86, 0x03, 0x82, 0x03, 0x81, 0x03, 0x81, 0x83, 0x80, 0x83, 0x80,
  0xC3, 0x80, 0x43, 0x80, 0x63, 0x80, 0x23, 0x80, 0x33, 0x80, 0x1B, 0x80,
  0x0B, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x07, 0xE0, 0x1C,
  0x38, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40,
  0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x0E, 0x38, 0x07, 0xE0, 0xFF,
  0xC2, 0x01, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x1A, 0x01, 0xCF,
  0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x1C, 0x38, 0x30,
  0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60,
  0x02, 0x20, 0x06, 0x30, 0x0C, 0x1C, 0x38, 0x07, 0xF0, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC1, 0x00, 0xE2, 0x00, 0x64, 0x00,
  0x48, 0x00, 0xD0, 0x01, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x88, 0x07, 0x1F, 0xF8, 0x20, 0x30, 0x40, 0x20, 0x80,
  0x61, 0x00, 0x42, 0x00, 0xC4, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03,
  0x40, 0x02, 0x80, 0x06, 0x0F, 0xC0, 0x70, 0xE1, 0x80, 0x62, 0x00, 0x6C,
  0x00, 0x58, 0x00, 0xB0, 0x01, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x58, 0x01, 0x98, 0x02, 0x1C,
  0x38, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x05, 0x00, 0x36, 0x01, 0x8E, 0x1C, 0x0F,
  0xC0, 0x80, 0x01, 0xE0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x66, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x08, 0x06, 0x04, 0x03,
  0x03, 0x01, 0x00, 0x80, 0x80, 0x40, 0xC0, 0x30, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x03, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x34, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x08, 0x00, 0xA0, 0x06,
  0x00, 0xD0, 0x07, 0x00, 0x68, 0x02, 0x80, 0x26, 0x01, 0x40, 0x13, 0x00,
  0x90, 0x08, 0x80, 0xC8, 0x0C, 0x40, 0x44, 0x06, 0x20, 0x22, 0x02, 0x18,
  0x10, 0x81, 0x04, 0x18, 0x40, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x40,
  0xC2, 0x04, 0x20, 0x63, 0x02, 0x10, 0x11, 0x01, 0x18, 0x08, 0x80, 0x8C,
  0x04, 0x40, 0x64, 0x03, 0x60, 0x12, 0x00, 0xA0, 0x09, 0x00, 0x50, 0x05,
  0x80, 0x28, 0x03, 0x80, 0x14, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x00, 0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x04, 0x18, 0x0C,
  0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30,
  0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06,
  0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x60, 0x01, 0x98, 0x00, 0x8C, 0x00,
  0xC2, 0x00, 0x41, 0x80, 0x60, 0x40, 0x20, 0x30, 0x30, 0x08, 0x10, 0x06,
  0x18, 0x01, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04,
  0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xF8, 0x08, 0x0C, 0x05,
  0x02, 0x82, 0x61, 0x10, 0x88, 0x86, 0x41, 0x60, 0xA0, 0x70, 0x10, 0xFF,
  0xF8, 0x43, 0x0C, 0x21, 0x80, 0x1F, 0x83, 0x0C, 0x60, 0x2C, 0x02, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0xF7, 0x03, 0x40, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x07, 0x73, 0xB3, 0xE1, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x8B, 0x1C, 0xC0,
  0x6C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x2C, 0x06, 0xB1, 0xC9, 0xF8, 0x1F,
  0x83, 0x8C, 0x60, 0x2C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x36, 0x02, 0x38,
  0xC1, 0xF8, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x1F, 0x13, 0x8D, 0x60, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0x40,
  0x16, 0x03, 0x38, 0xD1, 0xF9, 0x0F, 0x83, 0x8C, 0x60, 0x64, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x03, 0x38, 0xE0, 0xF8, 0x07, 0x86, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x1F, 0x13, 0x8D, 0x60, 0x34, 0x03, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40,
  0x16, 0x03, 0x38, 0xD1, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x60,
  0x23, 0x8E, 0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x8F, 0x93, 0x3A, 0x81, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0xA0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x08,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x63, 0x38, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x50,
  0x1A, 0x06, 0x41, 0x88, 0x61, 0x18, 0x26, 0x05, 0x80, 0xB8, 0x19, 0x02,
  0x10, 0x43, 0x08, 0x21, 0x02, 0x20, 0x64, 0x06, 0x80, 0x50, 0x0C, 0xFF,
  0xFF, 0xFF, 0xC0, 0x8F, 0x83, 0xE2, 0xC7, 0x18, 0xCA, 0x04, 0x81, 0xB0,
  0x1C, 0x02, 0xC0, 0x30, 0x0A, 0x00, 0x80, 0x28, 0x02, 0x00, 0xE0, 0x08,
  0x03, 0x80, 0x20, 0x0E, 0x00, 0x80, 0x38, 0x02, 0x00, 0xE0, 0x08, 0x03,
  0x80, 0x20, 0x0E, 0x00, 0x80, 0x38, 0x02, 0x00, 0xE0, 0x08, 0x03, 0x80,
  0x20, 0x0E, 0x00, 0x80, 0x30, 0x8F, 0x93, 0x3A, 0x81, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0F, 0x81, 0xC7, 0x18, 0x0C, 0x80,
  0x2C, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x0D, 0x00, 0x4C, 0x06, 0x38, 0xE0, 0x7C, 0x00,
  0x9F, 0x8B, 0x1C, 0xC0, 0x6C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x2C, 0x06,
  0xB1, 0xC9, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x1F, 0x13, 0x9D, 0x60, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0x40,
  0x16, 0x03, 0x38, 0xD1, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x8F, 0x62, 0x86, 0x0C, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x1F, 0x0E, 0x39, 0x01,
  0xE0, 0x18, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x0A, 0x03, 0x71, 0xC3, 0xF0, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1E, 0x07, 0x61, 0xA7, 0xC4, 0x80, 0x1E, 0x00,
  0x90, 0x04, 0x80, 0x66, 0x02, 0x10, 0x10, 0x81, 0x86, 0x08, 0x10, 0x40,
  0x82, 0x06, 0x20, 0x11, 0x00, 0x88, 0x06, 0x80, 0x14, 0x00, 0xA0, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x20, 0x12, 0x03, 0x00, 0x90, 0x14, 0x0C, 0xC0,
  0xA0, 0x62, 0x05, 0x02, 0x10, 0x6C, 0x10, 0x82, 0x20, 0x86, 0x11, 0x0C,
  0x10, 0x88, 0x40, 0x88, 0x62, 0x04, 0x41, 0x10, 0x32, 0x09, 0x80, 0xB0,
  0x48, 0x05, 0x01, 0x40, 0x28, 0x0A, 0x01, 0x40, 0x70, 0x04, 0x03, 0x00,
  0x20, 0x08, 0x00, 0x40, 0x13, 0x01, 0x88, 0x08, 0x60, 0x81, 0x8C, 0x04,
  0x40, 0x36, 0x00, 0xA0, 0x02, 0x00, 0x38, 0x01, 0x40, 0x13, 0x01, 0x88,
  0x08, 0x20, 0xC1, 0x84, 0x04, 0x60, 0x36, 0x00, 0xC0, 0x80, 0x1E, 0x00,
  0xD0, 0x04, 0x80, 0x66, 0x03, 0x10, 0x10, 0x81, 0x86, 0x0C, 0x10, 0x40,
  0x82, 0x06, 0x30, 0x11, 0x00, 0x88, 0x02, 0xC0, 0x14, 0x00, 0xA0, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x70, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x0F, 0xFF, 0x01, 0x81, 0x81, 0x80, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x70,
  0x70, 0x0C, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x40, 0x30, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x03, 0x00, 0xC1, 0x80, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x60, 0x20, 0x00, 0x3C, 0x02, 0xCC, 0x07, 0x0C, 0x0C, 0x0C, 0x38, 0x0C,
  0xD0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 25, 7, 3, -25 },
  { 8, 6, 7, 9, 2, -26 },
  { 14, 16, 25, 17, 1, -25 },
  { 64, 13, 31, 17, 2, -28 },
  { 115, 19, 25, 23, 2, -25 },
  { 175, 16, 25, 19, 2, -25 },
  { 225, 2, 7, 6, 2, -26 },
  { 227, 7, 36, 10, 2, -28 },
  { 259, 6, 36, 10, 1, -28 },
  { 286, 13, 14, 15, 1, -25 },
  { 309, 15, 17, 17, 1, -20 },
  { 341, 3, 7, 7, 1, -3 },
  { 344, 7, 1, 9, 1, -12 },
  { 345, 2, 2, 8, 3, -2 },
  { 346, 10, 27, 12, 1, -25 },
  { 380, 13, 25, 17, 2, -25 },
  { 421, 7, 25, 17, 3, -25 },
  { 443, 13, 25, 17, 2, -25 },
  { 484, 13, 25, 17, 2, -25 },
  { 525, 15, 25, 17, 1, -25 },
  { 572, 12, 25, 17, 3, -25 },
  { 610, 13, 25, 17, 2, -25 },
  { 651, 14, 25, 17, 1, -25 },
  { 695, 13, 25, 17, 2, -25 },
  { 736, 13, 25, 17, 2, -25 },
  { 777, 3, 18, 6, 2, -18 },
  { 784, 4, 22, 6, 1, -18 },
  { 795, 13, 14, 16, 1, -18 },
  { 818, 13, 7, 17, 2, -15 },
  { 830, 12, 14, 16, 2, -18 },
  { 851, 10, 25, 14, 2, -25 },
  { 883, 24, 32, 28, 2, -24 },
  { 979, 17, 25, 19, 1, -25 },
  { 1033, 14, 25, 19, 3, -25 },
  { 1077, 16, 25, 20, 2, -25 },
  { 1127, 15, 25, 20, 3, -25 },
  { 1174, 13, 25, 18, 3, -25 },
  { 1215, 13, 25, 17, 3, -25 },
  { 1256, 15, 25, 21, 3, -25 },
  { 1303, 15, 25, 22, 3, -25 },
  { 1350, 1, 25, 8, 4, -25 },
  { 1354, 13, 25, 17, 1, -25 },
  { 1395, 15, 25, 19, 3, -25 },
  { 1442, 12, 25, 16, 3, -25 },
  { 1480, 20, 25, 26, 3, -25 },
  { 1543, 16, 25, 22, 3, -25 },
  { 1593, 16, 25, 21, 2, -25 },
  { 1643, 14, 25, 19, 3, -25 },
  { 1687, 16, 29, 21, 2, -25 },
  { 1745, 15, 25, 20, 3, -25 },
  { 1792, 15, 25, 18, 2, -25 },
  { 1839, 16, 25, 18, 1, -25 },
  { 1889, 14, 25, 20, 3, -25 },
  { 1933, 17, 25, 19, 1, -25 },
  { 1987, 25, 25, 27, 1, -25 },
  { 2066, 16, 25, 19, 1, -25 },
  { 2116, 17, 25, 18, 1, -25 },
  { 2170, 15, 25, 18, 2, -25 },
  { 2217, 4, 33, 7, 3, -28 },
  { 2234, 10, 27, 12, 1, -25 },
  { 2268, 5, 33, 7, 0, -28 },
  { 2289, 9, 12, 13, 2, -25 },
  { 2303, 13, 1, 13, 0, 0 },
  { 2305, 5, 5, 10, 2, -27 },
  { 2309, 12, 18, 16, 2, -18 },
  { 2336, 12, 26, 17, 3, -26 },
  { 2375, 12, 18, 16, 2, -18 },
  { 2402, 12, 26, 17, 2, -26 },
  { 2441, 12, 18, 16, 2, -18 },
  { 2468, 9, 26, 10, 1, -26 },
  { 2498, 12, 25, 17, 2, -18 },
  { 2536, 11, 26, 17, 3, -26 },
  { 2572, 2, 25, 7, 3, -25 },
  { 2579, 6, 32, 7, -1, -25 },
  { 2603, 11, 26, 15, 3, -26 },
  { 2639, 1, 26, 7, 3, -26 },
  { 2643, 22, 18, 27, 3, -18 },
  { 2693, 11, 18, 17, 3, -18 },
  { 2718, 13, 18, 17, 2, -18 },
  { 2748, 12, 25, 17, 3, -18 },
  { 2786, 12, 25, 17, 2, -18 },
  { 2824, 7, 18, 11, 3, -18 },
  { 2840, 11, 18, 16, 2, -18 },
  { 2865, 8, 23, 10, 1, -23 },
  { 2888, 11, 18, 17, 3, -18 },
  { 2913, 13, 18, 15, 1, -18 },
  { 2943, 21, 18, 23, 1, -18 },
  { 2991, 13, 18, 15, 1, -18 },
  { 3021, 13, 25, 15, 1, -18 },
  { 3062, 12, 18, 15, 2, -18 },
  { 3089, 9, 34, 10, 1, -27 },
  { 3128, 1, 30, 7, 3, -25 },
  { 3132, 9, 34, 10, 0, -27 },
  { 3171, 15, 6, 21, 3, -13 },
};

const GFXfont RobotoCondensed_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT35PT7B_H_
