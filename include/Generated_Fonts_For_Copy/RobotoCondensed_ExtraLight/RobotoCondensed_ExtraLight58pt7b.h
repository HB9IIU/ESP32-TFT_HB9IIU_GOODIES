#ifndef _ROBOTOCONDENSED_EXTRALIGHT58PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x08, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0E, 0x01,
  0xE0, 0x70, 0x03, 0x81, 0x80, 0x07, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x38,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x1C, 0x0E, 0x00, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x60, 0x04, 0x01, 0x80, 0xC0, 0x0C, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x06, 0x00, 0x60, 0x60,
  0x0C, 0x00, 0x80, 0xC0, 0x18, 0x03, 0x03, 0x00, 0x18, 0x06, 0x06, 0x00,
  0x30, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x60, 0x00, 0x79, 0xC0, 0xC0, 0x00,
  0x3F, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x07, 0xF0, 0x00, 0x0C, 0x1E, 0xF0, 0x00, 0x30, 0x70, 0x30, 0x00,
  0x60, 0xC0, 0x60, 0x01, 0x81, 0x00, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x0C,
  0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30, 0x02, 0x01, 0x80,
  0x60, 0x04, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03,
  0x00, 0x60, 0x20, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x70,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x1C,
  0x01, 0x87, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x06, 0x30, 0x03, 0x80, 0xC6,
  0x00, 0x38, 0x19, 0xC0, 0x03, 0x06, 0x30, 0x00, 0x30, 0xC6, 0x00, 0x07,
  0x18, 0xC0, 0x00, 0x77, 0x18, 0x00, 0x06, 0xC3, 0x80, 0x00, 0xF8, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x1D,
  0xC0, 0xE0, 0x0F, 0x1C, 0x0F, 0xFF, 0x81, 0x80, 0x7F, 0xC0, 0x18, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x40, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x01,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x18,
  0x02, 0xF0, 0x30, 0x1D, 0xF8, 0x61, 0xF8, 0x7E, 0xCF, 0x80, 0x1F, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x67, 0x00,
  0x01, 0xC7, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0xE7, 0x33, 0x98, 0x80, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xC0, 0x70, 0x0C, 0x00, 0xE0, 0x60, 0x01, 0x83, 0x80, 0x07, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x60, 0x01,
  0x80, 0xC0, 0x0E, 0x03, 0xC0, 0x70, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xF3, 0x7C, 0x3F, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF8, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x07,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB0,
  0x00, 0x0E, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x70,
  0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x06,
  0x07, 0x80, 0x78, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x38, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x1F,
  0x80, 0x67, 0xFE, 0x07, 0xE0, 0xF8, 0x78, 0x03, 0xC6, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03, 0xF0, 0x18, 0x7F, 0xE0,
  0xCF, 0x07, 0x86, 0xE0, 0x0E, 0x36, 0x00, 0x39, 0xE0, 0x00, 0xCE, 0x00,
  0x07, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x60, 0x38, 0x0F,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3,
  0x00, 0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0xC0, 0x0E, 0x01,
  0xC0, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x1C, 0x07, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x30, 0xC0, 0x01,
  0xCE, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0xB8, 0x00, 0x1C, 0xC0, 0x01, 0xE7, 0x00, 0x1B, 0x1C, 0x01, 0xD8,
  0x78, 0x3C, 0xC1, 0xFF, 0x86, 0x03, 0xF0, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xEF, 0xE4, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xEE,
  0x40, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x67, 0x31, 0x9D, 0xC4,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0x01, 0xC7, 0x00, 0x73,
  0x00, 0x1B, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x1F,
  0x80, 0x0C, 0x18, 0x00, 0x7F, 0xC0, 0x06, 0x18, 0x00, 0xE0, 0xE0, 0x06,
  0x30, 0x01, 0xC0, 0x30, 0x06, 0x30, 0x01, 0x80, 0x30, 0x06, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x30, 0x06, 0x00, 0x30, 0x02, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x60, 0x06, 0x00, 0x20, 0x03, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x60,
  0x0C, 0x00, 0x60, 0x03, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x60, 0x0C, 0x00,
  0x60, 0x03, 0x40, 0x18, 0x00, 0x60, 0x03, 0x40, 0x18, 0x00, 0x60, 0x03,
  0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x02, 0xC0, 0x18,
  0x00, 0x60, 0x06, 0x40, 0x18, 0x00, 0x60, 0x06, 0x60, 0x18, 0x00, 0x60,
  0x06, 0x60, 0x18, 0x00, 0xE0, 0x06, 0x60, 0x18, 0x00, 0xE0, 0x0C, 0x60,
  0x0C, 0x01, 0xE0, 0x0C, 0x60, 0x0C, 0x01, 0x60, 0x18, 0x60, 0x0C, 0x03,
  0x60, 0x18, 0x70, 0x06, 0x06, 0x30, 0x30, 0x30, 0x07, 0xBC, 0x3C, 0xE0,
  0x30, 0x03, 0xF8, 0x1F, 0xC0, 0x38, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x38, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x06,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x71, 0x80, 0x01, 0xC3, 0x00, 0x0F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x3C, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x1C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00,
  0x03, 0x98, 0x00, 0x0E, 0x30, 0x00, 0x78, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x78, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x07,
  0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0xF0, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xE0, 0x00, 0xE3, 0x00, 0x06, 0x1C, 0x00, 0x70, 0x78, 0x0F, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x60,
  0x03, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06,
  0x01, 0xC0, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0xF8, 0x00, 0x0C, 0xEE, 0x00,
  0x06, 0xE3, 0x00, 0x03, 0x61, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0x00, 0x6F,
  0x60, 0x00, 0x00, 0x37, 0x98, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x19,
  0xE7, 0x00, 0x00, 0x0C, 0xF1, 0x80, 0x00, 0x0E, 0x78, 0xC0, 0x00, 0x06,
  0x3C, 0x70, 0x00, 0x03, 0x1E, 0x18, 0x00, 0x03, 0x0F, 0x0C, 0x00, 0x01,
  0x87, 0x83, 0x00, 0x00, 0xC3, 0xC1, 0x80, 0x00, 0xC1, 0xE0, 0xC0, 0x00,
  0x60, 0xF0, 0x30, 0x00, 0x30, 0x78, 0x18, 0x00, 0x30, 0x3C, 0x0C, 0x00,
  0x18, 0x1E, 0x03, 0x00, 0x1C, 0x0F, 0x01, 0x80, 0x0C, 0x07, 0x80, 0xE0,
  0x06, 0x03, 0xC0, 0x30, 0x06, 0x01, 0xE0, 0x18, 0x03, 0x00, 0xF0, 0x06,
  0x01, 0x80, 0x78, 0x03, 0x01, 0x80, 0x3C, 0x01, 0x80, 0xC0, 0x1E, 0x00,
  0x60, 0x60, 0x0F, 0x00, 0x30, 0x60, 0x07, 0x80, 0x18, 0x30, 0x03, 0xC0,
  0x06, 0x38, 0x01, 0xE0, 0x03, 0x18, 0x00, 0xF0, 0x01, 0xCC, 0x00, 0x78,
  0x00, 0x6C, 0x00, 0x3C, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x30, 0x00,
  0x0F, 0x06, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x3C, 0x0E,
  0x00, 0x0F, 0x01, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0C, 0x00, 0x3C,
  0x01, 0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x80,
  0x3C, 0x00, 0x60, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x00, 0xF0, 0x00,
  0x60, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x18, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x18,
  0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x06, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x18,
  0x00, 0x3C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x1E, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xE0, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x76, 0x00, 0x01,
  0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x19, 0xC0, 0x00, 0xC8, 0x00,
  0x0C, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x30, 0x00, 0x23, 0x00, 0x06, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x0E, 0x00, 0x18, 0x40, 0x01, 0x83, 0x00, 0x0C,
  0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0x38, 0x01, 0x81, 0x80, 0x18, 0x0C,
  0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x18, 0x03, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30,
  0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x1C,
  0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x18, 0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x18, 0x30,
  0x18, 0x30, 0x18, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81,
  0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x72, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1E, 0x00, 0x73, 0x80,
  0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0x60, 0x03, 0x37, 0x80, 0xE3, 0x3F, 0xFC, 0x30, 0xFF, 0x83,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0xFF, 0x03, 0x9F, 0xFE, 0x1D, 0xC0, 0x38, 0xF8, 0x00, 0xE7,
  0x80, 0x03, 0x3C, 0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xDE, 0x00, 0x0C,
  0xF8, 0x00, 0xE7, 0x70, 0x0E, 0x31, 0xFF, 0xE1, 0x87, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xC0, 0x1C,
  0x38, 0x00, 0xE3, 0x00, 0x06, 0x70, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x33, 0x00, 0x06,
  0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81,
  0xFF, 0x0C, 0x3F, 0xFC, 0x63, 0xC0, 0x33, 0x38, 0x00, 0xD9, 0x80, 0x02,
  0xCC, 0x00, 0x1E, 0xE0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB8, 0x00, 0x1C, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x18, 0x00,
  0xD8, 0xF0, 0x0C, 0xC3, 0xFF, 0xC6, 0x07, 0xFC, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x81, 0x80,
  0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x07, 0x0F, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xC3, 0xFF, 0xC6,
  0x3C, 0x07, 0x33, 0x80, 0x0D, 0x98, 0x00, 0x2D, 0xC0, 0x01, 0xEC, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x01,
  0xCC, 0x00, 0x0E, 0x70, 0x00, 0xF1, 0x80, 0x0D, 0x8F, 0x00, 0xCC, 0x3F,
  0xFC, 0x60, 0x7F, 0xC3, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC6, 0x00,
  0x0C, 0x1C, 0x00, 0xE0, 0x78, 0x1E, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x10, 0x0E, 0x1F, 0xF0, 0xE3,
  0xFF, 0x8E, 0x60, 0x1C, 0xEC, 0x00, 0xCF, 0x80, 0x0E, 0xF8, 0x00, 0x6F,
  0x00, 0x06, 0xF0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x6E, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x01, 0x80, 0xE0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x3F, 0x0F, 0x80, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF8, 0x00, 0xF9, 0x80, 0x0F, 0x1C, 0x00,
  0xF0, 0xE0, 0x0E, 0x06, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0x8E, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x08, 0x06, 0x0F, 0xF0, 0x07, 0xFC, 0x30, 0xFF, 0xE0, 0xFF, 0xF1,
  0x8C, 0x07, 0x8E, 0x01, 0xCC, 0xC0, 0x0C, 0xE0, 0x06, 0x6C, 0x00, 0x76,
  0x00, 0x3B, 0x40, 0x01, 0xE0, 0x00, 0xDE, 0x00, 0x0F, 0x00, 0x06, 0xE0,
  0x00, 0x70, 0x00, 0x37, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x07,
  0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x18,
  0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x10, 0x0E, 0x1F, 0xF0, 0xE3, 0xFF, 0x8E, 0x60, 0x1C,
  0xEC, 0x00, 0xCF, 0x80, 0x0E, 0xF8, 0x00, 0x6F, 0x00, 0x06, 0xF0, 0x00,
  0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0,
  0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00,
  0x01, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x31, 0xFF,
  0xE1, 0xDC, 0x07, 0x8F, 0x80, 0x0E, 0x78, 0x00, 0x33, 0xC0, 0x01, 0xDC,
  0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00,
  0x01, 0xB8, 0x00, 0x1D, 0xE0, 0x00, 0xCF, 0x80, 0x0E, 0x76, 0x00, 0xE3,
  0x9F, 0xFE, 0x1C, 0x7F, 0xC0, 0xE0, 0x30, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xC3, 0xFF, 0xC6, 0x3C, 0x07, 0x33,
  0x80, 0x0D, 0x9C, 0x00, 0x3C, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00, 0x0E,
  0x70, 0x00, 0xF1, 0x80, 0x0D, 0x8F, 0x00, 0xCC, 0x3F, 0xFC, 0x60, 0x7F,
  0xC3, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x2E, 0x1F,
  0xE7, 0xFE, 0xE0, 0xEC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xC0, 0x01, 0x98,
  0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xB0, 0x00, 0x77, 0x00, 0x0C, 0x70, 0x07, 0x07, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x40, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xFC, 0x07, 0xE0, 0x04, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x1F, 0x3C, 0x07, 0x71, 0xFF, 0xE7,
  0x07, 0xFC, 0x70, 0x0C, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00,
  0x0C, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x38, 0x01, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xD8, 0x00, 0x30, 0x00, 0x66,
  0x00, 0x1E, 0x00, 0x19, 0x80, 0x07, 0x80, 0x0E, 0x70, 0x01, 0xE0, 0x03,
  0x8C, 0x00, 0x58, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x0C, 0xC0,
  0x0C, 0x38, 0x03, 0x30, 0x07, 0x06, 0x01, 0x8C, 0x01, 0x81, 0x80, 0x61,
  0x80, 0x60, 0x60, 0x18, 0x60, 0x18, 0x1C, 0x06, 0x18, 0x0E, 0x03, 0x03,
  0x06, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x0C,
  0x0C, 0x0C, 0x1C, 0x01, 0x86, 0x03, 0x86, 0x00, 0x61, 0x80, 0x61, 0x80,
  0x18, 0x60, 0x18, 0x60, 0x06, 0x18, 0x06, 0x18, 0x00, 0xCC, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x03, 0x20, 0x03,
  0x30, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x33, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x70,
  0x01, 0x81, 0x80, 0x1C, 0x0E, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x60,
  0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x38, 0x00, 0x0D,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x18, 0x00, 0x30, 0xE0, 0x03, 0x83,
  0x00, 0x18, 0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x0E, 0x0E,
  0x00, 0x30, 0x60, 0x01, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x3B, 0x80, 0x00,
  0xE0, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x77, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x38, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x80, 0x38,
  0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x33, 0x87, 0x00,
  0x0D, 0xC0, 0xE0, 0x03, 0x60, 0x1C, 0x00, 0xD8, 0x03, 0x80, 0x3C, 0x00,
  0x70, 0x1B, 0x00, 0x0F, 0x0E, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 42, 11, 4, -41 },
  { 17, 8, 12, 16, 4, -44 },
  { 29, 27, 41, 29, 2, -41 },
  { 168, 22, 53, 28, 3, -47 },
  { 314, 31, 43, 37, 3, -42 },
  { 481, 27, 43, 31, 3, -42 },
  { 627, 2, 12, 10, 4, -44 },
  { 630, 11, 59, 16, 4, -46 },
  { 712, 11, 59, 17, 1, -46 },
  { 794, 23, 23, 24, 1, -41 },
  { 861, 24, 30, 29, 2, -34 },
  { 951, 5, 12, 11, 2, -5 },
  { 959, 11, 2, 15, 2, -20 },
  { 962, 4, 4, 13, 4, -3 },
  { 964, 17, 45, 20, 1, -41 },
  { 1060, 22, 43, 28, 3, -42 },
  { 1179, 12, 41, 28, 5, -41 },
  { 1241, 22, 42, 28, 3, -42 },
  { 1357, 22, 43, 28, 3, -42 },
  { 1476, 25, 41, 28, 2, -41 },
  { 1605, 20, 42, 28, 5, -41 },
  { 1710, 21, 42, 28, 4, -41 },
  { 1821, 23, 41, 28, 2, -41 },
  { 1939, 22, 43, 28, 3, -42 },
  { 2058, 21, 42, 28, 3, -42 },
  { 2169, 4, 31, 11, 4, -30 },
  { 2185, 5, 37, 10, 2, -30 },
  { 2209, 20, 23, 26, 2, -30 },
  { 2267, 20, 14, 28, 4, -26 },
  { 2302, 21, 24, 26, 3, -31 },
  { 2365, 17, 43, 23, 3, -42 },
  { 2457, 40, 53, 46, 3, -40 },
  { 2722, 29, 41, 31, 1, -41 },
  { 2871, 23, 41, 31, 5, -41 },
  { 2989, 25, 43, 33, 4, -42 },
  { 3124, 24, 41, 33, 5, -41 },
  { 3247, 22, 41, 29, 5, -41 },
  { 3360, 22, 41, 29, 5, -41 },
  { 3473, 25, 43, 35, 5, -42 },
  { 3608, 25, 41, 36, 5, -41 },
  { 3737, 2, 41, 14, 6, -41 },
  { 3748, 21, 42, 28, 2, -41 },
  { 3859, 25, 41, 32, 5, -41 },
  { 3988, 20, 41, 27, 5, -41 },
  { 4091, 33, 41, 43, 5, -41 },
  { 4261, 26, 41, 36, 5, -41 },
  { 4395, 26, 43, 34, 4, -42 },
  { 4535, 23, 41, 31, 5, -41 },
  { 4653, 26, 49, 34, 4, -42 },
  { 4813, 24, 41, 33, 5, -41 },
  { 4936, 25, 43, 30, 3, -42 },
  { 5071, 27, 41, 30, 2, -41 },
  { 5210, 24, 42, 34, 5, -41 },
  { 5336, 29, 41, 31, 1, -41 },
  { 5485, 41, 41, 45, 2, -41 },
  { 5696, 27, 41, 31, 2, -41 },
  { 5835, 28, 41, 30, 1, -41 },
  { 5979, 25, 41, 30, 3, -41 },
  { 6108, 7, 56, 12, 5, -47 },
  { 6157, 17, 45, 20, 2, -41 },
  { 6253, 8, 56, 12, 0, -47 },
  { 6309, 16, 21, 21, 3, -41 },
  { 6351, 20, 2, 22, 1, 0 },
  { 6356, 8, 8, 16, 4, -44 },
  { 6364, 20, 33, 27, 3, -32 },
  { 6447, 21, 45, 28, 4, -44 },
  { 6566, 20, 33, 26, 3, -32 },
  { 6649, 21, 45, 28, 3, -44 },
  { 6768, 21, 33, 26, 3, -32 },
  { 6855, 15, 45, 17, 2, -45 },
  { 6940, 21, 44, 28, 3, -32 },
  { 7056, 20, 44, 28, 4, -44 },
  { 7166, 4, 43, 12, 4, -43 },
  { 7188, 10, 55, 12, -2, -43 },
  { 7257, 20, 44, 25, 4, -44 },
  { 7367, 2, 44, 12, 5, -44 },
  { 7378, 37, 32, 45, 4, -32 },
  { 7526, 20, 32, 28, 4, -32 },
  { 7606, 22, 33, 28, 3, -32 },
  { 7697, 21, 44, 28, 4, -32 },
  { 7813, 21, 44, 28, 3, -32 },
  { 7929, 12, 32, 18, 4, -32 },
  { 7977, 19, 33, 26, 3, -32 },
  { 8056, 13, 40, 17, 1, -39 },
  { 8121, 20, 32, 28, 4, -31 },
  { 8201, 21, 31, 25, 2, -31 },
  { 8283, 34, 31, 38, 2, -31 },
  { 8415, 21, 31, 25, 2, -31 },
  { 8497, 22, 43, 24, 1, -31 },
  { 8616, 20, 31, 25, 3, -31 },
  { 8694, 14, 57, 17, 2, -45 },
  { 8794, 2, 49, 12, 5, -41 },
  { 8807, 14, 57, 17, 1, -45 },
  { 8907, 26, 10, 35, 4, -22 },
};

const GFXfont RobotoCondensed_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT58PT7B_H_
