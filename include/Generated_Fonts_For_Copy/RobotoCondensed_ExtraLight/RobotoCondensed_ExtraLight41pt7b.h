#ifndef _ROBOTOCONDENSED_EXTRALIGHT41PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0xCF, 0x3C, 0xE3,
  0x8E, 0x38, 0xE3, 0x8C, 0x01, 0x83, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04,
  0x08, 0x01, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x18, 0x02, 0x04,
  0x1F, 0xFF, 0xF0, 0x20, 0x40, 0x18, 0x10, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0xC1, 0x83, 0xFF,
  0xFE, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x18, 0x30,
  0x06, 0x0C, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x07, 0xE0, 0x0F, 0x78, 0x18, 0x1C,
  0x30, 0x0C, 0x20, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x02, 0x60, 0x02,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x06, 0x38, 0x0C,
  0x1F, 0x78, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x1E, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x18, 0x00, 0x10, 0x20, 0x00, 0xC0,
  0xC0, 0x83, 0x03, 0x02, 0x0C, 0x0C, 0x10, 0x30, 0x30, 0xC0, 0xC0, 0xC2,
  0x03, 0x03, 0x18, 0x04, 0x08, 0x40, 0x18, 0x63, 0x00, 0x33, 0x08, 0x00,
  0x78, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x63, 0x98, 0x01,
  0x08, 0x20, 0x0C, 0x60, 0xC0, 0x21, 0x01, 0x01, 0x84, 0x04, 0x04, 0x10,
  0x10, 0x30, 0x40, 0x40, 0x81, 0x01, 0x04, 0x04, 0x04, 0x10, 0x18, 0x30,
  0x00, 0x20, 0x80, 0x00, 0xE6, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xFE,
  0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x01, 0x80, 0x20, 0x10, 0x04, 0x06,
  0x00, 0x80, 0xC0, 0x10, 0x30, 0x03, 0x0C, 0x00, 0x23, 0x00, 0x06, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x30, 0xC0,
  0xCC, 0x08, 0x19, 0x81, 0x83, 0x20, 0x18, 0x6C, 0x01, 0x89, 0x80, 0x13,
  0x30, 0x03, 0x66, 0x00, 0x38, 0x40, 0x03, 0x0C, 0x00, 0xE0, 0xC0, 0x76,
  0x0F, 0x78, 0x60, 0x7E, 0x06, 0xFF, 0x80, 0x02, 0x02, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x40, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02,
  0x02, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04,
  0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x81, 0x02, 0xF1, 0x1E, 0x1F, 0x78, 0x03,
  0xC0, 0x03, 0x80, 0x06, 0xC0, 0x04, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x10,
  0x18, 0x10, 0x08, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x6D, 0xB6, 0xD6, 0x80, 0xFF, 0x5F, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xE0, 0x1F,
  0xE0, 0x60, 0x61, 0x80, 0x62, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xA0, 0x03,
  0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x20, 0x0C, 0x60, 0x18, 0x60, 0x60,
  0x7F, 0x80, 0x7E, 0x00, 0x01, 0x83, 0xC7, 0x7E, 0x3C, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x07, 0xE0, 0x1E, 0xF0, 0x30, 0x18, 0x20, 0x0C, 0x60, 0x04, 0x40,
  0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x07,
  0xE0, 0x3D, 0xE0, 0xE0, 0x61, 0x00, 0x66, 0x00, 0x48, 0x00, 0xD0, 0x01,
  0xA0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x3E, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x60, 0x06, 0xC0, 0x08,
  0xC0, 0x30, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x02, 0x30, 0x03,
  0x18, 0x01, 0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0,
  0x40, 0x60, 0x60, 0x30, 0x20, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x03,
  0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xFE, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x9F, 0x03, 0xFF, 0x87, 0x01, 0x84, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x78,
  0x00, 0xD0, 0x01, 0xA0, 0x02, 0x60, 0x0C, 0x40, 0x18, 0xC0, 0x60, 0xF7,
  0x80, 0x7E, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x1F, 0x04,
  0xF7, 0x8B, 0x01, 0x9C, 0x01, 0x30, 0x03, 0x60, 0x02, 0x80, 0x05, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0x60, 0x06,
  0x40, 0x0C, 0xC0, 0x30, 0xC0, 0xE0, 0xF7, 0x80, 0x7C, 0x00, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x1E, 0xF8,
  0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x38, 0x18, 0x0F, 0xF0,
  0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06,
  0x30, 0x0C, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3D, 0xE0, 0xE0, 0x61,
  0x80, 0x66, 0x00, 0xC8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0xD8, 0x01, 0x90, 0x05,
  0x30, 0x1A, 0x3D, 0xE4, 0x1F, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x7E, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x33, 0x36, 0x64, 0x00, 0x04, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0x80, 0x00, 0x0F, 0x83, 0xDC, 0x60, 0x64, 0x03, 0xC0, 0x3C, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x30, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x23, 0x00, 0x7C, 0x02, 0x20, 0x0C,
  0x60, 0x32, 0x01, 0x83, 0x01, 0x60, 0x30, 0x30, 0x14, 0x02, 0x03, 0x01,
  0x40, 0x60, 0x30, 0x14, 0x04, 0x02, 0x01, 0x40, 0xC0, 0x20, 0x14, 0x0C,
  0x02, 0x01, 0xC0, 0xC0, 0x20, 0x1C, 0x08, 0x02, 0x01, 0xC0, 0x80, 0x20,
  0x14, 0x08, 0x06, 0x03, 0x40, 0x80, 0x60, 0x24, 0x0C, 0x06, 0x02, 0x40,
  0xC0, 0xA0, 0x64, 0x04, 0x1B, 0x0C, 0x60, 0x77, 0x19, 0x82, 0x03, 0xE0,
  0xF0, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80,
  0x01, 0x98, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x30, 0xC0, 0x02, 0x04,
  0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0xC0,
  0x30, 0x08, 0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x80, 0x18, 0x1F,
  0xFF, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xC0,
  0x81, 0xF0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18,
  0x80, 0xF0, 0xFF, 0xF0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x0C, 0x80, 0xF8, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xCF,
  0x01, 0x80, 0x70, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x6C, 0x00, 0x0B,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x09,
  0x80, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x3D, 0xF0, 0x03,
  0xF0, 0x00, 0xFF, 0xC0, 0x40, 0xF8, 0x20, 0x06, 0x10, 0x01, 0x88, 0x00,
  0x64, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x06, 0x40, 0x06, 0x20, 0x06, 0x10,
  0x3E, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFE, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F,
  0xFF, 0x3F, 0xFE, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xEF, 0x81, 0x80,
  0x30, 0xC0, 0x06, 0x60, 0x00, 0x98, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x01,
  0x20, 0x00, 0x4C, 0x00, 0x31, 0xC0, 0x38, 0x3E, 0xFC, 0x03, 0xFC, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x03, 0xC0, 0x0D, 0x00, 0x66,
  0x03, 0x0F, 0xF8, 0x0F, 0xC0, 0x80, 0x03, 0x40, 0x03, 0x20, 0x03, 0x90,
  0x01, 0x88, 0x01, 0x84, 0x01, 0x82, 0x01, 0x81, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0xC0, 0x20, 0xC0, 0x10, 0xC0, 0x08, 0xC0, 0x04, 0xE0, 0x02, 0x78,
  0x01, 0x66, 0x00, 0xE1, 0x00, 0x60, 0xC0, 0x20, 0x30, 0x10, 0x0C, 0x08,
  0x06, 0x04, 0x01, 0x82, 0x00, 0x61, 0x00, 0x10, 0x80, 0x0C, 0x40, 0x03,
  0x20, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x18, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x5A, 0x00, 0x01,
  0xB6, 0x00, 0x02, 0x64, 0x00, 0x04, 0xC8, 0x00, 0x19, 0x98, 0x00, 0x27,
  0x10, 0x00, 0xCE, 0x30, 0x01, 0x9C, 0x60, 0x02, 0x38, 0x40, 0x0C, 0x70,
  0xC0, 0x18, 0xE1, 0x80, 0x21, 0xC1, 0x00, 0xC3, 0x83, 0x01, 0x07, 0x02,
  0x02, 0x0E, 0x04, 0x0C, 0x1C, 0x0C, 0x10, 0x38, 0x08, 0x60, 0x70, 0x10,
  0xC0, 0xE0, 0x31, 0x01, 0xC0, 0x26, 0x03, 0x80, 0x6C, 0x07, 0x00, 0xD0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x01, 0x00, 0x60, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0E, 0x80, 0x03, 0xB0, 0x00, 0xE4, 0x00, 0x39,
  0x80, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x20, 0x0E, 0x0C,
  0x03, 0x81, 0x00, 0xE0, 0x60, 0x38, 0x0C, 0x0E, 0x03, 0x03, 0x80, 0x60,
  0xE0, 0x08, 0x38, 0x03, 0x0E, 0x00, 0x43, 0x80, 0x18, 0xE0, 0x03, 0x38,
  0x00, 0xCE, 0x00, 0x1B, 0x80, 0x02, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0x80, 0x60, 0xC0,
  0x0C, 0x60, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x02, 0x60, 0x01,
  0x8C, 0x00, 0xC1, 0x80, 0x70, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xE0,
  0x80, 0xF8, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x0C, 0x80, 0xF8, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0xFF, 0xE0, 0x40, 0x7C, 0x20, 0x07, 0x10, 0x00, 0x88, 0x00, 0x64,
  0x00, 0x12, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00,
  0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x01, 0xF0, 0xFF,
  0xE0, 0x40, 0x30, 0x20, 0x08, 0x10, 0x06, 0x08, 0x01, 0x04, 0x00, 0xC2,
  0x00, 0x31, 0x00, 0x18, 0x80, 0x06, 0x40, 0x03, 0x20, 0x00, 0xD0, 0x00,
  0x68, 0x00, 0x18, 0x03, 0xF0, 0x03, 0xCF, 0x03, 0x80, 0x60, 0xC0, 0x0C,
  0x60, 0x01, 0x90, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x80, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0x60, 0x01, 0x9C,
  0x00, 0xE3, 0x80, 0x70, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x60, 0x01, 0x98,
  0x01, 0x8E, 0x01, 0x83, 0xEF, 0x80, 0x7F, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x02, 0x40, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x04, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x80,
  0x80, 0x10, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x40, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x19, 0x00, 0x00, 0x90, 0x00, 0x0B,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00,
  0x0D, 0x00, 0x0C, 0x00, 0x26, 0x00, 0x30, 0x01, 0x98, 0x01, 0xE0, 0x06,
  0x60, 0x06, 0x80, 0x18, 0x80, 0x12, 0x00, 0x42, 0x00, 0x48, 0x01, 0x0C,
  0x03, 0x30, 0x0C, 0x30, 0x0C, 0x40, 0x30, 0x40, 0x21, 0x00, 0xC1, 0x00,
  0x84, 0x02, 0x06, 0x06, 0x18, 0x08, 0x18, 0x18, 0x20, 0x60, 0x60, 0x40,
  0x81, 0x80, 0x81, 0x02, 0x04, 0x02, 0x0C, 0x0C, 0x10, 0x0C, 0x30, 0x10,
  0xC0, 0x30, 0x80, 0x43, 0x00, 0x42, 0x01, 0x0C, 0x01, 0x18, 0x06, 0x20,
  0x06, 0x60, 0x08, 0x80, 0x19, 0x00, 0x26, 0x00, 0x64, 0x00, 0x98, 0x00,
  0xB0, 0x03, 0x40, 0x02, 0xC0, 0x05, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00,
  0x6C, 0x00, 0x18, 0xC0, 0x03, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x30, 0x30, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x60,
  0x00, 0xC8, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x00, 0xB0, 0x00, 0x33, 0x00, 0x0C, 0x20, 0x01, 0x86, 0x00, 0x60, 0x40,
  0x08, 0x0C, 0x03, 0x00, 0xC0, 0x40, 0x18, 0x18, 0x01, 0x86, 0x00, 0x10,
  0xC0, 0x03, 0x30, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0x64, 0x00, 0x06,
  0x60, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x00, 0x18, 0x18, 0x01,
  0x00, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x08, 0x00, 0x11, 0x80, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0xE0, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x04, 0x01, 0xC0,
  0x28, 0x05, 0x01, 0xB0, 0x22, 0x04, 0x41, 0x8C, 0x20, 0x84, 0x11, 0x83,
  0x20, 0x24, 0x05, 0x80, 0xF0, 0x18, 0xFF, 0xFE, 0xC3, 0x0C, 0x61, 0x80,
  0x07, 0xC0, 0x7B, 0xC3, 0x01, 0x98, 0x03, 0x40, 0x0D, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xFF, 0xCF, 0x83, 0x70, 0x0D, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xD8, 0x0D, 0x3F,
  0xE4, 0x7E, 0x10, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x8F, 0x83, 0x7B, 0xC7,
  0x80, 0xCE, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x02, 0xC0, 0x05, 0x80,
  0x0B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x60, 0x02,
  0xC0, 0x05, 0x80, 0x1B, 0x00, 0x37, 0x00, 0x4F, 0x01, 0x9B, 0xDE, 0x31,
  0xF0, 0x00, 0x07, 0xC0, 0x3D, 0xE0, 0xC0, 0x63, 0x00, 0x64, 0x00, 0xD8,
  0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x40, 0x04, 0x80, 0x09,
  0x80, 0x31, 0x80, 0xC1, 0xEF, 0x00, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x0F, 0x8C, 0x7B, 0xD9, 0x80, 0xF6, 0x00, 0xEC, 0x00, 0xD0, 0x01,
  0xA0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x80, 0x19, 0x00,
  0x73, 0x01, 0xE3, 0xDE, 0xC1, 0xF1, 0x80, 0x07, 0xC0, 0x3D, 0xE0, 0xC0,
  0x63, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x11, 0x80, 0x61, 0xF7, 0x80, 0xFC,
  0x00, 0x03, 0xE0, 0xE4, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x1F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x07, 0xC6, 0x3D, 0xEC,
  0xC0, 0x7B, 0x00, 0x76, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xA0, 0x03, 0x40, 0x06, 0xC0, 0x0C, 0x80, 0x39, 0x80, 0xF1, 0xEF, 0x60,
  0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x80, 0x31, 0x80,
  0xC1, 0xEF, 0x00, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F, 0x0C, 0xEF,
  0x36, 0x06, 0xF0, 0x1B, 0x80, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x6F, 0xDE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x6C,
  0x03, 0x30, 0x18, 0xC0, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0xC6, 0x03,
  0x30, 0x0D, 0x80, 0x3F, 0x00, 0xE6, 0x03, 0x08, 0x0C, 0x30, 0x30, 0x60,
  0xC0, 0x83, 0x03, 0x0C, 0x06, 0x30, 0x08, 0xC0, 0x33, 0x00, 0x6C, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC7, 0xC0, 0x7C,
  0x33, 0xBC, 0x3B, 0xCD, 0x01, 0x90, 0x1B, 0x80, 0x68, 0x06, 0xE0, 0x0E,
  0x00, 0xB0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x30, 0xC7, 0xC3, 0x3B,
  0xCD, 0x81, 0xBC, 0x06, 0xE0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30,
  0x07, 0xE0, 0x1E, 0xF8, 0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x06,
  0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06,
  0x30, 0x0C, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xC7, 0xC1, 0xBD, 0xE3,
  0xC0, 0x67, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x02, 0xC0,
  0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x01,
  0x60, 0x02, 0xC0, 0x0D, 0x80, 0x1B, 0x80, 0x27, 0x80, 0xCD, 0xEF, 0x18,
  0xF8, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC6, 0x3D, 0xEC, 0xC0, 0x7B, 0x00,
  0x76, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x03, 0x40,
  0x06, 0xC0, 0x0C, 0x80, 0x39, 0x80, 0xF1, 0xEF, 0x60, 0xF8, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0xC7, 0xEF, 0xB4, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x0F, 0xC0, 0xF3, 0xC6, 0x03, 0x98, 0x06, 0x40, 0x09,
  0x00, 0x34, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x00,
  0x98, 0x06, 0x3E, 0xF0, 0x3F, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87,
  0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x07, 0x41,
  0xE0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x76, 0x01, 0xD8, 0x0F,
  0x3F, 0xEC, 0x7E, 0x30, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x26,
  0x00, 0xC4, 0x01, 0x8C, 0x02, 0x18, 0x0C, 0x10, 0x18, 0x30, 0x20, 0x60,
  0xC0, 0x41, 0x80, 0xC2, 0x01, 0x84, 0x01, 0x18, 0x02, 0x20, 0x06, 0x40,
  0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x10,
  0x07, 0x80, 0x60, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0x40, 0x24, 0x02, 0x80,
  0xCC, 0x0D, 0x81, 0x98, 0x13, 0x03, 0x30, 0x22, 0x04, 0x20, 0xC4, 0x08,
  0x41, 0x8C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0x81, 0x18, 0x21, 0x02,
  0x30, 0x66, 0x06, 0x40, 0xCC, 0x0C, 0x80, 0x90, 0x0B, 0x01, 0x20, 0x14,
  0x03, 0x40, 0x28, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x00, 0x60, 0x06, 0xC0, 0x18, 0xC0, 0x20, 0x80, 0xC1, 0x81, 0x01,
  0x06, 0x03, 0x18, 0x03, 0x30, 0x02, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x2C, 0x00, 0xC8, 0x01, 0x18, 0x06, 0x10, 0x18, 0x30, 0x30, 0x30,
  0xC0, 0x61, 0x00, 0x66, 0x00, 0x48, 0x00, 0xC0, 0xC0, 0x02, 0x80, 0x0D,
  0x00, 0x1B, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x8C, 0x02, 0x08, 0x0C, 0x10,
  0x18, 0x30, 0x20, 0x20, 0xC0, 0x41, 0x80, 0xC2, 0x00, 0x84, 0x01, 0x18,
  0x03, 0x20, 0x02, 0x40, 0x05, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x05, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x80, 0x60, 0x20,
  0x18, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x03, 0x03, 0x80, 0xC0, 0x0C, 0x01,
  0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x1C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x80, 0x30, 0x07, 0x00, 0xC0, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x06, 0x01, 0x01, 0xC0, 0x40, 0x00, 0x1E, 0x00, 0x67,
  0xE0, 0x09, 0x86, 0x01, 0x60, 0x60, 0x2C, 0x06, 0x0D, 0x00, 0x7F, 0x20,
  0x03, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 6, 9, 11, 3, -31 },
  { 16, 18, 29, 20, 2, -29 },
  { 82, 16, 37, 20, 2, -33 },
  { 156, 22, 29, 26, 2, -29 },
  { 236, 19, 29, 22, 2, -29 },
  { 305, 1, 9, 7, 3, -31 },
  { 307, 8, 42, 11, 3, -33 },
  { 349, 8, 42, 12, 1, -33 },
  { 391, 16, 16, 17, 1, -29 },
  { 423, 17, 22, 20, 2, -25 },
  { 470, 3, 9, 8, 2, -3 },
  { 474, 8, 1, 11, 1, -13 },
  { 475, 3, 3, 9, 3, -3 },
  { 477, 12, 32, 14, 1, -29 },
  { 525, 15, 29, 20, 2, -29 },
  { 580, 9, 29, 20, 3, -29 },
  { 613, 16, 29, 20, 2, -29 },
  { 671, 15, 29, 20, 2, -29 },
  { 726, 17, 29, 20, 2, -29 },
  { 788, 15, 29, 20, 3, -29 },
  { 843, 15, 29, 20, 3, -29 },
  { 898, 16, 29, 20, 2, -29 },
  { 956, 16, 29, 20, 2, -29 },
  { 1014, 15, 29, 20, 2, -29 },
  { 1069, 2, 22, 8, 3, -22 },
  { 1075, 4, 28, 7, 1, -22 },
  { 1089, 14, 17, 19, 2, -22 },
  { 1119, 14, 9, 20, 3, -18 },
  { 1135, 15, 17, 19, 2, -22 },
  { 1167, 12, 29, 16, 2, -29 },
  { 1211, 28, 37, 33, 2, -28 },
  { 1341, 20, 29, 22, 1, -29 },
  { 1414, 16, 29, 22, 4, -29 },
  { 1472, 18, 29, 23, 3, -29 },
  { 1538, 17, 29, 23, 4, -29 },
  { 1600, 15, 29, 21, 4, -29 },
  { 1655, 15, 29, 20, 4, -29 },
  { 1710, 18, 29, 25, 3, -29 },
  { 1776, 18, 29, 25, 4, -29 },
  { 1842, 2, 29, 10, 4, -29 },
  { 1850, 14, 29, 20, 2, -29 },
  { 1901, 17, 29, 23, 4, -29 },
  { 1963, 14, 29, 19, 4, -29 },
  { 2014, 23, 29, 31, 4, -29 },
  { 2098, 18, 29, 25, 4, -29 },
  { 2164, 18, 29, 24, 3, -29 },
  { 2230, 16, 29, 22, 4, -29 },
  { 2288, 18, 34, 24, 3, -29 },
  { 2365, 17, 29, 23, 4, -29 },
  { 2427, 18, 29, 21, 2, -29 },
  { 2493, 19, 29, 21, 1, -29 },
  { 2562, 17, 29, 24, 3, -29 },
  { 2624, 20, 29, 22, 1, -29 },
  { 2697, 30, 29, 32, 1, -29 },
  { 2806, 19, 29, 22, 1, -29 },
  { 2875, 20, 29, 21, 1, -29 },
  { 2948, 18, 29, 22, 2, -29 },
  { 3014, 5, 39, 9, 3, -33 },
  { 3039, 12, 32, 14, 1, -29 },
  { 3087, 6, 39, 9, 0, -33 },
  { 3117, 11, 15, 15, 2, -29 },
  { 3138, 15, 1, 15, 0, 0 },
  { 3140, 5, 5, 11, 3, -30 },
  { 3144, 14, 22, 19, 2, -22 },
  { 3183, 15, 31, 20, 3, -31 },
  { 3242, 15, 22, 19, 2, -22 },
  { 3284, 15, 31, 20, 2, -31 },
  { 3343, 15, 22, 19, 2, -22 },
  { 3385, 11, 31, 12, 1, -31 },
  { 3428, 15, 30, 20, 2, -22 },
  { 3485, 14, 31, 20, 3, -31 },
  { 3540, 2, 30, 8, 3, -30 },
  { 3548, 7, 38, 8, -2, -30 },
  { 3582, 14, 31, 18, 3, -31 },
  { 3637, 2, 31, 8, 3, -31 },
  { 3645, 26, 22, 32, 3, -22 },
  { 3717, 14, 22, 20, 3, -22 },
  { 3756, 16, 22, 20, 2, -22 },
  { 3800, 15, 30, 20, 3, -22 },
  { 3857, 15, 30, 20, 2, -22 },
  { 3914, 9, 22, 12, 3, -22 },
  { 3939, 14, 22, 18, 2, -22 },
  { 3978, 9, 27, 12, 1, -27 },
  { 4009, 14, 22, 20, 3, -22 },
  { 4048, 15, 22, 17, 1, -22 },
  { 4090, 23, 22, 27, 2, -22 },
  { 4154, 15, 22, 17, 1, -22 },
  { 4196, 15, 30, 17, 1, -22 },
  { 4253, 14, 22, 17, 2, -22 },
  { 4292, 10, 41, 12, 2, -32 },
  { 4344, 1, 34, 9, 4, -29 },
  { 4349, 10, 41, 12, 0, -32 },
  { 4401, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT41PT7B_H_
