#ifndef _ROBOTOCONDENSED_EXTRALIGHT37PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xF0, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0x40,
  0x18, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x3F, 0xFF, 0x81, 0x04, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x40, 0x10, 0x60, 0x08, 0x30, 0x04,
  0x10, 0x7F, 0xFF, 0x83, 0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x10, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x01, 0xF0, 0x1C, 0x60, 0xC0, 0xC6, 0x01, 0x98, 0x02, 0x40,
  0x09, 0x00, 0x34, 0x00, 0xD8, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80, 0x23, 0x01, 0x87, 0x1C, 0x0F, 0xC0,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x41, 0x00,
  0x0C, 0x10, 0x00, 0x81, 0x02, 0x08, 0x18, 0x60, 0x81, 0x84, 0x08, 0x18,
  0xC0, 0xC1, 0x08, 0x04, 0x11, 0x80, 0x62, 0x10, 0x03, 0xC2, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC3, 0xC0, 0x08, 0x46, 0x01, 0x88, 0x20,
  0x10, 0x83, 0x03, 0x18, 0x10, 0x21, 0x81, 0x04, 0x18, 0x10, 0x41, 0x81,
  0x08, 0x08, 0x30, 0x00, 0x82, 0x00, 0x04, 0x60, 0x00, 0x3C, 0x07, 0x80,
  0x0E, 0x60, 0x04, 0x18, 0x06, 0x04, 0x03, 0x03, 0x01, 0x81, 0x00, 0xC0,
  0x80, 0x60, 0xC0, 0x10, 0xC0, 0x0C, 0xC0, 0x02, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0xC4, 0x04, 0xC3, 0x02, 0x40, 0xC3, 0x60, 0x31,
  0xB0, 0x08, 0x90, 0x06, 0x4C, 0x01, 0xE6, 0x00, 0x61, 0x00, 0x30, 0xC0,
  0x6C, 0x38, 0xE3, 0x07, 0xC0, 0xC0, 0xFF, 0xFF, 0x04, 0x08, 0x20, 0xC1,
  0x04, 0x08, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x81, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30, 0x41, 0x86,
  0x08, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x07, 0x8C,
  0x73, 0xFE, 0x01, 0xE0, 0x07, 0x00, 0x12, 0x00, 0x8C, 0x06, 0x18, 0x30,
  0x30, 0x80, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x32, 0x26, 0x64, 0xFE, 0xF0, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x07, 0x80,
  0x73, 0x83, 0x03, 0x08, 0x04, 0x60, 0x19, 0x00, 0x24, 0x00, 0xB0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x02, 0x40, 0x09, 0x80,
  0x62, 0x01, 0x0C, 0x0C, 0x1C, 0xE0, 0x3E, 0x00, 0x03, 0x0F, 0x3B, 0xC3,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x80,
  0x63, 0x83, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00, 0x2C, 0x00, 0xA0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x63, 0x83,
  0x03, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x2C, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x26, 0x01,
  0x8C, 0x04, 0x1C, 0x60, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x90, 0x01, 0x10, 0x02, 0x10,
  0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x10, 0x60, 0x10, 0x40, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xF9,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x7C, 0x1E, 0x38, 0xC0, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x01, 0xE0, 0x0D, 0x00, 0x4C,
  0x06, 0x38, 0xE0, 0x7C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x1F, 0x05, 0xC7,
  0x3C, 0x04, 0xE0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x80, 0x22, 0x01, 0x8C, 0x0C, 0x1C,
  0x60, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0F, 0xC0, 0x73, 0x83, 0x03, 0x18, 0x06, 0x40, 0x09, 0x00, 0x24,
  0x00, 0x90, 0x02, 0x40, 0x09, 0x80, 0x63, 0x03, 0x06, 0x38, 0x0F, 0xC0,
  0xE1, 0xC6, 0x01, 0x90, 0x02, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x34, 0x00, 0x98, 0x06, 0x38, 0x70, 0x3F, 0x00, 0x0F,
  0x80, 0x63, 0x83, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x40, 0x1D, 0x80, 0x72,
  0x02, 0xCE, 0x32, 0x0F, 0x88, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x07, 0x80, 0x78, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1D, 0x80, 0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x22, 0x22, 0x26, 0x44, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x40,
  0x00, 0x1F, 0x0E, 0x31, 0x03, 0x60, 0x28, 0x07, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x60,
  0x00, 0x02, 0x20, 0x0F, 0x01, 0x10, 0x18, 0xC0, 0x58, 0x18, 0x30, 0x28,
  0x08, 0x18, 0x14, 0x0C, 0x0C, 0x0A, 0x04, 0x04, 0x07, 0x02, 0x02, 0x03,
  0x83, 0x01, 0x01, 0xC1, 0x00, 0x80, 0xC0, 0x80, 0x40, 0x60, 0x40, 0x20,
  0x30, 0x20, 0x10, 0x1C, 0x10, 0x18, 0x1E, 0x08, 0x0C, 0x09, 0x06, 0x06,
  0x04, 0x81, 0x05, 0x04, 0x40, 0xCC, 0x46, 0x30, 0x3C, 0x1C, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x01, 0x20, 0x00,
  0xC8, 0x00, 0x23, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01, 0x06, 0x00, 0x40,
  0x80, 0x30, 0x20, 0x0C, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x18,
  0x10, 0x02, 0x07, 0xFF, 0x83, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x01, 0x18,
  0x00, 0x64, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x30, 0xFF,
  0xC1, 0x81, 0xE3, 0x00, 0x66, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x03, 0x8F, 0xFE, 0x18,
  0x07, 0x30, 0x02, 0x60, 0x06, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0x71, 0xFF, 0xC0,
  0x07, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x60, 0x06, 0x30, 0x0C,
  0x1C, 0x38, 0x07, 0xE0, 0xFF, 0xC0, 0xC0, 0xF0, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x06,
  0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x01,
  0x20, 0x03, 0x30, 0x06, 0x1E, 0x3C, 0x07, 0xF0, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x60, 0x0B, 0x00, 0xCC, 0x0C, 0x39, 0xC0, 0xFC, 0x00, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0,
  0xC0, 0xC0, 0x80, 0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDE,
  0x00, 0xD2, 0x00, 0xE3, 0x00, 0xC1, 0x80, 0xC0, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x02, 0xE8,
  0x00, 0x37, 0x60, 0x01, 0x3B, 0x00, 0x09, 0xC8, 0x00, 0xCE, 0x60, 0x04,
  0x71, 0x00, 0x23, 0x88, 0x03, 0x1C, 0x60, 0x10, 0xE1, 0x00, 0x87, 0x08,
  0x0C, 0x38, 0x60, 0x41, 0xC1, 0x06, 0x0E, 0x0C, 0x20, 0x70, 0x21, 0x03,
  0x81, 0x18, 0x1C, 0x0C, 0x80, 0xE0, 0x24, 0x07, 0x01, 0x60, 0x38, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x40, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3D, 0x00, 0x1E, 0xC0, 0x0F, 0x20, 0x07, 0x88, 0x03,
  0xC6, 0x01, 0xE1, 0x00, 0xF0, 0xC0, 0x78, 0x20, 0x3C, 0x18, 0x1E, 0x04,
  0x0F, 0x01, 0x07, 0x80, 0xC3, 0xC0, 0x21, 0xE0, 0x18, 0xF0, 0x04, 0x78,
  0x03, 0x3C, 0x00, 0xDE, 0x00, 0x2F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xC0, 0x03, 0xF0, 0x07, 0x1E, 0x06, 0x01, 0x86, 0x00, 0x66,
  0x00, 0x13, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x19,
  0x00, 0x08, 0xC0, 0x0C, 0x30, 0x0C, 0x0E, 0x1C, 0x01, 0xF8, 0x00, 0xFF,
  0xE1, 0x80, 0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x6C, 0x01, 0x98,
  0x0F, 0x3F, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x03, 0xF0, 0x07, 0x1E, 0x06, 0x01, 0x86, 0x00, 0x66, 0x00, 0x13, 0x00,
  0x0D, 0x00, 0x06, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x08, 0xC0,
  0x0C, 0x30, 0x0C, 0x0E, 0x3C, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0xFF, 0xC0, 0xC0, 0x70, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xC0,
  0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x07, 0xE0,
  0x1C, 0x38, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x1E, 0x38,
  0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xD8, 0x01, 0x18, 0x06, 0x1C, 0x38, 0x1F, 0xC0, 0xC0,
  0x00, 0xF0, 0x00, 0x24, 0x00, 0x09, 0x00, 0x06, 0x60, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x30, 0xC0, 0x08, 0x10, 0x02, 0x04, 0x01, 0x81, 0x80, 0x60,
  0x20, 0x10, 0x08, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x04,
  0x18, 0x01, 0x84, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x03, 0x20, 0x00, 0x48,
  0x00, 0x16, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x04,
  0x00, 0x68, 0x01, 0xC0, 0x09, 0x00, 0x28, 0x01, 0x30, 0x05, 0x00, 0x66,
  0x00, 0xA0, 0x0C, 0x40, 0x36, 0x01, 0x08, 0x04, 0x40, 0x21, 0x00, 0x88,
  0x04, 0x30, 0x11, 0x01, 0x86, 0x06, 0x30, 0x30, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x08, 0x30, 0x30, 0xC1, 0x86, 0x02, 0x10, 0x10,
  0x80, 0x42, 0x02, 0x10, 0x08, 0x40, 0x42, 0x01, 0x98, 0x0C, 0xC0, 0x32,
  0x00, 0x98, 0x02, 0x40, 0x12, 0x00, 0x48, 0x02, 0x40, 0x0B, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x40, 0x01, 0xB0, 0x00, 0x8C, 0x00, 0xC2, 0x00, 0xC1, 0x80,
  0x60, 0x40, 0x60, 0x30, 0x20, 0x08, 0x30, 0x06, 0x10, 0x01, 0x98, 0x00,
  0x58, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05, 0x80, 0x06, 0x40,
  0x02, 0x30, 0x03, 0x08, 0x01, 0x06, 0x01, 0x81, 0x81, 0x80, 0x40, 0x80,
  0x30, 0xC0, 0x08, 0x40, 0x06, 0x60, 0x01, 0xE0, 0x00, 0xC0, 0xC0, 0x00,
  0x90, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C, 0x30, 0x02, 0x04, 0x01, 0x81,
  0x80, 0x40, 0x20, 0x30, 0x0C, 0x08, 0x01, 0x06, 0x00, 0x61, 0x00, 0x08,
  0xC0, 0x03, 0x20, 0x00, 0x58, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0,
  0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x30, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x43, 0xF0, 0x08, 0x03, 0x01, 0xC0, 0x58, 0x12, 0x0C, 0x82, 0x30, 0x84,
  0x61, 0x10, 0x6C, 0x0B, 0x02, 0x80, 0xC0, 0xFF, 0xFC, 0x61, 0x83, 0x06,
  0x08, 0x0F, 0x81, 0xC7, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0x60, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x7F, 0x8E, 0x04, 0xC0, 0x2C, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x36, 0x02, 0x9C, 0x66, 0x3E, 0x30, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x8F,
  0x85, 0xCF, 0x28, 0x09, 0x80, 0x6C, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50,
  0x02, 0xC0, 0x37, 0x01, 0x2E, 0x79, 0x1F, 0x00, 0x0F, 0x81, 0xC7, 0x18,
  0x0C, 0x80, 0x2C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x38, 0x03, 0x40, 0x13,
  0x01, 0x8F, 0x38, 0x1F, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x0F, 0x89, 0xE6, 0x48, 0x0A, 0xC0,
  0x34, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x28, 0x01, 0x60, 0x19, 0x01, 0x4F,
  0x3A, 0x1F, 0x10, 0x0F, 0x81, 0xE7, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0xCF, 0x3C, 0x1F, 0x80,
  0x03, 0xC3, 0x90, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x86,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0F,
  0x89, 0xE6, 0x58, 0x0A, 0xC0, 0x34, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x28,
  0x01, 0x60, 0x19, 0x01, 0x4F, 0x3A, 0x1F, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x13, 0x01, 0x8E, 0x38, 0x1F, 0x80, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x87, 0x89, 0x8E,
  0xB0, 0x2E, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xF0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x0D, 0x33, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x18, 0x83,
  0x08, 0x60, 0x8C, 0x08, 0x80, 0x90, 0x0B, 0x80, 0xEC, 0x0C, 0x40, 0x82,
  0x08, 0x30, 0x81, 0x08, 0x08, 0x80, 0xC8, 0x06, 0x80, 0x28, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x8F, 0x81, 0xF1, 0x31, 0x86, 0x32, 0x81, 0x90, 0x36,
  0x01, 0xC0, 0x2C, 0x03, 0x80, 0x70, 0x02, 0x00, 0xE0, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x87, 0x89, 0x8E, 0xB0, 0x2E, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0x73, 0x83, 0x03,
  0x18, 0x06, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xD0, 0x02, 0x60,
  0x18, 0xC0, 0xC1, 0xCE, 0x03, 0xF0, 0x8F, 0x85, 0xCF, 0x28, 0x09, 0x80,
  0x68, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0xC0, 0x37, 0x01, 0x2E,
  0x79, 0x1F, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x0F, 0x89, 0xE6, 0x58, 0x0A, 0xC0, 0x34, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x28, 0x01, 0x60, 0x19, 0x01, 0xCF, 0x3A, 0x1F,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x8F, 0x32, 0x86, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1F, 0x83, 0x0C, 0x60,
  0x2C, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0xC0, 0x34, 0x03, 0x39,
  0xE1, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x18, 0x0C, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0xC0, 0x34, 0x05, 0x71, 0x91, 0xF1, 0xC0, 0x0F, 0x00,
  0x24, 0x00, 0x90, 0x06, 0x60, 0x10, 0x80, 0x42, 0x03, 0x0C, 0x08, 0x10,
  0x20, 0x41, 0x81, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x32, 0x00, 0x48, 0x01,
  0x20, 0x05, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x40, 0x30, 0x0D, 0x00,
  0xC0, 0x24, 0x03, 0x00, 0x98, 0x0E, 0x06, 0x20, 0x68, 0x18, 0x81, 0x20,
  0x42, 0x04, 0x81, 0x0C, 0x33, 0x04, 0x30, 0xC4, 0x30, 0x42, 0x10, 0x81,
  0x08, 0x42, 0x06, 0x61, 0x88, 0x19, 0x02, 0x60, 0x24, 0x09, 0x00, 0x90,
  0x34, 0x03, 0xC0, 0xD0, 0x0E, 0x01, 0x40, 0x18, 0x07, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x20, 0x40, 0x19, 0x80, 0x42, 0x03, 0x0C, 0x08, 0x18, 0x60,
  0x21, 0x00, 0xCC, 0x01, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xE0,
  0x0C, 0x80, 0x23, 0x01, 0x84, 0x04, 0x18, 0x30, 0x30, 0x80, 0x46, 0x01,
  0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x24, 0x00, 0x98, 0x06, 0x60, 0x10, 0x80,
  0x42, 0x03, 0x0C, 0x08, 0x10, 0x20, 0x41, 0x81, 0x86, 0x02, 0x10, 0x08,
  0x40, 0x33, 0x00, 0x48, 0x01, 0x20, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xFF, 0xF0, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0xFF, 0xF0,
  0x00, 0x80, 0x60, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x1C, 0x0E, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x30, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x06, 0x01, 0xC0, 0x60, 0x60, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x0C, 0x04,
  0x00, 0x3C, 0x01, 0x66, 0x01, 0xC1, 0x01, 0x80, 0xC3, 0x80, 0x66, 0x80,
  0x3C,
};

const GFXglyph RobotoCondensed_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 7, 3, -26 },
  { 8, 5, 8, 10, 3, -28 },
  { 13, 17, 26, 18, 1, -26 },
  { 69, 14, 32, 18, 2, -29 },
  { 125, 20, 26, 24, 2, -26 },
  { 190, 17, 26, 20, 2, -26 },
  { 246, 2, 8, 6, 2, -28 },
  { 248, 7, 37, 10, 3, -29 },
  { 281, 7, 37, 11, 1, -29 },
  { 314, 14, 14, 16, 1, -26 },
  { 339, 16, 19, 18, 1, -22 },
  { 377, 4, 8, 7, 1, -3 },
  { 381, 7, 1, 10, 1, -12 },
  { 382, 2, 2, 8, 3, -2 },
  { 383, 10, 28, 13, 1, -26 },
  { 418, 14, 26, 18, 2, -26 },
  { 464, 8, 26, 18, 3, -26 },
  { 490, 14, 26, 18, 2, -26 },
  { 536, 14, 26, 18, 2, -26 },
  { 582, 16, 26, 18, 1, -26 },
  { 634, 13, 26, 18, 3, -26 },
  { 677, 14, 26, 18, 2, -26 },
  { 723, 14, 26, 18, 2, -26 },
  { 769, 14, 26, 18, 2, -26 },
  { 815, 14, 26, 18, 2, -26 },
  { 861, 3, 19, 7, 2, -19 },
  { 869, 4, 24, 7, 1, -19 },
  { 881, 12, 14, 17, 2, -19 },
  { 902, 12, 8, 18, 3, -16 },
  { 914, 13, 14, 17, 2, -19 },
  { 937, 11, 26, 15, 2, -26 },
  { 973, 25, 34, 29, 2, -26 },
  { 1080, 18, 26, 20, 1, -26 },
  { 1139, 15, 26, 20, 3, -26 },
  { 1188, 16, 26, 21, 3, -26 },
  { 1240, 16, 26, 21, 3, -26 },
  { 1292, 14, 26, 19, 3, -26 },
  { 1338, 14, 26, 18, 3, -26 },
  { 1384, 16, 26, 22, 3, -26 },
  { 1436, 16, 26, 23, 3, -26 },
  { 1488, 1, 26, 9, 4, -26 },
  { 1492, 13, 26, 18, 2, -26 },
  { 1535, 16, 26, 20, 3, -26 },
  { 1587, 13, 26, 17, 3, -26 },
  { 1630, 21, 26, 28, 3, -26 },
  { 1699, 17, 26, 23, 3, -26 },
  { 1755, 17, 26, 22, 2, -26 },
  { 1811, 15, 26, 20, 3, -26 },
  { 1860, 17, 31, 22, 2, -26 },
  { 1926, 16, 26, 21, 3, -26 },
  { 1978, 16, 26, 19, 2, -26 },
  { 2030, 17, 26, 19, 1, -26 },
  { 2086, 15, 26, 21, 3, -26 },
  { 2135, 18, 26, 20, 1, -26 },
  { 2194, 27, 26, 29, 1, -26 },
  { 2282, 17, 26, 20, 1, -26 },
  { 2338, 18, 26, 19, 1, -26 },
  { 2397, 16, 26, 19, 2, -26 },
  { 2449, 5, 36, 8, 3, -30 },
  { 2472, 11, 28, 13, 1, -26 },
  { 2511, 5, 36, 8, 0, -30 },
  { 2534, 10, 13, 14, 2, -26 },
  { 2551, 14, 1, 14, 0, 0 },
  { 2553, 6, 5, 10, 2, -28 },
  { 2557, 13, 20, 17, 2, -20 },
  { 2590, 13, 28, 18, 3, -28 },
  { 2636, 13, 20, 17, 2, -20 },
  { 2669, 13, 28, 18, 2, -28 },
  { 2715, 13, 20, 17, 2, -20 },
  { 2748, 10, 28, 11, 1, -28 },
  { 2783, 13, 28, 18, 2, -20 },
  { 2829, 12, 28, 18, 3, -28 },
  { 2871, 2, 27, 7, 3, -27 },
  { 2878, 7, 35, 8, -2, -27 },
  { 2909, 12, 28, 16, 3, -28 },
  { 2951, 1, 28, 7, 3, -28 },
  { 2955, 23, 20, 29, 3, -20 },
  { 3013, 12, 20, 18, 3, -20 },
  { 3043, 14, 20, 18, 2, -20 },
  { 3078, 13, 28, 18, 3, -20 },
  { 3124, 13, 28, 18, 2, -20 },
  { 3170, 7, 20, 11, 3, -20 },
  { 3188, 12, 20, 16, 2, -20 },
  { 3218, 8, 25, 11, 1, -25 },
  { 3243, 12, 20, 18, 3, -20 },
  { 3273, 14, 20, 16, 1, -20 },
  { 3308, 22, 20, 24, 1, -20 },
  { 3363, 14, 20, 16, 1, -20 },
  { 3398, 14, 28, 16, 1, -20 },
  { 3447, 13, 20, 16, 2, -20 },
  { 3480, 10, 37, 11, 1, -29 },
  { 3527, 2, 31, 8, 3, -26 },
  { 3535, 9, 37, 11, 0, -29 },
  { 3577, 16, 6, 22, 3, -14 },
};

const GFXfont RobotoCondensed_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT37PT7B_H_
