#ifndef _ROBOTOCONDENSED_EXTRALIGHT11PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x29, 0x4E, 0x55, 0x39, 0x4A, 0x0E, 0x98, 0xC2, 0x11,
  0xE0, 0xC3, 0x4D, 0x38, 0x39, 0x51, 0x46, 0xE5, 0x28, 0x8C, 0x5A, 0x5C,
  0x00, 0x6A, 0xAA, 0xA9, 0x95, 0x55, 0x56, 0x27, 0x88, 0xA0, 0x21, 0x1C,
  0x42, 0x10, 0x00, 0x40, 0x00, 0x04, 0x94, 0x94, 0x80, 0xE9, 0x99, 0x99,
  0x9E, 0x55, 0x54, 0xE1, 0x12, 0x24, 0x8E, 0xE1, 0x12, 0x01, 0x1E, 0x11,
  0x8C, 0xA5, 0x38, 0x40, 0xE8, 0x8E, 0x11, 0x1E, 0x48, 0x8E, 0x99, 0x9E,
  0x78, 0x44, 0x22, 0x10, 0x80, 0xE9, 0x9E, 0x99, 0x9E, 0xE9, 0x99, 0xF1,
  0x2C, 0x00, 0x00, 0x16, 0x86, 0x10, 0x66, 0x88, 0xA8, 0x71, 0x11, 0x20,
  0x00, 0x7D, 0x06, 0xED, 0x5C, 0xB9, 0x72, 0xDF, 0x80, 0xF0, 0x20, 0xC3,
  0x12, 0x49, 0xE8, 0xA0, 0xF9, 0x9E, 0x99, 0x97, 0x74, 0x63, 0x08, 0x46,
  0x2E, 0x64, 0xA3, 0x18, 0xC6, 0x4C, 0x68, 0x8E, 0x88, 0x86, 0x68, 0x8E,
  0x88, 0x80, 0x74, 0x61, 0x09, 0x46, 0x2E, 0x0C, 0x63, 0xD8, 0xC6, 0x21,
  0xFF, 0x01, 0x11, 0x11, 0x17, 0x14, 0xA9, 0x8A, 0x52, 0x41, 0x08, 0x88,
  0x88, 0x86, 0x86, 0x18, 0xF3, 0xCE, 0xDB, 0x44, 0x8C, 0x73, 0x5A, 0xCE,
  0x21, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF9, 0x99, 0xF8, 0x80, 0x74, 0x63,
  0x18, 0xC6, 0x2E, 0x08, 0xF4, 0xA3, 0x2F, 0x42, 0x40, 0xF8, 0x8C, 0x31,
  0x1F, 0x71, 0x08, 0x42, 0x10, 0x80, 0x09, 0x99, 0x99, 0x97, 0x82, 0x24,
  0x92, 0x48, 0xC3, 0x00, 0x88, 0x99, 0x59, 0x55, 0x55, 0x66, 0x62, 0x22,
  0x02, 0x4C, 0x42, 0x19, 0x20, 0x81, 0x24, 0x8C, 0x20, 0x82, 0x00, 0x71,
  0x22, 0x48, 0x86, 0x7F, 0xC0, 0x88, 0x44, 0x42, 0x22, 0x00, 0x7F, 0xC0,
  0x46, 0x60, 0x60, 0x80, 0xE4, 0xFB, 0xC0, 0x08, 0x8E, 0x99, 0x99, 0xE0,
  0xF2, 0x49, 0xC0, 0x04, 0xFB, 0x6D, 0xE0, 0x74, 0x6D, 0x08, 0x38, 0x49,
  0x24, 0x92, 0x40, 0xF6, 0xDB, 0xCF, 0x12, 0x7B, 0x6D, 0x00, 0x1E, 0x1F,
  0xC0, 0x08, 0x8A, 0xC8, 0xCA, 0x00, 0x7F, 0x00, 0xED, 0x26, 0x4C, 0x99,
  0x20, 0x40, 0x76, 0xDA, 0x00, 0xE9, 0x99, 0x9E, 0xE9, 0x99, 0x9E, 0x80,
  0xF6, 0xDB, 0xC8, 0xAA, 0x80, 0xF3, 0x13, 0xC0, 0x49, 0x24, 0x90, 0x16,
  0xDB, 0xC0, 0x89, 0x55, 0x62, 0x13, 0x25, 0xB3, 0x62, 0x40, 0x00, 0x05,
  0x22, 0x50, 0x89, 0x55, 0x62, 0x24, 0x31, 0x22, 0x42, 0x29, 0x24, 0x12,
  0x48, 0x80, 0x7F, 0x00, 0x89, 0x24, 0x12, 0x4A, 0x00, 0xC9, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 1, 2, 3, 1, -8 },
  { 3, 5, 8, 5, 0, -8 },
  { 8, 4, 10, 5, 1, -9 },
  { 13, 6, 8, 7, 1, -8 },
  { 19, 5, 8, 6, 1, -8 },
  { 24, 1, 2, 2, 0, -8 },
  { 25, 2, 12, 3, 1, -9 },
  { 28, 2, 12, 3, 0, -9 },
  { 31, 5, 4, 5, 0, -8 },
  { 34, 5, 6, 5, 0, -6 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 3, 1, 3, 0, -4 },
  { 40, 1, 1, 2, 1, -1 },
  { 41, 3, 9, 4, 0, -8 },
  { 45, 4, 8, 5, 1, -8 },
  { 49, 2, 8, 5, 1, -8 },
  { 51, 4, 8, 5, 1, -8 },
  { 55, 4, 8, 5, 1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 4, 8, 5, 1, -8 },
  { 68, 4, 8, 5, 1, -8 },
  { 72, 5, 8, 5, 0, -8 },
  { 77, 4, 8, 5, 1, -8 },
  { 81, 4, 8, 5, 1, -8 },
  { 85, 1, 6, 2, 1, -6 },
  { 86, 1, 7, 2, 0, -6 },
  { 87, 4, 5, 5, 0, -6 },
  { 90, 4, 2, 5, 1, -5 },
  { 91, 3, 5, 5, 1, -6 },
  { 93, 4, 8, 4, 0, -8 },
  { 97, 7, 10, 9, 1, -8 },
  { 106, 6, 8, 6, 0, -8 },
  { 112, 4, 8, 6, 1, -8 },
  { 116, 5, 8, 6, 1, -8 },
  { 121, 5, 8, 6, 1, -8 },
  { 126, 4, 8, 6, 1, -8 },
  { 130, 4, 8, 5, 1, -8 },
  { 134, 5, 8, 7, 1, -8 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 1, 8, 3, 1, -8 },
  { 145, 4, 8, 5, 0, -8 },
  { 149, 5, 8, 6, 1, -8 },
  { 154, 4, 8, 5, 1, -8 },
  { 158, 6, 8, 8, 1, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 5, 8, 6, 1, -8 },
  { 174, 4, 8, 6, 1, -8 },
  { 178, 5, 9, 6, 1, -8 },
  { 184, 5, 8, 6, 1, -8 },
  { 189, 4, 8, 6, 1, -8 },
  { 193, 5, 8, 6, 0, -8 },
  { 198, 4, 8, 6, 1, -8 },
  { 202, 6, 8, 6, 0, -8 },
  { 208, 8, 8, 9, 0, -8 },
  { 216, 5, 8, 6, 0, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 4, 8, 6, 1, -8 },
  { 231, 1, 11, 2, 1, -9 },
  { 233, 4, 9, 4, 0, -8 },
  { 238, 1, 11, 2, 0, -9 },
  { 240, 4, 4, 4, 0, -8 },
  { 242, 4, 1, 4, 0, 0 },
  { 243, 1, 2, 3, 1, -9 },
  { 244, 3, 6, 5, 1, -6 },
  { 247, 4, 9, 5, 1, -9 },
  { 252, 3, 6, 5, 1, -6 },
  { 255, 3, 9, 5, 1, -9 },
  { 259, 5, 6, 5, 0, -6 },
  { 263, 3, 9, 3, 0, -9 },
  { 267, 3, 8, 5, 1, -6 },
  { 270, 3, 9, 5, 1, -9 },
  { 274, 1, 8, 2, 1, -8 },
  { 275, 1, 10, 2, 0, -8 },
  { 277, 4, 9, 5, 1, -9 },
  { 282, 1, 9, 2, 1, -9 },
  { 284, 7, 6, 9, 1, -6 },
  { 290, 3, 6, 5, 1, -6 },
  { 293, 4, 6, 5, 1, -6 },
  { 296, 4, 8, 5, 1, -6 },
  { 300, 3, 8, 5, 1, -6 },
  { 303, 2, 6, 3, 1, -6 },
  { 305, 3, 6, 5, 1, -6 },
  { 308, 3, 7, 3, 0, -7 },
  { 311, 3, 6, 5, 1, -6 },
  { 314, 4, 6, 5, 0, -6 },
  { 317, 7, 6, 7, 0, -6 },
  { 323, 4, 6, 5, 0, -6 },
  { 326, 4, 8, 5, 0, -6 },
  { 330, 4, 6, 5, 0, -6 },
  { 333, 3, 11, 3, 0, -9 },
  { 338, 1, 9, 2, 1, -8 },
  { 340, 3, 11, 3, 0, -9 },
  { 345, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT11PT7B_H_
