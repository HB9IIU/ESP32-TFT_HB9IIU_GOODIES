#ifndef _ROBOTOCONDENSED_EXTRALIGHT59PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xB0, 0xD8,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x10, 0x06, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC0, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80,
  0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x0F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0,
  0x3C, 0x07, 0x80, 0xC0, 0x07, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x38, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x37, 0x00, 0x01, 0xCC, 0x00, 0x06,
  0x38, 0x00, 0x38, 0x70, 0x01, 0xC0, 0xF0, 0x0E, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x08, 0x01, 0x80, 0xC0,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x0C, 0x0C, 0x00, 0x60, 0x08, 0x18, 0x00, 0x60, 0x18, 0x18, 0x00, 0x60,
  0x18, 0x30, 0x00, 0x30, 0x30, 0x70, 0x00, 0x1F, 0xE0, 0x60, 0x00, 0x0F,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0xF0, 0x00,
  0x06, 0x07, 0xBC, 0x00, 0x06, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x06, 0x00,
  0x0C, 0x18, 0x06, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x10, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x00, 0x30, 0x30, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00,
  0xE0, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x10, 0x03, 0x01,
  0x80, 0x18, 0x03, 0x01, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x1C, 0x01, 0xC3, 0x01, 0x80, 0x38, 0xC0, 0x38, 0x06, 0x38, 0x03,
  0x80, 0xC6, 0x00, 0x30, 0x18, 0xC0, 0x03, 0x03, 0x38, 0x00, 0x70, 0x67,
  0x00, 0x07, 0x1C, 0xC0, 0x00, 0x63, 0x18, 0x00, 0x06, 0x63, 0x80, 0x00,
  0xF8, 0x30, 0x00, 0x0F, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x3C, 0x0C,
  0x00, 0x0F, 0xC1, 0xC0, 0x03, 0x9C, 0x1E, 0x01, 0xE1, 0x81, 0xFF, 0xF0,
  0x38, 0x0F, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x40,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x40, 0x0C, 0x03, 0xF0, 0x18,
  0x1F, 0xFC, 0x31, 0xF8, 0x7E, 0x6F, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x00, 0x01, 0xC7, 0x00,
  0x07, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x0E, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0x33, 0x98, 0x80,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x60, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE7, 0x00, 0x06, 0x18, 0x00, 0x30, 0xE0,
  0x03, 0x83, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xF3, 0x7C, 0x3F, 0x03,
  0xC0, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x0E, 0x0C,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x10,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x60,
  0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x87, 0x00, 0x1C,
  0x0E, 0x00, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x3F, 0x80, 0x67, 0xFF, 0x03, 0xF0, 0x7C, 0x1E, 0x00,
  0xF0, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06,
  0x18, 0x00, 0x70, 0xE0, 0x03, 0x03, 0x80, 0x78, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x3F, 0x00,
  0xC3, 0xFF, 0x03, 0x1C, 0x1F, 0x0D, 0xC0, 0x1E, 0x36, 0x00, 0x38, 0xF0,
  0x00, 0x73, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xE0, 0x01,
  0x81, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x78, 0x0F, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x73,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x78, 0x3C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x81,
  0xE0, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x37, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1E,
  0x00, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0xF0, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x39,
  0x80, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77,
  0x00, 0x03, 0xCC, 0x00, 0x1B, 0x38, 0x00, 0xEC, 0x70, 0x07, 0x30, 0xF0,
  0x79, 0xC1, 0xFF, 0xC6, 0x01, 0xF8, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xEF, 0xE4,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0xFE, 0x40, 0x38, 0xF3, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86, 0x18,
  0x61, 0x8E, 0x38, 0xC7, 0x38, 0x40, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xE0, 0x38, 0x70, 0x07, 0x18, 0x00,
  0xEE, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0xF8, 0x00, 0x60, 0xE0, 0x01, 0xFF,
  0x00, 0x30, 0x60, 0x01, 0xC1, 0xC0, 0x08, 0x30, 0x01, 0x80, 0x60, 0x06,
  0x30, 0x01, 0x80, 0x30, 0x03, 0x18, 0x01, 0xC0, 0x18, 0x01, 0x8C, 0x00,
  0xC0, 0x0C, 0x00, 0xCE, 0x00, 0xC0, 0x06, 0x00, 0x66, 0x00, 0x60, 0x03,
  0x00, 0x33, 0x00, 0x30, 0x01, 0x80, 0x09, 0x80, 0x30, 0x00, 0xC0, 0x04,
  0xC0, 0x18, 0x00, 0x60, 0x02, 0x60, 0x0C, 0x00, 0x30, 0x01, 0x30, 0x06,
  0x00, 0x18, 0x00, 0x98, 0x03, 0x00, 0x0C, 0x00, 0xCC, 0x01, 0x80, 0x06,
  0x00, 0x64, 0x01, 0x80, 0x06, 0x00, 0x32, 0x00, 0xC0, 0x03, 0x00, 0x19,
  0x80, 0x60, 0x01, 0x80, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x06, 0x60, 0x18,
  0x00, 0x60, 0x03, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x18, 0x03, 0x00, 0x38,
  0x01, 0x8C, 0x01, 0x80, 0x1C, 0x00, 0xC6, 0x00, 0xC0, 0x1A, 0x00, 0xC3,
  0x00, 0x70, 0x19, 0x80, 0xC0, 0xC0, 0x1C, 0x18, 0xE0, 0xE0, 0x60, 0x07,
  0xFC, 0x3D, 0xE0, 0x30, 0x01, 0xF8, 0x0F, 0xE0, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x86, 0x00, 0x07, 0x8C,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x31, 0x80, 0x01, 0xC3, 0x00, 0x0F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x18, 0x00, 0x3C, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00,
  0x07, 0x30, 0x00, 0x1C, 0x60, 0x00, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E,
  0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x38, 0x07,
  0x80, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x01, 0xF8, 0x18, 0x00, 0x1E,
  0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00,
  0x03, 0xC1, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x0E, 0xE0, 0x00, 0x63, 0x00, 0x03, 0x1C, 0x00, 0x38, 0x70,
  0x03, 0x83, 0xC0, 0x38, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x0F, 0x00, 0x00, 0xC7, 0xE0, 0x00, 0x33, 0x98, 0x00, 0x0D,
  0xC7, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0x18, 0x00, 0x38, 0x07, 0x00,
  0x0C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C,
  0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00, 0x06, 0xF6,
  0x00, 0x00, 0x01, 0xBD, 0xC0, 0x00, 0x00, 0xEF, 0x30, 0x00, 0x00, 0x33,
  0xCC, 0x00, 0x00, 0x0C, 0xF3, 0x80, 0x00, 0x07, 0x3C, 0x60, 0x00, 0x01,
  0x8F, 0x18, 0x00, 0x00, 0x63, 0xC7, 0x00, 0x00, 0x38, 0xF0, 0xC0, 0x00,
  0x0C, 0x3C, 0x30, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x01, 0x83, 0xC1, 0x80,
  0x00, 0x60, 0xF0, 0x60, 0x00, 0x18, 0x3C, 0x0C, 0x00, 0x0C, 0x0F, 0x03,
  0x00, 0x03, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xF0, 0x18, 0x00, 0x60, 0x3C,
  0x06, 0x00, 0x18, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x30, 0x03, 0x00,
  0xF0, 0x0C, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x60, 0x0F, 0x00, 0x60, 0x18,
  0x03, 0xC0, 0x18, 0x06, 0x00, 0xF0, 0x03, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0xC0, 0x0F, 0x00, 0x38, 0x30, 0x03, 0xC0, 0x06, 0x18, 0x00, 0xF0, 0x01,
  0x86, 0x00, 0x3C, 0x00, 0x73, 0x80, 0x0F, 0x00, 0x0C, 0xC0, 0x03, 0xC0,
  0x03, 0x30, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x30, 0x00,
  0x0F, 0x06, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x3C, 0x0E,
  0x00, 0x0F, 0x01, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0C, 0x00, 0x3C,
  0x01, 0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x80,
  0x3C, 0x00, 0x60, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x00, 0xF0, 0x00,
  0x60, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x18, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x18,
  0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x06, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF0, 0xC0, 0x00, 0x78, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x78, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x06, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x78, 0x18, 0x00, 0x0E, 0x0C, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x06, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x3C, 0x00, 0x1C, 0x1E,
  0x00, 0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x76, 0x00, 0x01, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x01, 0x9C, 0x00,
  0x06, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00,
  0xC3, 0x80, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x1C, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x01, 0x80,
  0x60, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x1C, 0x0C, 0x00,
  0xC0, 0x60, 0x07, 0x03, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x86, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x07, 0x1C, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x18, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0xE0, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x30,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0x80, 0x01, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0x00, 0x31, 0xC0, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0xB0, 0x00, 0x3D, 0xC0, 0x03, 0x67, 0x00, 0x3B, 0x3C, 0x03, 0x98,
  0xFF, 0xF8, 0xC1, 0xFF, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0x00, 0x70, 0xFF, 0x83, 0x9F, 0xFE, 0x1D,
  0xC0, 0x38, 0xF8, 0x00, 0xE7, 0xC0, 0x03, 0xBC, 0x00, 0x0D, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1B,
  0xC0, 0x00, 0xDE, 0x00, 0x0C, 0xF8, 0x00, 0xE7, 0x70, 0x0E, 0x39, 0xFF,
  0xE1, 0xC3, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3C, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC0,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00,
  0x3B, 0x00, 0x01, 0x9C, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x0E, 0x0F,
  0x00, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x02, 0x01, 0x81, 0xFF, 0x0C, 0x3F,
  0xFC, 0x63, 0xC0, 0x33, 0x18, 0x00, 0xD9, 0xC0, 0x03, 0xCC, 0x00, 0x0E,
  0xE0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB8,
  0x00, 0x0C, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x1C, 0x00, 0xD8, 0xF0, 0x0E,
  0xC3, 0xFF, 0xE6, 0x07, 0xFC, 0x30, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3C, 0x03, 0x81, 0x80, 0x0E, 0x18, 0x00,
  0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x03, 0x07, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0xC3, 0xFF, 0xC6, 0x3C, 0x03, 0x31,
  0x80, 0x0D, 0x9C, 0x00, 0x3C, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x00, 0xCC, 0x00, 0x0E,
  0x70, 0x00, 0xF1, 0x80, 0x0D, 0x8F, 0x00, 0xEC, 0x3F, 0xFE, 0x60, 0x7F,
  0xC3, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x40, 0x00, 0xC7, 0x00, 0x0E, 0x1C, 0x00,
  0xE0, 0x78, 0x1E, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x83, 0xFC, 0x31, 0xFF, 0xC6, 0x70, 0x1C, 0xD8,
  0x01, 0xDB, 0x00, 0x1B, 0xC0, 0x03, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x3F, 0x8F,
  0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0xB0, 0x00,
  0xE6, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x70, 0x60, 0x1C,
  0x0C, 0x07, 0x01, 0x81, 0xC0, 0x30, 0x70, 0x06, 0x1C, 0x00, 0xC7, 0x00,
  0x18, 0xC0, 0x03, 0x38, 0x00, 0x6F, 0x80, 0x0F, 0xB0, 0x01, 0xE3, 0x00,
  0x38, 0x70, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xE0,
  0x60, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x86, 0x00, 0x18,
  0xC0, 0x03, 0x98, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x0F, 0xF8, 0x07, 0xFC, 0x30, 0xFF, 0xE0, 0x7F, 0xF1, 0xCC,
  0x03, 0x87, 0x01, 0xCE, 0xC0, 0x0E, 0x60, 0x07, 0x7C, 0x00, 0x36, 0x00,
  0x1B, 0xC0, 0x01, 0xB0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x07,
  0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x18,
  0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C,
  0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0xF0,
  0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x3F, 0xC3, 0x1F, 0xFC, 0x67, 0x01, 0xCD, 0x80,
  0x1D, 0xB0, 0x01, 0xBC, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03,
  0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x1D, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8E, 0x00, 0x0C, 0x1C, 0x00,
  0x70, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xDC, 0x03, 0x8F, 0x80,
  0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xE0,
  0x00, 0xCF, 0x80, 0x0E, 0x77, 0x00, 0xE3, 0x9F, 0xFE, 0x1C, 0x3F, 0xE0,
  0xE0, 0x30, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0xC3, 0xFF, 0xC6, 0x3C, 0x03, 0xB1, 0x80, 0x0D, 0x9C, 0x00, 0x3C,
  0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x70, 0x00, 0xF1, 0x80, 0x0F,
  0x8F, 0x00, 0xEC, 0x3F, 0xFE, 0x60, 0x7F, 0xC3, 0x00, 0x20, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x3F, 0xCF, 0xED, 0xC0, 0xD8, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xC0, 0x38, 0x30, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x66,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0xC0, 0x3C, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x08, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x1B, 0x1C,
  0x03, 0x31, 0xFF, 0xE3, 0x07, 0xFC, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00,
  0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x38, 0x00, 0x60, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC1, 0xC0, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xD8,
  0x00, 0x38, 0x00, 0x36, 0x00, 0x0E, 0x00, 0x1D, 0x80, 0x07, 0x80, 0x06,
  0x70, 0x01, 0xE0, 0x01, 0x8C, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x1B, 0x00,
  0x38, 0xC0, 0x0C, 0xC0, 0x0C, 0x38, 0x03, 0x38, 0x03, 0x06, 0x00, 0xC6,
  0x00, 0xC1, 0x80, 0x71, 0x80, 0x70, 0x60, 0x18, 0x60, 0x18, 0x1C, 0x06,
  0x1C, 0x06, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC0, 0xC0, 0xC0, 0xE0, 0x30,
  0x30, 0x30, 0x30, 0x0E, 0x0C, 0x06, 0x0C, 0x01, 0x83, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x61, 0xC0, 0x18, 0x60, 0x1C, 0x60, 0x07, 0x18, 0x03, 0x18,
  0x00, 0xCE, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06,
  0xC0, 0x03, 0x30, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x1E, 0x00,
  0x1B, 0x00, 0x07, 0x80, 0x02, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x3B, 0x80, 0x03,
  0x8C, 0x00, 0x18, 0x70, 0x01, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0xE0, 0x38,
  0x0E, 0x00, 0xC0, 0x60, 0x07, 0x07, 0x00, 0x18, 0x30, 0x00, 0x63, 0x80,
  0x03, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00,
  0x30, 0x60, 0x03, 0x83, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x0C, 0x01,
  0x80, 0xE0, 0x06, 0x0E, 0x00, 0x38, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x30,
  0x00, 0x1B, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0,
  0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x87, 0x00, 0x07, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01,
  0x80, 0x70, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x30,
  0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x07, 0x03, 0x00, 0x06, 0x0E, 0x00,
  0x0C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x0C, 0xE1, 0xE0, 0x01, 0xB8, 0x0E, 0x00,
  0x36, 0x00, 0xE0, 0x0E, 0xC0, 0x0E, 0x01, 0xB8, 0x00, 0xE0, 0x76, 0x00,
  0x0E, 0x1C, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 43, 12, 4, -42 },
  { 23, 9, 12, 16, 4, -44 },
  { 37, 27, 42, 29, 2, -42 },
  { 179, 22, 55, 29, 3, -49 },
  { 331, 32, 44, 38, 3, -43 },
  { 507, 27, 44, 32, 3, -43 },
  { 656, 2, 12, 10, 4, -44 },
  { 659, 11, 61, 17, 4, -47 },
  { 743, 11, 61, 17, 1, -47 },
  { 827, 23, 23, 25, 1, -42 },
  { 894, 25, 30, 29, 2, -34 },
  { 988, 5, 12, 11, 2, -5 },
  { 996, 11, 2, 16, 2, -20 },
  { 999, 4, 4, 13, 4, -3 },
  { 1001, 17, 46, 21, 1, -42 },
  { 1099, 21, 44, 29, 4, -43 },
  { 1215, 12, 42, 29, 5, -42 },
  { 1278, 23, 43, 29, 3, -43 },
  { 1402, 22, 44, 29, 3, -43 },
  { 1523, 25, 42, 29, 2, -42 },
  { 1655, 21, 43, 29, 5, -42 },
  { 1768, 22, 43, 29, 4, -42 },
  { 1887, 23, 42, 29, 2, -42 },
  { 2008, 23, 44, 29, 3, -43 },
  { 2135, 22, 43, 29, 3, -43 },
  { 2254, 4, 31, 11, 4, -30 },
  { 2270, 6, 37, 10, 2, -30 },
  { 2298, 21, 24, 27, 2, -31 },
  { 2361, 20, 14, 29, 4, -26 },
  { 2396, 21, 24, 27, 3, -31 },
  { 2459, 18, 44, 23, 3, -43 },
  { 2558, 41, 54, 47, 3, -41 },
  { 2835, 29, 42, 32, 1, -42 },
  { 2988, 23, 42, 31, 5, -42 },
  { 3109, 26, 44, 33, 4, -43 },
  { 3252, 25, 42, 34, 5, -42 },
  { 3384, 22, 42, 30, 5, -42 },
  { 3500, 22, 42, 29, 5, -42 },
  { 3616, 26, 44, 35, 5, -43 },
  { 3759, 26, 42, 36, 5, -42 },
  { 3896, 2, 42, 14, 6, -42 },
  { 3907, 21, 43, 29, 2, -42 },
  { 4020, 26, 42, 33, 5, -42 },
  { 4157, 20, 42, 27, 5, -42 },
  { 4262, 34, 42, 44, 5, -42 },
  { 4441, 26, 42, 36, 5, -42 },
  { 4578, 27, 44, 35, 4, -43 },
  { 4727, 24, 42, 31, 5, -42 },
  { 4853, 27, 51, 35, 4, -43 },
  { 5026, 25, 42, 33, 5, -42 },
  { 5158, 25, 44, 31, 3, -43 },
  { 5296, 27, 42, 31, 2, -42 },
  { 5438, 24, 43, 34, 5, -42 },
  { 5567, 29, 42, 31, 1, -42 },
  { 5720, 42, 42, 46, 2, -42 },
  { 5941, 27, 42, 31, 2, -42 },
  { 6083, 29, 42, 31, 1, -42 },
  { 6236, 25, 42, 31, 3, -42 },
  { 6368, 7, 57, 13, 5, -48 },
  { 6418, 17, 46, 20, 2, -42 },
  { 6516, 8, 57, 13, 0, -48 },
  { 6573, 16, 21, 22, 3, -42 },
  { 6615, 21, 2, 22, 1, 0 },
  { 6621, 8, 8, 16, 4, -44 },
  { 6629, 21, 33, 28, 3, -32 },
  { 6716, 21, 45, 29, 4, -44 },
  { 6835, 21, 33, 27, 3, -32 },
  { 6922, 21, 45, 29, 3, -44 },
  { 7041, 21, 33, 27, 3, -32 },
  { 7128, 15, 45, 17, 2, -45 },
  { 7213, 21, 44, 29, 3, -32 },
  { 7329, 19, 44, 28, 5, -44 },
  { 7434, 4, 43, 12, 4, -43 },
  { 7456, 10, 55, 12, -2, -43 },
  { 7525, 19, 44, 25, 5, -44 },
  { 7630, 2, 44, 12, 5, -44 },
  { 7641, 37, 32, 46, 4, -32 },
  { 7789, 19, 32, 28, 5, -32 },
  { 7865, 22, 33, 29, 3, -32 },
  { 7956, 21, 44, 29, 4, -32 },
  { 8072, 21, 44, 29, 3, -32 },
  { 8188, 12, 32, 18, 5, -32 },
  { 8236, 20, 33, 26, 3, -32 },
  { 8319, 14, 40, 17, 1, -39 },
  { 8389, 20, 32, 28, 4, -31 },
  { 8469, 21, 31, 25, 2, -31 },
  { 8551, 34, 31, 39, 2, -31 },
  { 8683, 21, 31, 25, 2, -31 },
  { 8765, 23, 43, 25, 1, -31 },
  { 8889, 20, 31, 25, 3, -31 },
  { 8967, 15, 58, 17, 2, -46 },
  { 9076, 2, 50, 12, 5, -42 },
  { 9089, 14, 58, 17, 1, -46 },
  { 9191, 27, 10, 35, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT59PT7B_H_
