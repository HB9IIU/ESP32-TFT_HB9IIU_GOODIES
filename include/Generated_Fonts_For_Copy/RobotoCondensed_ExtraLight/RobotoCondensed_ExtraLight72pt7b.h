#ifndef _ROBOTOCONDENSED_EXTRALIGHT72PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight72pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF6, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xB8,
  0x37, 0x06, 0xE0, 0xDC, 0x1B, 0x83, 0x70, 0x6E, 0x0D, 0xC1, 0xB0, 0x30,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0C,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00,
  0xE0, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x01, 0x80, 0x1C,
  0x0E, 0x00, 0x03, 0x80, 0x30, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x70, 0x00,
  0x03, 0x87, 0x80, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x03, 0xF8,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0x30, 0x0F,
  0xF8, 0x00, 0x00, 0xE0, 0x38, 0x78, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x00, 0x38, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x18, 0x03,
  0x00, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x30, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x70, 0x07, 0x80,
  0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0x70, 0x07, 0x1C, 0x00, 0x1C,
  0x03, 0x8C, 0x00, 0x0F, 0x01, 0x8E, 0x00, 0x03, 0x80, 0xC7, 0x00, 0x00,
  0xE0, 0xE3, 0x80, 0x00, 0x38, 0x71, 0xC0, 0x00, 0x1E, 0x30, 0xE0, 0x00,
  0x07, 0x38, 0x70, 0x00, 0x01, 0xDC, 0x38, 0x00, 0x00, 0x7C, 0x1C, 0x00,
  0x00, 0x3E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x0E, 0xE0, 0x78, 0x00, 0x0E, 0x70, 0x1E, 0x00, 0x1E, 0x1C, 0x07,
  0xC0, 0x3E, 0x07, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x20, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x07, 0xF8, 0x07, 0x01, 0xFF, 0xF0, 0x70,
  0xFE, 0x1F, 0xE7, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x20, 0x00, 0x20, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3,
  0x9C, 0x73, 0x84, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x1F,
  0xF0, 0xFC, 0xE7, 0xE1, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0xE0,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x1F, 0x00, 0x0E, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x06,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0F, 0xE0, 0x03, 0x1F, 0xFE, 0x01,
  0xBF, 0xFF, 0x80, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x70, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x38,
  0x0F, 0x80, 0x78, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x03, 0xF8, 0x03, 0x83, 0xFF, 0x80, 0xE3, 0xFF, 0xF8, 0x31, 0xE0, 0x1F,
  0x0C, 0xE0, 0x01, 0xE3, 0x70, 0x00, 0x38, 0xF8, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x1C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x06, 0xC7, 0x00,
  0x03, 0x31, 0xE0, 0x03, 0xCC, 0x3E, 0x01, 0xE7, 0x07, 0xFF, 0xF1, 0xC0,
  0x7F, 0xF0, 0x70, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xF7,
  0x98, 0x38, 0xF7, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0xE7, 0x3C, 0xE1, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78, 0x1C, 0x00, 0xF0, 0xE0, 0x01,
  0xC3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0xFF, 0x00, 0x06, 0x0E, 0x00, 0x07, 0xE7, 0xC0, 0x03,
  0x87, 0x00, 0x07, 0x80, 0x70, 0x00, 0xC3, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x63, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x60, 0x01, 0xC0, 0x01, 0x80,
  0x07, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xB8, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xD8, 0x00, 0x70, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x36, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0D, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x03, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x1B, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x0D, 0xC0, 0x06, 0x00,
  0x07, 0x00, 0x06, 0x60, 0x03, 0x00, 0x03, 0x80, 0x07, 0x30, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x18, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0x8C, 0x00, 0x70,
  0x00, 0xB0, 0x01, 0xC7, 0x00, 0x38, 0x00, 0xD8, 0x00, 0xC3, 0x80, 0x0C,
  0x00, 0xCE, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x60, 0x01,
  0xC0, 0xE1, 0xC0, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1C, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x06, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x1F, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x83, 0x80,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF8,
  0x38, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0x00, 0xE3, 0xF8, 0x00, 0x00, 0xE3, 0xB8, 0x00, 0x00, 0xE7, 0x1C, 0x00,
  0x00, 0xEE, 0x0E, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x6F,
  0xB0, 0x00, 0x00, 0x00, 0x77, 0xDC, 0x00, 0x00, 0x00, 0x3B, 0xEE, 0x00,
  0x00, 0x00, 0x19, 0xF3, 0x00, 0x00, 0x00, 0x1C, 0xF9, 0xC0, 0x00, 0x00,
  0x0E, 0x7C, 0xE0, 0x00, 0x00, 0x06, 0x3E, 0x38, 0x00, 0x00, 0x07, 0x1F,
  0x1C, 0x00, 0x00, 0x03, 0x8F, 0x86, 0x00, 0x00, 0x03, 0x87, 0xC3, 0x80,
  0x00, 0x01, 0xC3, 0xE1, 0xC0, 0x00, 0x00, 0xC1, 0xF0, 0x60, 0x00, 0x00,
  0xE0, 0xF8, 0x38, 0x00, 0x00, 0x70, 0x7C, 0x1C, 0x00, 0x00, 0x30, 0x3E,
  0x06, 0x00, 0x00, 0x38, 0x1F, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x81, 0xC0,
  0x00, 0x0C, 0x07, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0xE0, 0x38, 0x00, 0x07,
  0x01, 0xF0, 0x0C, 0x00, 0x07, 0x00, 0xF8, 0x07, 0x00, 0x03, 0x80, 0x7C,
  0x03, 0x80, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x70,
  0x00, 0xE0, 0x0F, 0x80, 0x38, 0x00, 0x60, 0x07, 0xC0, 0x0C, 0x00, 0x70,
  0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x03, 0x80, 0x18, 0x00, 0xF8,
  0x00, 0xC0, 0x1C, 0x00, 0x7C, 0x00, 0x70, 0x0E, 0x00, 0x3E, 0x00, 0x18,
  0x06, 0x00, 0x1F, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x80, 0x07, 0x03, 0x00,
  0x07, 0xC0, 0x01, 0x83, 0x80, 0x03, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xF0,
  0x00, 0x70, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0xE0, 0x00, 0x7C, 0x00, 0x0E,
  0x70, 0x00, 0x3E, 0x00, 0x07, 0x30, 0x00, 0x1F, 0x00, 0x01, 0xB8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x07, 0xE7,
  0x00, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x07, 0xE1,
  0xC0, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0xE0,
  0xE0, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x07, 0xE0,
  0x38, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x07, 0xE0,
  0x0E, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0,
  0x01, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x60, 0x07, 0xE0,
  0x00, 0x70, 0x07, 0xE0, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x38, 0x07, 0xE0,
  0x00, 0x1C, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x0E, 0x07, 0xE0,
  0x00, 0x07, 0x07, 0xE0, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x03, 0x87, 0xE0,
  0x00, 0x03, 0x87, 0xE0, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x01, 0xC7, 0xE0,
  0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x00, 0x77, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x00,
  0x1F, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x03,
  0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xE3, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0xF8, 0x0E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x03,
  0x80, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0xC0,
  0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x07, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1D, 0x80, 0x01, 0x98, 0x00, 0x39,
  0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x60, 0x06,
  0x06, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x1C, 0x03, 0x81,
  0xC0, 0x18, 0x18, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x81, 0xE0,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0x00,
  0xE1, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x9C, 0x00, 0x0D, 0xCF,
  0x00, 0x1E, 0x63, 0xC0, 0x3E, 0x30, 0xFF, 0xFC, 0x1C, 0x3F, 0xFC, 0x0E,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x00, 0xE0, 0xFF, 0xE0, 0x38, 0x7F,
  0xFE, 0x0E, 0x78, 0x07, 0xC3, 0x98, 0x00, 0x78, 0xEC, 0x00, 0x0E, 0x3E,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0x3F, 0x00, 0x03, 0x8E, 0xE0, 0x01,
  0xE3, 0x9E, 0x01, 0xF0, 0xE3, 0xFF, 0xF8, 0x38, 0x3F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xF0, 0x0F, 0x01, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8F, 0x00, 0x03, 0x83, 0xC0, 0x03, 0x80, 0xF8, 0x07, 0xC0, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0x01, 0xFF, 0xC1,
  0x83, 0xFF, 0xF0, 0xC3, 0xE0, 0x1E, 0x63, 0xC0, 0x03, 0x31, 0xC0, 0x00,
  0xD9, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x06, 0xC7, 0x80, 0x07, 0x61, 0xF0,
  0x0F, 0x30, 0x7F, 0xFF, 0x18, 0x0F, 0xFE, 0x0C, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x00, 0xF8,
  0x0F, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x3E, 0x00, 0x1E, 0x07, 0xE0, 0x1F, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xFF, 0xF8, 0x61, 0xF0,
  0x0F, 0x31, 0xE0, 0x01, 0x98, 0xE0, 0x00, 0x6C, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xC7,
  0x00, 0x03, 0x63, 0xC0, 0x03, 0xB0, 0xF8, 0x07, 0x98, 0x3F, 0xFF, 0x8C,
  0x07, 0xFF, 0x06, 0x00, 0x7C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x20, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0F, 0x80,
  0xC0, 0xFF, 0xC1, 0x83, 0xFF, 0xE3, 0x1E, 0x03, 0xE6, 0x30, 0x01, 0xCC,
  0xC0, 0x01, 0xDB, 0x00, 0x03, 0xB6, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x3C, 0xFF, 0x8F, 0xF0, 0x7C, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0xC0, 0x01, 0xE0,
  0xC0, 0x03, 0xC0, 0xC0, 0x07, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xF0, 0x00,
  0xC1, 0xE0, 0x00, 0xC3, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0xC7, 0x80, 0x00,
  0xCF, 0x80, 0x00, 0xDD, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x3C, 0x00, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x78, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1E,
  0xC0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x38,
  0x7F, 0xFE, 0x03, 0xFF, 0xF1, 0xC7, 0x80, 0xF0, 0x3C, 0x07, 0xCE, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x77, 0x00, 0x0F, 0x38, 0x00, 0x3B, 0xB0, 0x00,
  0x3B, 0x80, 0x01, 0xDF, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x01, 0x81, 0xFF, 0x83, 0x07, 0xFF,
  0xC6, 0x3C, 0x07, 0xCC, 0x60, 0x03, 0x99, 0x80, 0x03, 0xB6, 0x00, 0x07,
  0x6C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x38, 0x3F, 0xF8, 0x0E, 0x3F, 0xFF, 0x83, 0x9E, 0x01,
  0xF0, 0xEE, 0x00, 0x1E, 0x3B, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0C, 0xF0, 0x00, 0x07, 0x3E,
  0x00, 0x01, 0xCF, 0xC0, 0x00, 0xE3, 0xB8, 0x00, 0x70, 0xE7, 0x80, 0x7C,
  0x38, 0xFF, 0xFE, 0x0E, 0x0F, 0xFE, 0x03, 0x80, 0x7C, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xE0, 0xC1, 0xFF, 0xF8, 0x61, 0xF0, 0x0F, 0x31, 0xE0, 0x01, 0xD8,
  0xE0, 0x00, 0x6C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xE3, 0xC0, 0x03,
  0xB0, 0xF8, 0x07, 0x98, 0x3F, 0xFF, 0x8C, 0x07, 0xFF, 0x06, 0x00, 0x7C,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x07,
  0xFC, 0x3F, 0xF1, 0xE0, 0xCE, 0x03, 0x70, 0x0D, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x38,
  0x00, 0x1B, 0x1C, 0x00, 0x73, 0x1F, 0x00, 0xF3, 0x0F, 0xFF, 0xC3, 0x03,
  0xFF, 0x83, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0xEC, 0x00, 0x07, 0xC0, 0x00, 0x67, 0x00,
  0x03, 0x60, 0x00, 0x73, 0x80, 0x01, 0xB0, 0x00, 0x39, 0xC0, 0x00, 0xD8,
  0x00, 0x1C, 0x60, 0x00, 0xEE, 0x00, 0x0C, 0x38, 0x00, 0x77, 0x00, 0x0E,
  0x1C, 0x00, 0x31, 0x80, 0x07, 0x0E, 0x00, 0x18, 0xE0, 0x03, 0x83, 0x00,
  0x1C, 0x70, 0x01, 0x81, 0xC0, 0x0C, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x0C,
  0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x70, 0x18, 0x03, 0x83, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x60, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x70, 0x30, 0x06,
  0x07, 0x00, 0x38, 0x18, 0x03, 0x03, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x30, 0x60, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0x78, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x06, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xC7, 0xFF, 0x80, 0x00, 0xE7, 0x81, 0xE0, 0x00,
  0x73, 0x00, 0x78, 0x00, 0x33, 0x80, 0x1E, 0x00, 0x19, 0x80, 0x07, 0x80,
  0x1C, 0xC0, 0x01, 0xE0, 0x0C, 0xE0, 0x00, 0x78, 0x1E, 0x70, 0x00, 0x1F,
  0xFE, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 52, 14, 5, -51 },
  { 27, 11, 15, 19, 5, -54 },
  { 48, 33, 51, 36, 3, -51 },
  { 259, 27, 67, 35, 4, -59 },
  { 486, 39, 53, 47, 4, -52 },
  { 745, 33, 53, 39, 4, -52 },
  { 964, 2, 15, 12, 5, -54 },
  { 968, 14, 74, 20, 5, -57 },
  { 1098, 13, 74, 21, 2, -57 },
  { 1219, 28, 28, 30, 1, -51 },
  { 1317, 30, 37, 36, 3, -43 },
  { 1456, 6, 15, 14, 3, -6 },
  { 1468, 14, 2, 19, 2, -24 },
  { 1472, 5, 5, 16, 5, -4 },
  { 1476, 20, 55, 25, 2, -51 },
  { 1614, 27, 53, 35, 4, -52 },
  { 1793, 15, 51, 35, 6, -51 },
  { 1889, 28, 52, 35, 4, -52 },
  { 2071, 27, 53, 35, 4, -52 },
  { 2250, 30, 51, 35, 3, -51 },
  { 2442, 25, 52, 35, 6, -51 },
  { 2605, 26, 52, 35, 5, -51 },
  { 2774, 28, 51, 35, 3, -51 },
  { 2953, 27, 53, 35, 4, -52 },
  { 3132, 26, 52, 35, 4, -52 },
  { 3301, 5, 38, 13, 4, -37 },
  { 3325, 6, 46, 13, 3, -37 },
  { 3360, 25, 29, 33, 3, -38 },
  { 3451, 25, 17, 35, 5, -32 },
  { 3505, 25, 29, 33, 4, -38 },
  { 3596, 22, 53, 28, 3, -52 },
  { 3742, 49, 66, 57, 4, -50 },
  { 4147, 35, 51, 39, 2, -51 },
  { 4371, 28, 51, 38, 6, -51 },
  { 4550, 31, 53, 41, 5, -52 },
  { 4756, 30, 51, 41, 6, -51 },
  { 4948, 27, 51, 36, 6, -51 },
  { 5121, 27, 51, 36, 6, -51 },
  { 5294, 31, 53, 43, 6, -52 },
  { 5500, 32, 51, 44, 6, -51 },
  { 5704, 3, 51, 17, 7, -51 },
  { 5724, 26, 52, 35, 3, -51 },
  { 5893, 32, 51, 40, 6, -51 },
  { 6097, 25, 51, 33, 6, -51 },
  { 6257, 41, 51, 54, 6, -51 },
  { 6519, 32, 51, 45, 6, -51 },
  { 6723, 32, 53, 42, 5, -52 },
  { 6935, 29, 51, 38, 6, -51 },
  { 7120, 32, 61, 42, 5, -52 },
  { 7364, 31, 51, 41, 6, -51 },
  { 7562, 31, 53, 37, 3, -52 },
  { 7768, 33, 51, 38, 2, -51 },
  { 7979, 30, 52, 42, 6, -51 },
  { 8174, 35, 51, 38, 2, -51 },
  { 8398, 52, 51, 56, 2, -51 },
  { 8730, 34, 51, 38, 2, -51 },
  { 8947, 34, 51, 38, 2, -51 },
  { 9164, 31, 51, 38, 3, -51 },
  { 9362, 9, 70, 15, 6, -59 },
  { 9441, 21, 55, 25, 2, -51 },
  { 9586, 9, 70, 15, 1, -59 },
  { 9665, 20, 26, 27, 3, -51 },
  { 9730, 25, 3, 27, 1, 0 },
  { 9740, 11, 10, 20, 4, -54 },
  { 9754, 25, 40, 34, 4, -39 },
  { 9879, 26, 55, 35, 5, -54 },
  { 10058, 25, 40, 32, 4, -39 },
  { 10183, 25, 55, 35, 4, -54 },
  { 10355, 26, 40, 33, 3, -39 },
  { 10485, 18, 55, 21, 3, -55 },
  { 10609, 25, 54, 35, 4, -39 },
  { 10778, 23, 54, 35, 6, -54 },
  { 10934, 4, 52, 14, 5, -52 },
  { 10960, 12, 67, 15, -3, -52 },
  { 11061, 24, 54, 31, 6, -54 },
  { 11223, 3, 54, 14, 6, -54 },
  { 11244, 45, 39, 56, 5, -39 },
  { 11464, 23, 39, 35, 6, -39 },
  { 11577, 27, 40, 35, 4, -39 },
  { 11712, 26, 54, 35, 5, -39 },
  { 11888, 25, 54, 35, 4, -39 },
  { 12057, 14, 39, 22, 6, -39 },
  { 12126, 24, 40, 32, 4, -39 },
  { 12246, 16, 49, 21, 2, -48 },
  { 12344, 24, 39, 35, 5, -38 },
  { 12461, 27, 38, 31, 2, -38 },
  { 12590, 41, 38, 47, 3, -38 },
  { 12785, 26, 38, 31, 2, -38 },
  { 12909, 27, 53, 30, 2, -38 },
  { 13088, 25, 38, 31, 3, -38 },
  { 13207, 17, 71, 21, 3, -56 },
  { 13358, 3, 61, 15, 6, -51 },
  { 13381, 17, 71, 21, 1, -56 },
  { 13532, 33, 12, 43, 5, -27 },
};

const GFXfont RobotoCondensed_ExtraLight72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT72PT7B_H_
