#ifndef _ROBOTOCONDENSED_EXTRALIGHT69PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xF6, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x60, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x07,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF1, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x80, 0x01,
  0xE1, 0xE0, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0x30, 0x06, 0x00, 0x38, 0x01, 0x80, 0x30, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0xE0, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x70,
  0x00, 0xE0, 0x06, 0x03, 0x00, 0x03, 0x00, 0x30, 0x38, 0x00, 0x18, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0x38, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0xC0, 0x00,
  0x0F, 0xF8, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xF0, 0x00, 0x00, 0xC0, 0x7F, 0xE0, 0x00, 0x06, 0x07, 0x87, 0x00, 0x00,
  0x60, 0x30, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x70, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x03, 0x81, 0xC0, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x60, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x06, 0x00, 0x18, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x38, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x06,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x03, 0x0E, 0x00, 0xE0, 0x06, 0x38, 0x00, 0xE0, 0x0C, 0x70,
  0x01, 0xC0, 0x18, 0xC0, 0x01, 0xC0, 0x33, 0x80, 0x01, 0xC0, 0xE7, 0x00,
  0x03, 0xC1, 0xCC, 0x00, 0x03, 0x83, 0x18, 0x00, 0x03, 0x86, 0x30, 0x00,
  0x03, 0x9C, 0x60, 0x00, 0x07, 0xB0, 0xE0, 0x00, 0x07, 0xE1, 0xC0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x7E, 0x07, 0x00, 0x01, 0xCE, 0x0F, 0x00, 0x07, 0x0E, 0x0F, 0x80, 0x3C,
  0x1C, 0x07, 0xFF, 0xF0, 0x1C, 0x07, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x6D, 0xB6, 0xDB, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x40, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x1F, 0xF0, 0x18, 0x1F,
  0x9F, 0xC3, 0x0F, 0xC0, 0x7E, 0x6F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xE0, 0x18, 0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0x39, 0xDC,
  0xEE, 0x71, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x67, 0xBF, 0xE6, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0x70, 0x00,
  0x07, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0x9D, 0xF8, 0x7F, 0x01, 0xF0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0x80,
  0x03, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0xFE, 0x00, 0x73,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7E, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x0F, 0xE0, 0x06, 0x0F, 0xFE, 0x01, 0x8F, 0xEF,
  0xE0, 0x67, 0x80, 0x3C, 0x1B, 0x80, 0x07, 0x8E, 0xC0, 0x00, 0xE3, 0xE0,
  0x00, 0x1C, 0xF8, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x07, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3E,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x78, 0x0F, 0x80, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x3C, 0x01,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x98, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xE7,
  0x00, 0x01, 0xB3, 0x80, 0x01, 0xB8, 0xE0, 0x01, 0xDC, 0x3C, 0x03, 0xCE,
  0x0F, 0xDF, 0xC7, 0x03, 0xFF, 0x83, 0x80, 0x7F, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x33, 0xFE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFF, 0xF7, 0x00,
  0x08, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x38,
  0x71, 0xC3, 0x82, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83,
  0xC0, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0xFE, 0x00,
  0x0C, 0x1C, 0x00, 0x1F, 0x1E, 0x00, 0x18, 0x30, 0x00, 0x78, 0x0F, 0x00,
  0x18, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x31, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x63, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x9C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xB0, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x0D,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3E,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xF8,
  0x01, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x07, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x36, 0x00, 0x30, 0x00, 0x30, 0x00, 0x6C, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xDC, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xB8, 0x01,
  0x80, 0x01, 0x80, 0x07, 0x70, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x60, 0x06,
  0x00, 0x0E, 0x00, 0x18, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x71, 0x80, 0x0C,
  0x00, 0x7C, 0x00, 0xC3, 0x00, 0x18, 0x01, 0x98, 0x03, 0x87, 0x00, 0x38,
  0x07, 0x30, 0x0E, 0x06, 0x00, 0x38, 0x1C, 0x70, 0x38, 0x0C, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x38, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x3F, 0xE0, 0x70,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x78, 0x38, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x38, 0x03, 0xFE, 0x01, 0xC0, 0x00,
  0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x1F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0xFC, 0x00, 0x00, 0xE7, 0x78,
  0x00, 0x03, 0xB8, 0xE0, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x3F, 0x03, 0x80,
  0x00, 0xF8, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x06, 0xFF, 0x00, 0x00, 0x00, 0x0D, 0xF6, 0x00, 0x00,
  0x00, 0x3B, 0xEE, 0x00, 0x00, 0x00, 0x67, 0xDC, 0x00, 0x00, 0x01, 0xCF,
  0x98, 0x00, 0x00, 0x03, 0x9F, 0x38, 0x00, 0x00, 0x06, 0x3E, 0x30, 0x00,
  0x00, 0x1C, 0x7C, 0x60, 0x00, 0x00, 0x38, 0xF8, 0xE0, 0x00, 0x00, 0x61,
  0xF0, 0xC0, 0x00, 0x01, 0xC3, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0xC3, 0x80,
  0x00, 0x06, 0x0F, 0x83, 0x00, 0x00, 0x1C, 0x1F, 0x07, 0x00, 0x00, 0x30,
  0x3E, 0x0E, 0x00, 0x00, 0xE0, 0x7C, 0x0C, 0x00, 0x01, 0xC0, 0xF8, 0x1C,
  0x00, 0x03, 0x01, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0xE0, 0x30, 0x00, 0x1C,
  0x07, 0xC0, 0x70, 0x00, 0x30, 0x0F, 0x80, 0x60, 0x00, 0xE0, 0x1F, 0x00,
  0xC0, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x03, 0x00, 0x7C, 0x01, 0x80, 0x0E,
  0x00, 0xF8, 0x03, 0x80, 0x18, 0x01, 0xF0, 0x07, 0x00, 0x30, 0x03, 0xE0,
  0x06, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x01, 0x80, 0x0F, 0x80, 0x1C, 0x07,
  0x00, 0x1F, 0x00, 0x18, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x18, 0x00, 0x7C,
  0x00, 0x30, 0x70, 0x00, 0xF8, 0x00, 0x60, 0xE0, 0x01, 0xF0, 0x00, 0xE1,
  0x80, 0x03, 0xE0, 0x00, 0xC7, 0x00, 0x07, 0xC0, 0x01, 0xCC, 0x00, 0x0F,
  0x80, 0x03, 0x98, 0x00, 0x1F, 0x00, 0x03, 0x70, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0x00, 0x00,
  0x03, 0xF7, 0x00, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x0F, 0xCE, 0x00, 0x00,
  0x1F, 0x8E, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x00,
  0xFC, 0x1C, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07,
  0xE0, 0x70, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x3F,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xC0, 0x01, 0xF8,
  0x01, 0xC0, 0x03, 0xF0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0,
  0x03, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x7E, 0x00,
  0x0E, 0x00, 0xFC, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x1C, 0x03, 0xF0, 0x00,
  0x1C, 0x07, 0xE0, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x38, 0x1F, 0x80, 0x00,
  0x38, 0x3F, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00,
  0xE1, 0xF8, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x00, 0xC7, 0xE0, 0x00, 0x01,
  0xCF, 0xC0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0xF0,
  0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0xE3, 0x80, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE3, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0xFF, 0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1E, 0x07, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x33, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x30, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x81, 0x80, 0x00, 0x71, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x87, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x0C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x07, 0x00, 0x18,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x1C,
  0x60, 0x00, 0x07, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0D, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x1B, 0x00, 0x03, 0x70, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x1C,
  0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x07, 0x00, 0xE0, 0x60, 0x18, 0x0C,
  0x03, 0x01, 0xC0, 0xE0, 0x38, 0x18, 0x03, 0x03, 0x00, 0x70, 0xE0, 0x0E,
  0x18, 0x00, 0xC3, 0x00, 0x1C, 0xE0, 0x03, 0x98, 0x00, 0x33, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0xE1,
  0xF0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x3E, 0x70, 0x00, 0x3F, 0x1C, 0x00, 0x3B, 0x8F, 0x80, 0x78, 0xC3, 0xFF,
  0xF8, 0x60, 0x7F, 0xF0, 0x38, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0xE1, 0xFF,
  0xC0, 0x71, 0xFF, 0xF8, 0x39, 0xC0, 0x1E, 0x1D, 0xC0, 0x07, 0x8F, 0x80,
  0x01, 0xC7, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x67, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xF0,
  0x00, 0x38, 0xEC, 0x00, 0x3C, 0x77, 0x80, 0x7C, 0x38, 0xFF, 0xFC, 0x1C,
  0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x38, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x7C, 0x03, 0x03, 0xFF, 0x83, 0x07, 0xFF, 0xE3, 0x0F,
  0x00, 0xF3, 0x1C, 0x00, 0x3B, 0x38, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x0F, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x3B, 0x0F, 0x00, 0xF3, 0x07,
  0xFF, 0xE3, 0x03, 0xFF, 0x83, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x80, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0x07, 0x80, 0x03, 0x81, 0xF0, 0x07, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0x83, 0x07, 0xFF, 0xE3, 0x0F, 0x00, 0xF3, 0x1C, 0x00, 0x33, 0x38, 0x00,
  0x1B, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1B, 0x1C, 0x00,
  0x3B, 0x0F, 0x00, 0xF3, 0x07, 0xFF, 0xE3, 0x03, 0xFF, 0x83, 0x00, 0x7C,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x10, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x07, 0xE7, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x0F, 0x80, 0xE0, 0xFF, 0xC1, 0xC3, 0xFF, 0xE3, 0x8E, 0x01, 0xE7, 0x38,
  0x01, 0xCE, 0xE0, 0x01, 0xDD, 0x80, 0x03, 0xBE, 0x00, 0x03, 0x7C, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x30, 0xFF, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0xFF, 0x8F, 0xF0, 0x7C, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x38, 0x01, 0xE0, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0xC0, 0x01, 0xDF, 0x80, 0x03,
  0xF3, 0x80, 0x07, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1C, 0x1F,
  0xF8, 0x01, 0xFF, 0xC3, 0x87, 0xFF, 0xC0, 0xFF, 0xFC, 0x73, 0xC0, 0x7C,
  0x3C, 0x03, 0xCE, 0x60, 0x03, 0x8F, 0x00, 0x39, 0xD8, 0x00, 0x39, 0x80,
  0x03, 0xBE, 0x00, 0x07, 0x70, 0x00, 0x37, 0xC0, 0x00, 0x6C, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x1F, 0x01, 0xC1, 0xFF, 0x83, 0x87, 0xFF, 0xC7, 0x1C, 0x03, 0xCE,
  0x70, 0x03, 0x9D, 0xC0, 0x03, 0xBB, 0x00, 0x07, 0x7C, 0x00, 0x06, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x70, 0xFF, 0xE0, 0x38, 0xFF, 0xFC,
  0x1C, 0xE0, 0x1F, 0x0E, 0xC0, 0x03, 0xC7, 0xC0, 0x00, 0xE3, 0xE0, 0x00,
  0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x33, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0x7E, 0x00,
  0x1E, 0x3B, 0xC0, 0x3E, 0x1C, 0x7F, 0xFE, 0x0E, 0x1F, 0xFC, 0x07, 0x01,
  0xF0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0x83, 0x07, 0xFF, 0xE3, 0x0F, 0x00, 0xF3, 0x1C, 0x00, 0x3B, 0x38, 0x00,
  0x1B, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x1C, 0x00,
  0x3B, 0x0F, 0x00, 0xF3, 0x07, 0xFF, 0xE3, 0x03, 0xFF, 0x83, 0x00, 0x7C,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x3F, 0x87, 0xFE, 0x3F, 0xF9, 0xE0, 0xEE,
  0x03, 0xB0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x38, 0x00, 0x79, 0xC0,
  0x00, 0xE6, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x70, 0x00, 0x39, 0xE0, 0x00, 0xE3, 0xE0, 0x0F, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x1B, 0x3C, 0x00, 0x76, 0x3C, 0x03,
  0xCC, 0x3F, 0xFF, 0x18, 0x3F, 0xF8, 0x30, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x18,
  0x00, 0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0C,
  0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x76, 0x00,
  0x06, 0xC0, 0x00, 0xCE, 0x00, 0x0D, 0x80, 0x03, 0x9C, 0x00, 0x1B, 0x00,
  0x07, 0x18, 0x00, 0x77, 0x00, 0x0E, 0x30, 0x00, 0xEE, 0x00, 0x18, 0x70,
  0x01, 0x8C, 0x00, 0x70, 0xE0, 0x03, 0x1C, 0x00, 0xE0, 0xC0, 0x0E, 0x38,
  0x01, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x03, 0x80, 0x30, 0x60, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x06, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0x30, 0x30, 0x06, 0x07, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xE0, 0xC0,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x01, 0x86, 0x00, 0x30, 0xE0,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70,
  0x01, 0xCE, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x37, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x30, 0x00, 0x18, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x06, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x00,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xBE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0x00, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0x80, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x19, 0xC0,
  0xF0, 0x00, 0x37, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xD8, 0x00,
  0xF0, 0x03, 0x70, 0x00, 0xF0, 0x0E, 0xE0, 0x00, 0xF0, 0x39, 0x80, 0x00,
  0xFF, 0xF3, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 50, 14, 5, -49 },
  { 26, 10, 14, 19, 5, -52 },
  { 44, 31, 49, 34, 3, -49 },
  { 234, 25, 63, 33, 4, -56 },
  { 431, 37, 51, 45, 4, -50 },
  { 667, 31, 51, 37, 4, -50 },
  { 865, 3, 14, 12, 4, -52 },
  { 871, 13, 71, 19, 5, -55 },
  { 987, 13, 71, 20, 2, -55 },
  { 1103, 27, 27, 29, 1, -49 },
  { 1195, 28, 37, 34, 3, -42 },
  { 1325, 5, 15, 13, 3, -6 },
  { 1335, 14, 2, 18, 2, -23 },
  { 1339, 5, 5, 16, 5, -4 },
  { 1343, 19, 53, 24, 2, -49 },
  { 1469, 25, 51, 33, 4, -50 },
  { 1629, 14, 49, 33, 6, -49 },
  { 1715, 26, 50, 33, 4, -50 },
  { 1878, 26, 51, 33, 3, -50 },
  { 2044, 29, 49, 33, 3, -49 },
  { 2222, 24, 50, 33, 6, -49 },
  { 2372, 26, 50, 33, 4, -49 },
  { 2535, 27, 49, 33, 3, -49 },
  { 2701, 26, 51, 33, 4, -50 },
  { 2867, 25, 50, 33, 4, -50 },
  { 3024, 5, 37, 13, 4, -36 },
  { 3048, 7, 45, 12, 2, -36 },
  { 3088, 24, 28, 31, 3, -36 },
  { 3172, 24, 16, 34, 5, -30 },
  { 3220, 24, 27, 31, 4, -36 },
  { 3301, 21, 51, 27, 3, -50 },
  { 3435, 47, 63, 55, 4, -48 },
  { 3806, 33, 49, 37, 2, -49 },
  { 4009, 27, 49, 37, 6, -49 },
  { 4175, 30, 51, 39, 5, -50 },
  { 4367, 29, 49, 39, 6, -49 },
  { 4545, 26, 49, 35, 6, -49 },
  { 4705, 26, 49, 34, 6, -49 },
  { 4865, 31, 51, 41, 5, -50 },
  { 5063, 30, 49, 42, 6, -49 },
  { 5247, 3, 49, 17, 7, -49 },
  { 5266, 24, 50, 33, 3, -49 },
  { 5416, 30, 49, 38, 6, -49 },
  { 5600, 24, 49, 32, 6, -49 },
  { 5747, 39, 49, 52, 6, -49 },
  { 5986, 31, 49, 43, 6, -49 },
  { 6176, 31, 51, 40, 5, -50 },
  { 6374, 27, 49, 37, 6, -49 },
  { 6540, 32, 59, 40, 4, -50 },
  { 6776, 29, 49, 39, 6, -49 },
  { 6954, 30, 51, 36, 3, -50 },
  { 7146, 32, 49, 36, 2, -49 },
  { 7342, 28, 50, 40, 6, -49 },
  { 7517, 33, 49, 37, 2, -49 },
  { 7720, 50, 49, 54, 2, -49 },
  { 8027, 32, 49, 37, 2, -49 },
  { 8223, 34, 49, 36, 1, -49 },
  { 8432, 30, 49, 36, 3, -49 },
  { 8616, 8, 67, 15, 6, -56 },
  { 8683, 20, 53, 24, 2, -49 },
  { 8816, 8, 67, 15, 1, -56 },
  { 8883, 19, 25, 26, 3, -49 },
  { 8943, 24, 2, 26, 1, 0 },
  { 8949, 10, 9, 19, 4, -52 },
  { 8961, 25, 38, 32, 3, -37 },
  { 9080, 25, 53, 33, 5, -52 },
  { 9246, 25, 38, 31, 3, -37 },
  { 9365, 24, 53, 33, 4, -52 },
  { 9524, 25, 38, 31, 3, -37 },
  { 9643, 18, 53, 20, 2, -53 },
  { 9763, 24, 51, 33, 4, -37 },
  { 9916, 23, 52, 33, 5, -52 },
  { 10066, 4, 49, 14, 5, -49 },
  { 10091, 12, 63, 14, -3, -49 },
  { 10186, 23, 52, 29, 5, -52 },
  { 10336, 2, 52, 14, 6, -52 },
  { 10349, 43, 37, 53, 5, -37 },
  { 10548, 23, 37, 33, 5, -37 },
  { 10655, 26, 38, 34, 4, -37 },
  { 10779, 25, 51, 33, 5, -37 },
  { 10939, 24, 51, 34, 4, -37 },
  { 11092, 14, 37, 21, 5, -37 },
  { 11157, 22, 38, 31, 4, -37 },
  { 11262, 15, 47, 20, 2, -46 },
  { 11351, 23, 37, 33, 5, -36 },
  { 11458, 25, 36, 29, 2, -36 },
  { 11571, 39, 36, 45, 3, -36 },
  { 11747, 25, 36, 29, 2, -36 },
  { 11860, 26, 50, 29, 2, -36 },
  { 12023, 24, 36, 29, 3, -36 },
  { 12131, 17, 68, 20, 3, -54 },
  { 12276, 3, 58, 14, 6, -49 },
  { 12298, 17, 68, 20, 1, -54 },
  { 12443, 31, 12, 41, 5, -27 },
};

const GFXfont RobotoCondensed_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT69PT7B_H_
