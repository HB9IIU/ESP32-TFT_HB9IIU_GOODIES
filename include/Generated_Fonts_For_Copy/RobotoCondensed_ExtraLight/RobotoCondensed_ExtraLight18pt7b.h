#ifndef _ROBOTOCONDENSED_EXTRALIGHT18PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0xB6, 0xD0, 0x12, 0x12, 0x22, 0xFF, 0x24, 0x24, 0x24,
  0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x10, 0x20, 0xE2, 0x28, 0x30, 0x60,
  0x20, 0x38, 0x08, 0x0C, 0x18, 0x28, 0x8E, 0x08, 0x10, 0x60, 0x24, 0x09,
  0x22, 0x48, 0x94, 0x19, 0x00, 0x80, 0x2E, 0x12, 0x45, 0x12, 0x44, 0x09,
  0x03, 0x80, 0x38, 0x44, 0x44, 0x48, 0x48, 0x30, 0x20, 0x51, 0x89, 0x85,
  0x82, 0x86, 0x79, 0xF0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x84, 0x44,
  0x21, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x12, 0x22, 0x48, 0x10, 0x23,
  0x49, 0xE1, 0x84, 0x91, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0x10, 0xF0, 0xE0, 0x80, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x84,
  0x10, 0x42, 0x00, 0x38, 0x8A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x12, 0x23, 0x80, 0x3C, 0x92, 0x49, 0x24, 0x92, 0x38, 0x8A, 0x14, 0x20,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x0F, 0xE0, 0x38, 0x8A, 0x14, 0x10,
  0x40, 0x8E, 0x02, 0x03, 0x06, 0x0A, 0x23, 0x80, 0x04, 0x18, 0x50, 0xA2,
  0x44, 0x91, 0x22, 0x85, 0xFC, 0x10, 0x20, 0x40, 0x7E, 0x81, 0x02, 0x04,
  0x0F, 0x01, 0x01, 0x03, 0x05, 0x0A, 0x23, 0x80, 0x18, 0x41, 0x04, 0x0B,
  0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0A, 0x23, 0x80, 0xFE, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x00, 0x38, 0x8A, 0x0C, 0x18,
  0x28, 0x8E, 0x22, 0x83, 0x06, 0x0C, 0x27, 0x80, 0x38, 0x8A, 0x14, 0x18,
  0x30, 0x60, 0xA3, 0x3A, 0x08, 0x10, 0x47, 0x00, 0x80, 0x80, 0x81, 0xE0,
  0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81,
  0x81, 0x19, 0x88, 0x00, 0x74, 0x62, 0x10, 0x84, 0x44, 0x20, 0x00, 0x02,
  0x00, 0x0F, 0x81, 0x06, 0x20, 0x24, 0x01, 0x47, 0x18, 0x89, 0x88, 0x99,
  0x09, 0x91, 0x19, 0x11, 0x91, 0x18, 0xEE, 0x40, 0x04, 0x00, 0x20, 0x01,
  0xF0, 0x08, 0x06, 0x03, 0x02, 0x81, 0x20, 0x90, 0x88, 0x42, 0x3F, 0x20,
  0x90, 0x28, 0x18, 0x08, 0xF9, 0x0A, 0x14, 0x28, 0x50, 0xBE, 0x42, 0x83,
  0x06, 0x0C, 0x2F, 0x80, 0x3E, 0x41, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x41, 0x42, 0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x2F, 0x80, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82,
  0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20,
  0x80, 0x3E, 0x41, 0x41, 0x81, 0x80, 0x80, 0x80, 0x87, 0x81, 0x81, 0x41,
  0x41, 0x3E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0xFF, 0xF8, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x18,
  0x61, 0x78, 0x83, 0x0A, 0x24, 0x8A, 0x14, 0x38, 0x48, 0x91, 0x12, 0x14,
  0x28, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC,
  0x80, 0x60, 0x38, 0x0F, 0x03, 0xC1, 0x68, 0x5A, 0x26, 0x89, 0x92, 0x65,
  0x19, 0x46, 0x31, 0x88, 0x40, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91,
  0x89, 0x89, 0x85, 0x85, 0x83, 0x81, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x30,
  0x61, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x02, 0x01, 0xF9, 0x0A,
  0x0C, 0x18, 0x30, 0xBE, 0x44, 0x89, 0x0A, 0x14, 0x18, 0x20, 0x3C, 0x42,
  0x82, 0x81, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81, 0x81, 0x42, 0x3C, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x80, 0xA0, 0x50, 0x28, 0x22, 0x11, 0x08, 0x88, 0x24, 0x12, 0x0A,
  0x05, 0x01, 0x80, 0x80, 0x82, 0x18, 0x61, 0x86, 0x18, 0x61, 0x89, 0x14,
  0x92, 0x49, 0x24, 0x92, 0x50, 0xA3, 0x0A, 0x30, 0xC3, 0x04, 0x20, 0x40,
  0x81, 0x82, 0x42, 0x24, 0x28, 0x18, 0x10, 0x18, 0x24, 0x44, 0x42, 0x82,
  0x81, 0x40, 0xA0, 0x90, 0x44, 0x42, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xFE, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x80, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C,
  0x84, 0x20, 0x84, 0x21, 0x04, 0x21, 0x04, 0x21, 0x04, 0xD5, 0x55, 0x55,
  0x55, 0x70, 0x23, 0x14, 0xA9, 0x44, 0xFE, 0x48, 0x7A, 0x18, 0x41, 0x7E,
  0x18, 0x61, 0x8D, 0xD0, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x57, 0x00, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x21, 0x85,
  0xE0, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0,
  0x7A, 0x18, 0x61, 0xFE, 0x08, 0x20, 0x81, 0xF0, 0x34, 0x44, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41,
  0x05, 0xE0, 0x82, 0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0x9F, 0xF8, 0x20, 0x12, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x82, 0x08,
  0x20, 0x86, 0x29, 0x28, 0xA3, 0x49, 0x22, 0x86, 0x10, 0xFF, 0xFC, 0xB9,
  0xEC, 0x62, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84,
  0x18, 0x41, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x38, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0x70, 0xB9, 0x8A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xC5, 0x72, 0x04, 0x08, 0x10, 0x00, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xF0, 0x41, 0x04, 0x10, 0xBC, 0x88, 0x88, 0x88, 0x88,
  0x7A, 0x18, 0x60, 0x60, 0x60, 0x61, 0x85, 0xE0, 0x22, 0xF2, 0x22, 0x22,
  0x22, 0x23, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xF0, 0x82, 0x85,
  0x0A, 0x22, 0x44, 0x8A, 0x0C, 0x18, 0x20, 0x88, 0x63, 0x18, 0xC6, 0x52,
  0x54, 0x94, 0xA5, 0x29, 0x8C, 0x21, 0x08, 0x40, 0x86, 0x24, 0x8C, 0x20,
  0xC5, 0x12, 0x8A, 0x10, 0x82, 0x85, 0x0A, 0x22, 0x44, 0x8A, 0x0C, 0x18,
  0x20, 0x40, 0x81, 0x0C, 0x00, 0xFC, 0x20, 0x84, 0x10, 0x84, 0x10, 0x83,
  0xF0, 0x12, 0x44, 0x44, 0x44, 0x84, 0x44, 0x44, 0x42, 0x21, 0xFF, 0xFE,
  0x82, 0x08, 0x42, 0x10, 0x84, 0x18, 0x88, 0x42, 0x10, 0x84, 0x44, 0x00,
  0x71, 0x89, 0x87,
};

const GFXglyph RobotoCondensed_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 13, 4, 1, -13 },
  { 3, 3, 4, 5, 1, -14 },
  { 5, 8, 13, 9, 1, -13 },
  { 18, 7, 17, 9, 1, -15 },
  { 33, 10, 13, 12, 1, -13 },
  { 50, 8, 13, 10, 1, -13 },
  { 63, 1, 4, 3, 1, -14 },
  { 64, 4, 18, 5, 1, -14 },
  { 73, 4, 18, 5, 0, -14 },
  { 82, 7, 7, 8, 0, -13 },
  { 89, 7, 9, 9, 1, -11 },
  { 97, 1, 4, 3, 1, -2 },
  { 98, 3, 1, 5, 1, -6 },
  { 99, 2, 1, 4, 1, -1 },
  { 100, 6, 14, 6, 0, -13 },
  { 111, 7, 13, 9, 1, -13 },
  { 123, 3, 13, 9, 2, -13 },
  { 128, 7, 13, 9, 1, -13 },
  { 140, 7, 13, 9, 1, -13 },
  { 152, 7, 13, 9, 1, -13 },
  { 164, 7, 13, 9, 1, -13 },
  { 176, 7, 13, 9, 1, -13 },
  { 188, 7, 13, 9, 1, -13 },
  { 200, 7, 13, 9, 1, -13 },
  { 212, 7, 13, 9, 1, -13 },
  { 224, 1, 9, 3, 1, -9 },
  { 226, 1, 11, 3, 1, -9 },
  { 228, 6, 7, 8, 1, -9 },
  { 234, 6, 5, 9, 1, -8 },
  { 238, 6, 7, 8, 1, -9 },
  { 244, 5, 13, 7, 1, -13 },
  { 253, 12, 16, 14, 1, -12 },
  { 277, 9, 13, 10, 0, -13 },
  { 292, 7, 13, 10, 2, -13 },
  { 304, 8, 13, 10, 1, -13 },
  { 317, 7, 13, 10, 2, -13 },
  { 329, 6, 13, 9, 2, -13 },
  { 339, 6, 13, 9, 2, -13 },
  { 349, 8, 13, 11, 1, -13 },
  { 362, 7, 13, 11, 2, -13 },
  { 374, 1, 13, 4, 2, -13 },
  { 376, 6, 13, 9, 1, -13 },
  { 386, 7, 13, 10, 2, -13 },
  { 398, 6, 13, 8, 2, -13 },
  { 408, 10, 13, 13, 2, -13 },
  { 425, 8, 13, 11, 2, -13 },
  { 438, 8, 13, 11, 1, -13 },
  { 451, 7, 13, 10, 2, -13 },
  { 463, 8, 15, 11, 1, -13 },
  { 478, 7, 13, 10, 2, -13 },
  { 490, 8, 13, 9, 1, -13 },
  { 503, 8, 13, 9, 1, -13 },
  { 516, 8, 13, 10, 1, -13 },
  { 529, 9, 13, 10, 0, -13 },
  { 544, 12, 13, 14, 1, -13 },
  { 564, 8, 13, 10, 1, -13 },
  { 577, 9, 13, 9, 0, -13 },
  { 592, 8, 13, 9, 1, -13 },
  { 605, 3, 18, 4, 1, -15 },
  { 612, 5, 14, 6, 1, -13 },
  { 621, 2, 18, 4, 0, -15 },
  { 626, 5, 6, 7, 1, -13 },
  { 630, 7, 1, 7, 0, 0 },
  { 631, 3, 2, 5, 1, -13 },
  { 632, 6, 10, 8, 1, -10 },
  { 640, 7, 14, 9, 1, -14 },
  { 653, 6, 10, 8, 1, -10 },
  { 661, 6, 14, 9, 1, -14 },
  { 672, 6, 10, 8, 1, -10 },
  { 680, 4, 14, 5, 1, -14 },
  { 687, 6, 14, 9, 1, -10 },
  { 698, 6, 14, 9, 1, -14 },
  { 709, 1, 13, 4, 1, -13 },
  { 711, 3, 17, 4, -1, -13 },
  { 718, 6, 14, 8, 1, -14 },
  { 729, 1, 14, 4, 1, -14 },
  { 731, 12, 10, 14, 1, -10 },
  { 746, 6, 10, 9, 1, -10 },
  { 754, 7, 10, 9, 1, -10 },
  { 763, 7, 14, 9, 1, -10 },
  { 776, 6, 14, 9, 1, -10 },
  { 787, 4, 10, 5, 1, -10 },
  { 792, 6, 10, 8, 1, -10 },
  { 800, 4, 12, 5, 0, -12 },
  { 806, 6, 10, 9, 1, -10 },
  { 814, 7, 10, 8, 0, -10 },
  { 823, 10, 10, 12, 1, -10 },
  { 836, 6, 10, 8, 1, -10 },
  { 844, 7, 14, 8, 0, -10 },
  { 857, 6, 10, 8, 1, -10 },
  { 865, 4, 18, 5, 1, -14 },
  { 874, 1, 15, 4, 1, -13 },
  { 876, 5, 18, 5, 0, -14 },
  { 888, 8, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT18PT7B_H_
