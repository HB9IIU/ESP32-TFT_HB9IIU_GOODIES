#ifndef _ROBOTOCONDENSED_EXTRALIGHT30PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0x99, 0x99, 0x99, 0x02, 0x10,
  0x08, 0x40, 0x41, 0x01, 0x08, 0x04, 0x20, 0x10, 0x87, 0xFF, 0xC1, 0x08,
  0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84,
  0x3F, 0xFE, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x83, 0x18, 0x80, 0x90, 0x16, 0x03,
  0x80, 0x38, 0x01, 0x00, 0x20, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xD0, 0x13, 0x0C, 0x1F, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x78, 0x00, 0xC4, 0x00, 0x84, 0x00, 0x84, 0x10,
  0x82, 0x10, 0x82, 0x20, 0x84, 0x20, 0x84, 0x40, 0xC4, 0xC0, 0x78, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x1C, 0x02, 0x22, 0x04, 0x42, 0x04, 0x41,
  0x08, 0x41, 0x08, 0x41, 0x10, 0x41, 0x10, 0x42, 0x00, 0x22, 0x00, 0x1C,
  0x1E, 0x01, 0x88, 0x08, 0x20, 0xC1, 0x04, 0x08, 0x30, 0x40, 0x84, 0x04,
  0x40, 0x34, 0x00, 0xC0, 0x06, 0x00, 0x48, 0x04, 0x61, 0xE1, 0x0A, 0x04,
  0x50, 0x32, 0x80, 0x94, 0x03, 0x20, 0x19, 0x80, 0xE6, 0x19, 0x0F, 0x04,
  0xFC, 0x04, 0x21, 0x04, 0x20, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20,
  0x40, 0x84, 0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x62, 0x10, 0x88, 0x44, 0x42, 0x00, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x62, 0x33, 0xAC, 0x07, 0x00, 0x70, 0x0D, 0x80, 0x88,
  0x10, 0x43, 0x04, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x6D, 0xA5, 0x00, 0xFC, 0xF0, 0x01, 0x01, 0x03,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x06, 0x31,
  0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x50, 0x09, 0x01, 0x20,
  0x43, 0x18, 0x3C, 0x00, 0x0C, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1E, 0x0C, 0x31,
  0x02, 0x40, 0x28, 0x05, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0xFF, 0xC0, 0x1F, 0x04, 0x31, 0x03, 0x40, 0x28, 0x05, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x30, 0x78, 0x00, 0xC0, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x60, 0x26, 0x18, 0x3E, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x88,
  0x08, 0x40, 0xC2, 0x04, 0x10, 0x60, 0x82, 0x04, 0x20, 0x21, 0x01, 0x1F,
  0xFF, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x3F,
  0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x5F, 0x0E,
  0x31, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x28, 0x05,
  0x01, 0xB0, 0x23, 0x08, 0x1E, 0x00, 0x03, 0x81, 0x80, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x8F, 0x16, 0x33, 0x01, 0x60, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0D, 0x01, 0x30, 0x63, 0x18, 0x1E,
  0x00, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x1F, 0x0C,
  0x31, 0x03, 0x60, 0x28, 0x05, 0x00, 0xE0, 0x14, 0x02, 0x40, 0xC4, 0x30,
  0x78, 0x30, 0xC4, 0x05, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xE0, 0x26, 0x18, 0x3E, 0x00, 0x1E, 0x04, 0x31, 0x02, 0x60, 0x28, 0x05,
  0x00, 0xA0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x34, 0x0E, 0xC2,
  0xC7, 0x90, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x60, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x69, 0x40,
  0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0E, 0x02, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x1C, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x40, 0x01, 0xFC, 0x00, 0x70, 0x30, 0x0C,
  0x00, 0x81, 0x80, 0x04, 0x30, 0x00, 0x62, 0x00, 0x02, 0x60, 0x78, 0x24,
  0x08, 0xC1, 0x41, 0x04, 0x18, 0x30, 0x41, 0x82, 0x04, 0x18, 0x20, 0x41,
  0x82, 0x04, 0x18, 0x40, 0x41, 0x84, 0x08, 0x18, 0x40, 0x81, 0x84, 0x08,
  0x18, 0x40, 0x82, 0x82, 0x14, 0x28, 0x22, 0x44, 0xC1, 0xC3, 0x84, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x21, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x80, 0x42, 0x01, 0x0F, 0xFC, 0x60, 0x09, 0x00, 0x24,
  0x00, 0xB0, 0x03, 0x80, 0x06, 0x00, 0x10, 0xFF, 0x10, 0x32, 0x01, 0x40,
  0x28, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0x50, 0x33, 0xFC, 0x40, 0x68,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x0D,
  0xFE, 0x00, 0x0F, 0xC0, 0xC3, 0x08, 0x04, 0x80, 0x24, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x21, 0x86,
  0x07, 0xC0, 0xFF, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x81, 0x8F, 0xF0, 0xFF,
  0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x00, 0x0F, 0xC0, 0x61, 0xC2, 0x01, 0x18, 0x02, 0x40, 0x09, 0x00, 0x2C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFE,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x00, 0x36, 0x00, 0xC8, 0x02,
  0x18, 0x30, 0x1F, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x38, 0x0D, 0x01, 0x20, 0x23, 0x18,
  0x3E, 0x00, 0x80, 0x34, 0x03, 0x20, 0x11, 0x01, 0x08, 0x10, 0x41, 0x82,
  0x18, 0x10, 0x80, 0x88, 0x04, 0xC0, 0x2E, 0x01, 0xD0, 0x0C, 0x40, 0x43,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x84, 0x06, 0x20, 0x11, 0x00, 0x48, 0x03,
  0x40, 0x08, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xB8, 0x00, 0x5A, 0x00, 0x2D, 0x00, 0x26, 0x80, 0x13, 0x20, 0x09, 0x90,
  0x08, 0xC8, 0x04, 0x62, 0x02, 0x31, 0x02, 0x18, 0xC1, 0x0C, 0x21, 0x86,
  0x10, 0x83, 0x0C, 0x41, 0x82, 0x60, 0xC1, 0x20, 0x60, 0x50, 0x30, 0x38,
  0x18, 0x18, 0x0C, 0x04, 0x04, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40, 0x1A,
  0x00, 0xC8, 0x06, 0x40, 0x31, 0x01, 0x8C, 0x0C, 0x20, 0x61, 0x83, 0x04,
  0x18, 0x30, 0xC0, 0x86, 0x02, 0x30, 0x11, 0x80, 0x4C, 0x03, 0x60, 0x0B,
  0x00, 0x78, 0x01, 0xC0, 0x0C, 0x0F, 0xC0, 0xE1, 0x82, 0x01, 0x10, 0x06,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x09, 0x00,
  0x24, 0x01, 0x88, 0x04, 0x18, 0x60, 0x3F, 0x00, 0xFF, 0x08, 0x0C, 0x80,
  0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x38, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x68, 0x0C, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x80, 0xE1, 0x82, 0x01, 0x10, 0x06,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x09, 0x00,
  0x24, 0x01, 0x88, 0x04, 0x38, 0x60, 0x3F, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0xFF, 0x08, 0x0C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0xFF, 0x08, 0x10,
  0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x68, 0x02, 0x80, 0x38, 0x01,
  0x0F, 0xC0, 0xC3, 0x08, 0x04, 0x80, 0x34, 0x00, 0xA0, 0x05, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0xC0, 0x23, 0x87, 0x07, 0xE0,
  0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x04, 0xC0, 0x63,
  0x06, 0x07, 0xE0, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xD0, 0x02, 0x40, 0x09,
  0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x20, 0x0E, 0x01, 0x80, 0x50,
  0x0C, 0x02, 0x80, 0xA0, 0x34, 0x05, 0x01, 0x20, 0x24, 0x09, 0x81, 0x20,
  0x44, 0x11, 0x02, 0x20, 0x88, 0x31, 0x04, 0x21, 0x08, 0x21, 0x08, 0x22,
  0x08, 0x41, 0x10, 0x42, 0x08, 0x81, 0x30, 0x44, 0x09, 0x03, 0x40, 0x48,
  0x0A, 0x02, 0x40, 0x50, 0x1A, 0x02, 0x80, 0x60, 0x14, 0x03, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0xC0, 0x09, 0x00, 0x22, 0x01, 0x08, 0x0C, 0x10,
  0x20, 0x61, 0x80, 0x84, 0x03, 0x30, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x80, 0x12, 0x00, 0x8C, 0x02, 0x10, 0x10, 0x20, 0xC0, 0x82,
  0x01, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x30, 0x80, 0x0F, 0x00, 0x24, 0x00,
  0x98, 0x04, 0x20, 0x10, 0xC0, 0x81, 0x02, 0x06, 0x10, 0x08, 0x40, 0x22,
  0x00, 0x48, 0x01, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x7F, 0xF8,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x7F, 0xFC, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xF0, 0x80, 0x60, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x04, 0x05, 0x02, 0x83,
  0x41, 0x10, 0x88, 0xC4, 0x41, 0x20, 0xB0, 0x40, 0xFF, 0xE0, 0xC4, 0x21,
  0x0F, 0x06, 0x19, 0x81, 0x20, 0x34, 0x02, 0x00, 0x40, 0x08, 0xFF, 0x30,
  0x28, 0x05, 0x00, 0xE0, 0x14, 0x06, 0x81, 0x58, 0x69, 0xF1, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xB0, 0x98, 0x0B,
  0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xE0, 0x2C, 0x05, 0x63, 0x27, 0xC0, 0x0F, 0x06, 0x19, 0x81, 0x20, 0x14,
  0x02, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x14, 0x02,
  0xC0, 0xCC, 0x30, 0x78, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x79, 0x61, 0x50, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0xD8, 0x71, 0xE4, 0x0F, 0x06, 0x19,
  0x81, 0x20, 0x14, 0x03, 0x80, 0x60, 0x0F, 0xFF, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x0C, 0x10, 0x7C, 0x0F, 0x18, 0x10, 0x30, 0x20,
  0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1E, 0x58, 0x54, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x36,
  0x1C, 0xF9, 0x00, 0x40, 0x10, 0x05, 0x03, 0x61, 0x87, 0xC0, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x3C, 0x90, 0xA8, 0x3C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xC0, 0x00,
  0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0x8D, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x02, 0x81, 0xA0, 0xC8, 0x62, 0x10, 0x88, 0x24, 0x0B, 0x83, 0x20, 0x84,
  0x21, 0x88, 0x22, 0x04, 0x81, 0xA0, 0x28, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x8F, 0x0F, 0x96, 0x33, 0x1A, 0x83, 0x81, 0xE0, 0x30, 0x1C,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x8F, 0x24, 0x2A, 0x0F, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x1F, 0x0C, 0x31, 0x03, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x04, 0x81, 0x88, 0x60, 0xF8, 0x9F, 0x16,
  0x33, 0x01, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x3C, 0x05, 0x80, 0xAC, 0x64, 0xF8, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x00, 0x3E, 0x58, 0x54, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x36, 0x1C,
  0x79, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x9E, 0xCA, 0x30,
  0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3E, 0x10, 0x48,
  0x0A, 0x02, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x08, 0x02,
  0x80, 0xA0, 0x24, 0x18, 0xF8, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x07, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x50, 0x36, 0x14, 0x79, 0x80, 0x30, 0x09, 0x01, 0x20, 0x24, 0x0C, 0x41,
  0x08, 0x21, 0x0C, 0x11, 0x02, 0x20, 0x44, 0x0D, 0x00, 0xA0, 0x14, 0x03,
  0x00, 0x20, 0x80, 0x80, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x28, 0x34, 0x14,
  0x11, 0x09, 0x08, 0x84, 0x84, 0x44, 0x46, 0x22, 0x32, 0x19, 0x09, 0x05,
  0x84, 0x82, 0x82, 0x41, 0x40, 0xC0, 0xA0, 0x60, 0x20, 0x30, 0x10, 0x18,
  0xC0, 0x48, 0x18, 0x82, 0x10, 0xC1, 0x10, 0x34, 0x02, 0x80, 0x20, 0x0C,
  0x01, 0x40, 0x4C, 0x08, 0x82, 0x08, 0xC1, 0x10, 0x16, 0x03, 0x80, 0x30,
  0x0D, 0x01, 0x20, 0x24, 0x0C, 0x41, 0x08, 0x21, 0x0C, 0x11, 0x02, 0x20,
  0x44, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x08, 0x02, 0x00, 0xC0, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0,
  0x10, 0x07, 0xFF, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x30, 0x20, 0xC0, 0x38, 0x05, 0x18, 0x14, 0x30, 0xA0, 0x66,
  0x80, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 4, 6, 8, 2, -23 },
  { 10, 14, 22, 15, 1, -22 },
  { 49, 11, 28, 15, 2, -25 },
  { 88, 16, 22, 19, 2, -22 },
  { 132, 13, 22, 16, 2, -22 },
  { 168, 1, 6, 5, 2, -23 },
  { 169, 6, 31, 8, 2, -24 },
  { 193, 5, 31, 9, 1, -24 },
  { 213, 12, 12, 13, 0, -22 },
  { 231, 13, 15, 15, 1, -17 },
  { 256, 3, 6, 6, 1, -2 },
  { 259, 6, 1, 8, 1, -10 },
  { 260, 2, 2, 7, 2, -2 },
  { 261, 8, 24, 10, 1, -22 },
  { 285, 11, 22, 15, 2, -22 },
  { 316, 6, 22, 15, 3, -22 },
  { 333, 11, 22, 15, 2, -22 },
  { 364, 11, 22, 15, 2, -22 },
  { 395, 13, 22, 15, 1, -22 },
  { 431, 11, 22, 15, 2, -22 },
  { 462, 11, 22, 15, 2, -22 },
  { 493, 12, 22, 15, 1, -22 },
  { 526, 11, 22, 15, 2, -22 },
  { 557, 11, 22, 15, 2, -22 },
  { 588, 2, 16, 6, 2, -16 },
  { 592, 3, 20, 5, 1, -16 },
  { 600, 11, 12, 14, 1, -16 },
  { 617, 10, 7, 15, 2, -13 },
  { 626, 10, 12, 14, 2, -16 },
  { 641, 9, 22, 12, 1, -22 },
  { 666, 20, 28, 24, 2, -21 },
  { 736, 14, 22, 16, 1, -22 },
  { 775, 11, 22, 16, 3, -22 },
  { 806, 13, 22, 17, 2, -22 },
  { 842, 12, 22, 17, 3, -22 },
  { 875, 11, 22, 15, 3, -22 },
  { 906, 11, 22, 15, 3, -22 },
  { 937, 14, 22, 18, 2, -22 },
  { 976, 13, 22, 18, 3, -22 },
  { 1012, 1, 22, 7, 3, -22 },
  { 1015, 11, 22, 15, 1, -22 },
  { 1046, 13, 22, 17, 3, -22 },
  { 1082, 10, 22, 14, 3, -22 },
  { 1110, 17, 22, 22, 3, -22 },
  { 1157, 13, 22, 19, 3, -22 },
  { 1193, 14, 22, 18, 2, -22 },
  { 1232, 12, 22, 16, 3, -22 },
  { 1265, 14, 26, 18, 2, -22 },
  { 1311, 12, 22, 17, 3, -22 },
  { 1344, 13, 22, 16, 1, -22 },
  { 1380, 14, 22, 16, 1, -22 },
  { 1419, 13, 22, 17, 2, -22 },
  { 1455, 14, 22, 16, 1, -22 },
  { 1494, 21, 22, 23, 1, -22 },
  { 1552, 14, 22, 16, 1, -22 },
  { 1591, 14, 22, 16, 1, -22 },
  { 1630, 13, 22, 16, 1, -22 },
  { 1666, 4, 29, 6, 2, -24 },
  { 1681, 9, 24, 10, 1, -22 },
  { 1708, 4, 29, 6, 0, -24 },
  { 1723, 9, 11, 11, 1, -22 },
  { 1736, 11, 1, 11, 0, 0 },
  { 1738, 4, 4, 8, 2, -23 },
  { 1740, 11, 16, 14, 1, -16 },
  { 1762, 11, 23, 15, 2, -23 },
  { 1794, 11, 16, 14, 1, -16 },
  { 1816, 10, 23, 15, 2, -23 },
  { 1845, 11, 16, 14, 1, -16 },
  { 1867, 8, 23, 9, 1, -23 },
  { 1890, 10, 22, 15, 2, -16 },
  { 1918, 10, 23, 14, 2, -23 },
  { 1947, 2, 22, 6, 2, -22 },
  { 1953, 5, 28, 6, -1, -22 },
  { 1971, 10, 23, 13, 2, -23 },
  { 2000, 2, 23, 6, 2, -23 },
  { 2006, 19, 16, 23, 2, -16 },
  { 2044, 10, 16, 14, 2, -16 },
  { 2064, 11, 16, 15, 2, -16 },
  { 2086, 11, 22, 15, 2, -16 },
  { 2117, 10, 22, 15, 2, -16 },
  { 2145, 6, 16, 9, 2, -16 },
  { 2157, 10, 16, 13, 2, -16 },
  { 2177, 6, 20, 9, 1, -20 },
  { 2192, 10, 16, 14, 2, -16 },
  { 2212, 11, 16, 13, 1, -16 },
  { 2234, 17, 16, 20, 1, -16 },
  { 2268, 11, 16, 13, 1, -16 },
  { 2290, 11, 22, 13, 1, -16 },
  { 2321, 11, 16, 13, 1, -16 },
  { 2343, 8, 29, 9, 1, -23 },
  { 2372, 1, 26, 6, 3, -22 },
  { 2376, 8, 29, 9, 0, -23 },
  { 2405, 14, 5, 18, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT30PT7B_H_
