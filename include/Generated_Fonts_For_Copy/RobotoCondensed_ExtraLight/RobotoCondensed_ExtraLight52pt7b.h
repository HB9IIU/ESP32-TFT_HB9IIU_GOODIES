#ifndef _ROBOTOCONDENSED_EXTRALIGHT52PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87,
  0x0E, 0x18, 0x00, 0x20, 0x10, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x00, 0x80, 0x01, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x06,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x7C, 0xF8,
  0x1C, 0x03, 0x87, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xDC,
  0x00, 0x31, 0x80, 0x0E, 0x1C, 0x03, 0x81, 0xF3, 0xE0, 0x1F, 0xF8, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x80, 0xC0,
  0x30, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0x30, 0x20, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x40, 0x04,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x80, 0x03, 0x1C, 0x18, 0x00, 0x1F, 0x81,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x1F, 0x80, 0x01,
  0x83, 0x1C, 0x00, 0x30, 0x60, 0x60, 0x03, 0x0C, 0x06, 0x00, 0x60, 0xC0,
  0x20, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x08, 0x08, 0x03, 0x01,
  0x80, 0x80, 0x30, 0x10, 0x08, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x20, 0x0C,
  0x02, 0x02, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x0E, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x30, 0x0C, 0x70, 0x18, 0x0C, 0x60, 0x1C, 0x0C, 0xC0, 0x0C,
  0x0C, 0xC0, 0x06, 0x0C, 0xC0, 0x03, 0x0C, 0xC0, 0x03, 0x98, 0xC0, 0x01,
  0x98, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0xF0, 0x70, 0x01, 0xD8, 0x38, 0x03, 0x9C, 0x1F, 0x1E, 0x0C, 0x07, 0xFC,
  0x06, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x1F, 0x06, 0x0F, 0x7C, 0x63,
  0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19,
  0x80, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x07, 0x00, 0xC0, 0x30, 0x1C,
  0x01, 0x80, 0x80, 0x18, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x33, 0x33, 0x33, 0x37, 0x6E, 0x40, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3E, 0x78,
  0x0E, 0x03, 0x81, 0x80, 0x38, 0x60, 0x03, 0x0C, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x34,
  0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x30, 0x01, 0xC6,
  0x00, 0x30, 0x60, 0x0E, 0x0E, 0x03, 0x80, 0xF1, 0xE0, 0x07, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x8F, 0x3F, 0x87, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x1E,
  0x01, 0x80, 0x70, 0x30, 0x03, 0x87, 0x00, 0x18, 0x60, 0x01, 0xC6, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3C, 0x78, 0x0E,
  0x01, 0x83, 0x00, 0x18, 0xE0, 0x03, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x06, 0x1C, 0x01, 0xC1, 0xF1, 0xF0, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0xFE, 0x01, 0x7F, 0xF0, 0x7C, 0x0F, 0x0E,
  0x00, 0x70, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x06, 0x80, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x30,
  0x01, 0x86, 0x00, 0x30, 0x70, 0x0C, 0x07, 0x8F, 0x00, 0x7F, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC3, 0xF0, 0x19,
  0xFF, 0x82, 0x70, 0x38, 0xDC, 0x01, 0x9A, 0x00, 0x3B, 0xC0, 0x03, 0x70,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x30, 0x30,
  0x0E, 0x03, 0xC7, 0x80, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0x1F, 0x01, 0xC0, 0x78, 0x30, 0x01, 0x87, 0x00, 0x1C, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x03,
  0x81, 0xE0, 0x70, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x0F, 0x03, 0x80,
  0x38, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x01, 0xC3, 0x80, 0x38,
  0x1F, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3C, 0xF8, 0x0E, 0x03, 0x83, 0x80, 0x38, 0xE0, 0x03, 0x18, 0x00,
  0x73, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x1E, 0x60, 0x02,
  0xCE, 0x01, 0xD8, 0xE0, 0x73, 0x0F, 0xFC, 0x60, 0x7E, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x6F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x6F, 0xF0, 0x33, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x63, 0x19,
  0xCC, 0xC2, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x1E, 0x3C,
  0x38, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x3E, 0x00, 0x63, 0x00, 0x1F, 0xE0, 0x04, 0x60, 0x07, 0x06,
  0x00, 0xCC, 0x01, 0x80, 0x60, 0x1B, 0x00, 0x60, 0x0C, 0x03, 0x60, 0x0C,
  0x01, 0x00, 0x6C, 0x03, 0x00, 0x20, 0x05, 0x80, 0x60, 0x04, 0x00, 0xA0,
  0x0C, 0x00, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x03, 0x80, 0x60, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0x78, 0x04, 0x00, 0x60, 0x0F, 0x00, 0x80, 0x0C, 0x01, 0xE0, 0x10,
  0x01, 0x80, 0x3C, 0x02, 0x00, 0x30, 0x05, 0x80, 0x60, 0x0E, 0x00, 0xB0,
  0x0C, 0x01, 0xC0, 0x32, 0x01, 0x80, 0x78, 0x04, 0x40, 0x30, 0x0B, 0x01,
  0x8C, 0x03, 0x03, 0x30, 0x61, 0x80, 0x71, 0xC7, 0x1C, 0x30, 0x07, 0xF0,
  0x7E, 0x03, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0,
  0x07, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0C, 0x00, 0x78, 0xC0, 0x01, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x07, 0x8F, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x78, 0x7C,
  0x07, 0x80, 0x38, 0x18, 0x00, 0x70, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x70, 0x00, 0x18, 0xC0,
  0x00, 0xE1, 0x80, 0x03, 0x07, 0x80, 0x38, 0x07, 0xC7, 0xC0, 0x0F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30, 0x03, 0xC1,
  0x80, 0x07, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x1C, 0x30, 0x03, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x1F, 0x80, 0x70,
  0x03, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x7E, 0x3F,
  0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x01, 0x86, 0x00, 0x70, 0xE0, 0x1C, 0x0F, 0x9F,
  0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC,
  0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00,
  0x70, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x3C, 0x00, 0x0D, 0xD8, 0x00, 0x36, 0x70,
  0x00, 0xF0, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xC0,
  0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x00, 0xFB, 0x00, 0x00,
  0x07, 0xD8, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x03, 0x73, 0x00, 0x00, 0x1B,
  0x98, 0x00, 0x01, 0x9C, 0x60, 0x00, 0x0C, 0xE3, 0x00, 0x00, 0x67, 0x98,
  0x00, 0x06, 0x3C, 0x60, 0x00, 0x31, 0xE3, 0x00, 0x01, 0x8F, 0x18, 0x00,
  0x18, 0x78, 0x60, 0x00, 0xC3, 0xC3, 0x00, 0x06, 0x1E, 0x0C, 0x00, 0x60,
  0xF0, 0x60, 0x03, 0x07, 0x83, 0x00, 0x10, 0x3C, 0x0C, 0x01, 0x81, 0xE0,
  0x60, 0x0C, 0x0F, 0x03, 0x00, 0xC0, 0x78, 0x0C, 0x06, 0x03, 0xC0, 0x60,
  0x30, 0x1E, 0x03, 0x03, 0x00, 0xF0, 0x0C, 0x18, 0x07, 0x80, 0x60, 0xC0,
  0x3C, 0x01, 0x0C, 0x01, 0xE0, 0x0C, 0x60, 0x0F, 0x00, 0x63, 0x00, 0x78,
  0x01, 0xB0, 0x03, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x68, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7B, 0x00, 0x00, 0xF6, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xCC, 0x00, 0x07,
  0x8C, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x78,
  0x30, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0x60, 0x03, 0xC0, 0x60, 0x07, 0x80,
  0xE0, 0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x01,
  0x80, 0xF0, 0x03, 0x01, 0xE0, 0x03, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x06,
  0x0F, 0x00, 0x06, 0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x0C, 0x78, 0x00, 0x18,
  0xF0, 0x00, 0x19, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xE7, 0xE0, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x03, 0xE7, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xC0,
  0x07, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xE7, 0xE0,
  0x0F, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x0F, 0x00, 0x70, 0x03, 0xE7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x20,
  0x01, 0xE1, 0x00, 0x03, 0x88, 0x00, 0x0E, 0x40, 0x00, 0x32, 0x00, 0x01,
  0x90, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00,
  0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0xC4, 0x00, 0x0E, 0x20, 0x00, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x40, 0x06, 0x02, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x04,
  0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00,
  0x62, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x01, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0x1F, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x07, 0x00,
  0x03, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x33, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x7E, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0,
  0x01, 0xC1, 0xC0, 0x0E, 0x03, 0xF3, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0xA0, 0x00, 0x66, 0x00, 0x0D, 0x00,
  0x03, 0x30, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00,
  0x13, 0x00, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x18, 0x60, 0x02, 0x18, 0x01, 0x81, 0x80, 0x30,
  0x40, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0x40, 0xC0, 0x30, 0x18, 0x06, 0x02, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x08, 0x06, 0x03, 0x00, 0xC0,
  0xC0, 0x10, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x04, 0x60, 0x01, 0x98, 0x00, 0x36, 0x00, 0x04, 0xC0, 0x01,
  0xB0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x80, 0x03, 0x81, 0x80,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x70,
  0x1C, 0x00, 0x30, 0x18, 0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0E, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xFC, 0x01,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x18,
  0x06, 0x30, 0x08, 0x60, 0x30, 0x60, 0x60, 0xC0, 0x80, 0x83, 0x01, 0x86,
  0x03, 0x08, 0x02, 0x30, 0x06, 0x60, 0x0D, 0x80, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0xFF, 0xE1, 0xFF, 0xF8, 0xE0, 0x06, 0x70, 0x01, 0xB8,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xA0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0E, 0xC0, 0x07, 0x98, 0x03, 0x67, 0xCF, 0x8C, 0x7F, 0x83,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x01, 0x00, 0xC7, 0xFC, 0x33, 0x87, 0x8D, 0x80,
  0x73, 0xC0, 0x0E, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6E, 0x00, 0x1B, 0xC0, 0x0E,
  0xD8, 0x07, 0x33, 0xC7, 0x8C, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x6C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x06, 0x70, 0x01, 0x8E, 0x00, 0xC1, 0xF1, 0xE0, 0x1F, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x07, 0xF8, 0xC7, 0x87, 0x33, 0x80,
  0x6C, 0xC0, 0x0F, 0x60, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1C, 0xC0, 0x07,
  0x38, 0x07, 0xC7, 0xCF, 0xB0, 0x7F, 0x8C, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3E, 0x3C, 0x0E, 0x01, 0xC1, 0x80, 0x1C, 0x60, 0x01, 0x8C,
  0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x43, 0x80, 0x18, 0x3E,
  0x3E, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xC0, 0xE2, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x7F, 0xFB, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x31, 0xE1, 0xCC, 0xE0, 0x1B, 0x30, 0x03, 0xD8, 0x00,
  0x76, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x01, 0xCE, 0x01, 0xF1, 0xF3, 0xEC,
  0x1F, 0xE3, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x32, 0x00, 0x18, 0xC0, 0x0E, 0x1C, 0x07, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x3F, 0xC6, 0x38, 0xF3, 0x30, 0x1D, 0xB0,
  0x06, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x06, 0xFF, 0x00, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6C, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x73, 0xF1, 0xF0, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x36, 0x00, 0x33, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x38, 0x60, 0x38,
  0x30, 0x38, 0x18, 0x38, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x18, 0x01, 0x98,
  0x00, 0xDE, 0x00, 0x79, 0x80, 0x38, 0xE0, 0x18, 0x30, 0x0C, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x38, 0x60, 0x0E, 0x30, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xC3,
  0xFC, 0x07, 0xF8, 0xCF, 0x1E, 0x1E, 0x3C, 0xDC, 0x07, 0x38, 0x0E, 0xD0,
  0x03, 0x30, 0x06, 0xF0, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x61, 0xFE, 0x31, 0xC7, 0x99, 0x80, 0xED, 0x80, 0x37, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x3C, 0x7C, 0x0E, 0x01, 0xC3, 0x00, 0x18, 0xE0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x80, 0x06, 0x30, 0x01, 0x83, 0x80,
  0x70, 0x3C, 0x7C, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x40, 0x31, 0xFF,
  0x0C, 0xE1, 0xE3, 0x60, 0x1C, 0xF0, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B,
  0x80, 0x06, 0xF0, 0x03, 0xB6, 0x01, 0xCC, 0xF1, 0xE3, 0x1F, 0xF0, 0xC0,
  0x40, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x31, 0xE1, 0xCC, 0xE0, 0x1B, 0x30, 0x03, 0xD8,
  0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x01, 0xCE, 0x01, 0xF1, 0xF3,
  0xEC, 0x1F, 0xE3, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0xFF, 0x3C, 0x6C, 0x0D, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x0F,
  0x0F, 0x0E, 0x00, 0xC6, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x60, 0x03,
  0x38, 0x03, 0x8F, 0xCF, 0x81, 0xFF, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xEF, 0xFE,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x79,
  0x03, 0xF0, 0x04, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x0F, 0x30, 0x0D, 0x9F, 0x3C, 0xC3, 0xFC,
  0x60, 0x20, 0x00, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xD0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x78, 0x01, 0x98, 0x01,
  0xE0, 0x06, 0x60, 0x07, 0x80, 0x19, 0x80, 0x16, 0x00, 0x63, 0x00, 0xCC,
  0x03, 0x0C, 0x03, 0x30, 0x0C, 0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x21, 0x00,
  0xC1, 0x81, 0x86, 0x06, 0x06, 0x06, 0x18, 0x18, 0x18, 0x18, 0x60, 0x60,
  0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x03, 0x0C, 0x03, 0x0C, 0x0C, 0x30, 0x0C,
  0x20, 0x10, 0xC0, 0x31, 0x80, 0x63, 0x00, 0x66, 0x01, 0x98, 0x01, 0x98,
  0x06, 0x60, 0x06, 0x40, 0x09, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x2C, 0x00,
  0xD0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x31, 0xC0, 0x0E,
  0x18, 0x01, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x30, 0xE0,
  0x06, 0x18, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x06, 0x06, 0x00, 0xC0, 0xE0, 0x30, 0x0C, 0x0E, 0x00, 0xC1,
  0x80, 0x18, 0x60, 0x01, 0x9C, 0x00, 0x3B, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x36, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x10, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x38, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x80, 0x05, 0xC3, 0x80, 0x1B, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x78, 0x03,
  0x81, 0xB0, 0x03, 0x87, 0x60, 0x03, 0xFC, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 38, 10, 4, -37 },
  { 16, 7, 11, 14, 4, -39 },
  { 26, 24, 37, 26, 2, -37 },
  { 137, 19, 49, 25, 3, -43 },
  { 254, 28, 39, 34, 3, -38 },
  { 391, 24, 39, 28, 3, -38 },
  { 508, 2, 11, 9, 3, -39 },
  { 511, 9, 53, 15, 4, -41 },
  { 571, 10, 53, 15, 1, -41 },
  { 638, 20, 20, 22, 1, -37 },
  { 688, 21, 27, 26, 2, -30 },
  { 759, 4, 11, 10, 2, -4 },
  { 765, 10, 2, 14, 2, -18 },
  { 768, 3, 4, 12, 4, -3 },
  { 770, 15, 40, 18, 1, -37 },
  { 845, 19, 39, 25, 3, -38 },
  { 938, 11, 37, 25, 4, -37 },
  { 989, 20, 38, 25, 3, -38 },
  { 1084, 19, 39, 25, 3, -38 },
  { 1177, 22, 37, 25, 2, -37 },
  { 1279, 19, 38, 25, 4, -37 },
  { 1370, 19, 38, 25, 3, -37 },
  { 1461, 20, 37, 25, 2, -37 },
  { 1554, 20, 39, 25, 3, -38 },
  { 1652, 19, 38, 25, 3, -38 },
  { 1743, 4, 28, 10, 3, -27 },
  { 1757, 5, 34, 9, 2, -27 },
  { 1779, 18, 21, 24, 2, -27 },
  { 1827, 18, 12, 25, 4, -23 },
  { 1854, 18, 21, 24, 3, -27 },
  { 1902, 16, 39, 21, 2, -38 },
  { 1980, 35, 48, 41, 3, -36 },
  { 2190, 26, 37, 28, 1, -37 },
  { 2311, 20, 37, 28, 5, -37 },
  { 2404, 22, 39, 29, 4, -38 },
  { 2512, 21, 37, 30, 5, -37 },
  { 2610, 19, 37, 26, 5, -37 },
  { 2698, 19, 37, 26, 5, -37 },
  { 2786, 23, 39, 31, 4, -38 },
  { 2899, 22, 37, 32, 5, -37 },
  { 3001, 2, 37, 13, 5, -37 },
  { 3011, 19, 38, 25, 2, -37 },
  { 3102, 22, 37, 29, 5, -37 },
  { 3204, 17, 37, 24, 5, -37 },
  { 3283, 29, 37, 39, 5, -37 },
  { 3418, 23, 37, 32, 5, -37 },
  { 3525, 24, 39, 31, 3, -38 },
  { 3642, 20, 37, 28, 5, -37 },
  { 3735, 24, 45, 31, 3, -38 },
  { 3870, 21, 37, 29, 5, -37 },
  { 3968, 23, 39, 27, 2, -38 },
  { 4081, 24, 37, 27, 2, -37 },
  { 4192, 22, 38, 30, 4, -37 },
  { 4297, 26, 37, 28, 1, -37 },
  { 4418, 37, 37, 41, 2, -37 },
  { 4590, 24, 37, 28, 2, -37 },
  { 4701, 25, 37, 27, 1, -37 },
  { 4817, 23, 37, 27, 2, -37 },
  { 4924, 7, 50, 11, 4, -42 },
  { 4968, 15, 40, 18, 2, -37 },
  { 5043, 7, 50, 11, 0, -42 },
  { 5087, 15, 18, 19, 2, -37 },
  { 5121, 18, 2, 20, 1, 0 },
  { 5126, 8, 7, 14, 3, -39 },
  { 5133, 18, 29, 24, 3, -28 },
  { 5199, 18, 40, 25, 4, -39 },
  { 5289, 18, 29, 23, 3, -28 },
  { 5355, 18, 40, 25, 3, -39 },
  { 5445, 19, 29, 24, 2, -28 },
  { 5514, 13, 40, 15, 2, -40 },
  { 5579, 18, 39, 25, 3, -28 },
  { 5667, 17, 39, 25, 4, -39 },
  { 5750, 3, 37, 10, 4, -37 },
  { 5764, 9, 48, 11, -2, -37 },
  { 5818, 17, 39, 22, 4, -39 },
  { 5901, 2, 39, 10, 4, -39 },
  { 5911, 32, 28, 40, 4, -28 },
  { 6023, 17, 28, 25, 4, -28 },
  { 6083, 19, 29, 25, 3, -28 },
  { 6152, 18, 39, 25, 4, -28 },
  { 6240, 18, 39, 25, 3, -28 },
  { 6328, 11, 28, 16, 4, -28 },
  { 6367, 17, 29, 23, 3, -28 },
  { 6429, 12, 36, 15, 1, -35 },
  { 6483, 17, 28, 25, 4, -27 },
  { 6543, 20, 27, 22, 1, -27 },
  { 6611, 30, 27, 34, 2, -27 },
  { 6713, 19, 27, 22, 2, -27 },
  { 6778, 20, 38, 22, 1, -27 },
  { 6873, 19, 27, 22, 2, -27 },
  { 6938, 13, 52, 15, 2, -41 },
  { 7023, 2, 44, 11, 5, -37 },
  { 7034, 12, 52, 15, 1, -41 },
  { 7112, 23, 9, 31, 4, -20 },
};

const GFXfont RobotoCondensed_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT52PT7B_H_
