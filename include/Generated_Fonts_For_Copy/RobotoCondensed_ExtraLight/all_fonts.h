#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_ExtraLight
// Headers: 67

#include "RobotoCondensed_ExtraLight6pt7b.h"
#include "RobotoCondensed_ExtraLight7pt7b.h"
#include "RobotoCondensed_ExtraLight8pt7b.h"
#include "RobotoCondensed_ExtraLight9pt7b.h"
#include "RobotoCondensed_ExtraLight10pt7b.h"
#include "RobotoCondensed_ExtraLight11pt7b.h"
#include "RobotoCondensed_ExtraLight12pt7b.h"
#include "RobotoCondensed_ExtraLight13pt7b.h"
#include "RobotoCondensed_ExtraLight14pt7b.h"
#include "RobotoCondensed_ExtraLight15pt7b.h"
#include "RobotoCondensed_ExtraLight16pt7b.h"
#include "RobotoCondensed_ExtraLight17pt7b.h"
#include "RobotoCondensed_ExtraLight18pt7b.h"
#include "RobotoCondensed_ExtraLight19pt7b.h"
#include "RobotoCondensed_ExtraLight20pt7b.h"
#include "RobotoCondensed_ExtraLight21pt7b.h"
#include "RobotoCondensed_ExtraLight22pt7b.h"
#include "RobotoCondensed_ExtraLight23pt7b.h"
#include "RobotoCondensed_ExtraLight24pt7b.h"
#include "RobotoCondensed_ExtraLight25pt7b.h"
#include "RobotoCondensed_ExtraLight26pt7b.h"
#include "RobotoCondensed_ExtraLight27pt7b.h"
#include "RobotoCondensed_ExtraLight28pt7b.h"
#include "RobotoCondensed_ExtraLight29pt7b.h"
#include "RobotoCondensed_ExtraLight30pt7b.h"
#include "RobotoCondensed_ExtraLight31pt7b.h"
#include "RobotoCondensed_ExtraLight32pt7b.h"
#include "RobotoCondensed_ExtraLight33pt7b.h"
#include "RobotoCondensed_ExtraLight34pt7b.h"
#include "RobotoCondensed_ExtraLight35pt7b.h"
#include "RobotoCondensed_ExtraLight36pt7b.h"
#include "RobotoCondensed_ExtraLight37pt7b.h"
#include "RobotoCondensed_ExtraLight38pt7b.h"
#include "RobotoCondensed_ExtraLight39pt7b.h"
#include "RobotoCondensed_ExtraLight40pt7b.h"
#include "RobotoCondensed_ExtraLight41pt7b.h"
#include "RobotoCondensed_ExtraLight42pt7b.h"
#include "RobotoCondensed_ExtraLight43pt7b.h"
#include "RobotoCondensed_ExtraLight44pt7b.h"
#include "RobotoCondensed_ExtraLight45pt7b.h"
#include "RobotoCondensed_ExtraLight46pt7b.h"
#include "RobotoCondensed_ExtraLight47pt7b.h"
#include "RobotoCondensed_ExtraLight48pt7b.h"
#include "RobotoCondensed_ExtraLight49pt7b.h"
#include "RobotoCondensed_ExtraLight50pt7b.h"
#include "RobotoCondensed_ExtraLight51pt7b.h"
#include "RobotoCondensed_ExtraLight52pt7b.h"
#include "RobotoCondensed_ExtraLight53pt7b.h"
#include "RobotoCondensed_ExtraLight54pt7b.h"
#include "RobotoCondensed_ExtraLight55pt7b.h"
#include "RobotoCondensed_ExtraLight56pt7b.h"
#include "RobotoCondensed_ExtraLight57pt7b.h"
#include "RobotoCondensed_ExtraLight58pt7b.h"
#include "RobotoCondensed_ExtraLight59pt7b.h"
#include "RobotoCondensed_ExtraLight60pt7b.h"
#include "RobotoCondensed_ExtraLight61pt7b.h"
#include "RobotoCondensed_ExtraLight62pt7b.h"
#include "RobotoCondensed_ExtraLight63pt7b.h"
#include "RobotoCondensed_ExtraLight64pt7b.h"
#include "RobotoCondensed_ExtraLight65pt7b.h"
#include "RobotoCondensed_ExtraLight66pt7b.h"
#include "RobotoCondensed_ExtraLight67pt7b.h"
#include "RobotoCondensed_ExtraLight68pt7b.h"
#include "RobotoCondensed_ExtraLight69pt7b.h"
#include "RobotoCondensed_ExtraLight70pt7b.h"
#include "RobotoCondensed_ExtraLight71pt7b.h"
#include "RobotoCondensed_ExtraLight72pt7b.h"
