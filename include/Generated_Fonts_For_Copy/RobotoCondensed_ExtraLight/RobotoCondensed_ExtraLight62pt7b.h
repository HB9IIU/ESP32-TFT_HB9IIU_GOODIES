#ifndef _ROBOTOCONDENSED_EXTRALIGHT62PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF7, 0x00,
  0x61, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3C, 0x07, 0x81, 0xC0,
  0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x39, 0xC0, 0x00, 0x67, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0xC0,
  0x00, 0x73, 0x80, 0x03, 0x8F, 0x00, 0x1C, 0x1E, 0x01, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x01, 0x81, 0x80, 0x06, 0x00,
  0xE0, 0x60, 0x01, 0x80, 0x30, 0x30, 0x00, 0x60, 0x0C, 0x1C, 0x00, 0x0C,
  0x07, 0x06, 0x00, 0x03, 0x83, 0x83, 0x80, 0x00, 0x7F, 0xC0, 0xC0, 0x00,
  0x0F, 0xE0, 0x60, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x7F, 0x00, 0x00, 0x30, 0x3F, 0xE0, 0x00, 0x0C, 0x1C, 0x1C, 0x00, 0x06,
  0x06, 0x03, 0x80, 0x01, 0x83, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x18, 0x00,
  0x70, 0x30, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x30,
  0x03, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x30, 0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x60, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x18, 0x70, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0x06,
  0x38, 0x01, 0xC0, 0x31, 0x80, 0x07, 0x03, 0x8C, 0x00, 0x1C, 0x18, 0x60,
  0x00, 0x60, 0xC7, 0x00, 0x03, 0x86, 0x38, 0x00, 0x0E, 0x71, 0xC0, 0x00,
  0x3B, 0x06, 0x00, 0x00, 0xF8, 0x30, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x1D, 0x81, 0xE0, 0x01, 0xCE, 0x07,
  0x80, 0x3C, 0x38, 0x1F, 0xDF, 0xC0, 0xE0, 0x3F, 0xF8, 0x03, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x01, 0xE0, 0x18, 0x07, 0xFC, 0x18, 0x3F, 0x3F, 0x98,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x01, 0xC3, 0x80, 0x01, 0x81,
  0xC0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x04, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xC7, 0x18, 0x40, 0xFF, 0xFF,
  0xFF, 0x77, 0xDC, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xF0, 0x1C, 0x00, 0xE0,
  0x60, 0x01, 0x83, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x39, 0x80,
  0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00,
  0x06, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x1F, 0xB3,
  0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x78, 0x07, 0x80, 0xE0, 0x07, 0x03, 0x80,
  0x07, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00,
  0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xDC, 0x00, 0x03,
  0x98, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x3C, 0x03, 0xC0,
  0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x06, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0xFC,
  0x00, 0xDF, 0xFE, 0x03, 0xF0, 0x7C, 0x1F, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x3F, 0x00, 0xE1, 0xFF, 0x81, 0xCF, 0x87, 0xC3, 0x38, 0x03,
  0xC6, 0xE0, 0x03, 0x8D, 0x80, 0x03, 0x9E, 0x00, 0x03, 0x38, 0x00, 0x07,
  0x70, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x67, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0xC1, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x78, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x07,
  0x03, 0x80, 0x06, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x98, 0x00, 0x0F, 0x38, 0x00, 0x36, 0x38, 0x00,
  0xEC, 0x38, 0x03, 0x98, 0x3C, 0x1E, 0x30, 0x3F, 0xF0, 0x60, 0x1F, 0x81,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x3C, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x8E, 0x31, 0xCE, 0x10, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x1E, 0x03, 0x83, 0x80, 0x38, 0xE0, 0x03,
  0x18, 0x00, 0x77, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x03, 0xE0,
  0x00, 0xC1, 0x80, 0x03, 0xFE, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0xC0, 0x06,
  0x30, 0x00, 0xE0, 0x38, 0x01, 0x9C, 0x00, 0x60, 0x06, 0x00, 0x66, 0x00,
  0x38, 0x01, 0x80, 0x19, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x60, 0x07, 0x00,
  0x18, 0x01, 0xB8, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x80,
  0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xF0,
  0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x0C,
  0x00, 0x6C, 0x01, 0x80, 0x03, 0x00, 0x1B, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0xC0, 0x18, 0x00, 0x30, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0x6C, 0x01,
  0x80, 0x07, 0x00, 0x1B, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0xC0, 0x1C, 0x00,
  0x70, 0x03, 0x30, 0x03, 0x00, 0x3C, 0x00, 0xCE, 0x00, 0xC0, 0x1B, 0x00,
  0x61, 0x80, 0x38, 0x06, 0xC0, 0x38, 0x60, 0x06, 0x03, 0x18, 0x1C, 0x18,
  0x01, 0xE7, 0x87, 0x8E, 0x07, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x07, 0xE0,
  0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF0,
  0xC0, 0x00, 0x78, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x78, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x01, 0xF8,
  0x18, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x71, 0x80, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0x60,
  0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE6,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0,
  0x30, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0xC7, 0xC0, 0x00, 0x33, 0xF0, 0x00, 0x0C, 0xCE, 0x00, 0x03, 0x71, 0xC0,
  0x00, 0xF8, 0x30, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00,
  0x38, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x37,
  0xF0, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x01, 0xDE, 0xC0, 0x00, 0x00,
  0x33, 0xDC, 0x00, 0x00, 0x06, 0x79, 0x80, 0x00, 0x01, 0xCF, 0x30, 0x00,
  0x00, 0x31, 0xE7, 0x00, 0x00, 0x0E, 0x3C, 0x60, 0x00, 0x01, 0x87, 0x8C,
  0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x0E, 0x1E, 0x18, 0x00, 0x01, 0x83,
  0xC3, 0x80, 0x00, 0x30, 0x78, 0x30, 0x00, 0x0E, 0x0F, 0x06, 0x00, 0x01,
  0x81, 0xE0, 0xE0, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x0E, 0x07, 0x81, 0x80,
  0x01, 0x80, 0xF0, 0x38, 0x00, 0x30, 0x1E, 0x03, 0x00, 0x0C, 0x03, 0xC0,
  0x60, 0x01, 0x80, 0x78, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xC0, 0x0C, 0x01,
  0xE0, 0x1C, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x70, 0x07, 0x80, 0x30, 0x0C,
  0x00, 0xF0, 0x07, 0x01, 0x80, 0x1E, 0x00, 0x60, 0x70, 0x03, 0xC0, 0x0C,
  0x0C, 0x00, 0x78, 0x01, 0xC1, 0x80, 0x0F, 0x00, 0x18, 0x60, 0x01, 0xE0,
  0x03, 0x0C, 0x00, 0x3C, 0x00, 0x33, 0x80, 0x07, 0x80, 0x06, 0x60, 0x00,
  0xF0, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF7,
  0x00, 0x00, 0x3E, 0x60, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF8, 0xC0, 0x00,
  0x1F, 0x1C, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x7C, 0x38, 0x00, 0x0F, 0x83,
  0x80, 0x01, 0xF0, 0x30, 0x00, 0x3E, 0x07, 0x00, 0x07, 0xC0, 0x60, 0x00,
  0xF8, 0x0E, 0x00, 0x1F, 0x00, 0xC0, 0x03, 0xE0, 0x1C, 0x00, 0x7C, 0x01,
  0xC0, 0x0F, 0x80, 0x18, 0x01, 0xF0, 0x03, 0x80, 0x3E, 0x00, 0x30, 0x07,
  0xC0, 0x07, 0x00, 0xF8, 0x00, 0x60, 0x1F, 0x00, 0x0E, 0x03, 0xE0, 0x00,
  0xE0, 0x7C, 0x00, 0x0C, 0x0F, 0x80, 0x01, 0xC1, 0xF0, 0x00, 0x18, 0x3E,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x30, 0xF8, 0x00, 0x07, 0x1F, 0x00, 0x00,
  0x73, 0xE0, 0x00, 0x06, 0x7C, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x0D, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x07,
  0xC0, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF0, 0xC0, 0x00,
  0x78, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xC0, 0x03,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x0E, 0x00, 0x1F, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0x83, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x07, 0x00, 0x00, 0x76, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x67, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0x30, 0x00, 0x0D, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x0E,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x70,
  0x60, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x70,
  0x03, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x30, 0x03,
  0x00, 0xE0, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x70,
  0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C,
  0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x03, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x36, 0x00, 0x3B, 0x00, 0x19, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x1C,
  0x03, 0x06, 0x03, 0x83, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60,
  0x1C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x36,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC7, 0x00, 0x03,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0xF8, 0x3E, 0x00, 0x61, 0xC0, 0x01, 0x8E, 0x00, 0x06,
  0x70, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x79, 0x80, 0x03, 0x67, 0x00, 0x1D, 0x8F, 0x01, 0xE6, 0x1F, 0xFE, 0x1C,
  0x3F, 0xF0, 0x70, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x3F, 0xF0, 0x31,
  0xFF, 0xE0, 0xCE, 0x03, 0xC3, 0x60, 0x03, 0x8F, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80,
  0x01, 0xCF, 0x00, 0x07, 0x36, 0x00, 0x38, 0xDE, 0x03, 0xC3, 0x1F, 0xFE,
  0x0C, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00,
  0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x30,
  0x00, 0x18, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0xC0, 0x38, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x1F, 0xF8, 0x61, 0xFF,
  0xE3, 0x1E, 0x03, 0x99, 0xC0, 0x06, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0x76,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00, 0x1E,
  0x70, 0x01, 0xB1, 0xE0, 0x3D, 0x87, 0xFF, 0x8C, 0x0F, 0xF8, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78,
  0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x60,
  0x00, 0x1D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x21,
  0xC0, 0x01, 0x83, 0xC0, 0x1C, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x01, 0xF3, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC3, 0xFF, 0xC6, 0x3C, 0x07,
  0x33, 0x80, 0x0D, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x98, 0x00, 0x3C, 0xE0, 0x03, 0x63,
  0xC0, 0x7B, 0x0F, 0xFF, 0x18, 0x3F, 0xF0, 0xC0, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x39, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x78, 0x01, 0xC1, 0xF0, 0x3C,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x00, 0xC1, 0xFF, 0x0C, 0x3F, 0xF8, 0xC7, 0x01,
  0xCC, 0xC0, 0x0E, 0xD8, 0x00, 0x6F, 0x00, 0x06, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x67, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0xE4, 0x3C, 0xFF, 0x0F, 0x80, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x03, 0x98, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x30, 0x01,
  0xC1, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x01, 0xC0, 0x18,
  0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x8E, 0x00,
  0x0C, 0xF0, 0x00, 0x6F, 0x80, 0x03, 0xEE, 0x00, 0x1E, 0x38, 0x00, 0xE0,
  0xE0, 0x06, 0x03, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x60, 0x0E, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00,
  0x1C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x04, 0x03, 0x07, 0xFC, 0x01, 0xFF,
  0x0C, 0x7F, 0xF8, 0x1F, 0xFE, 0x33, 0x80, 0xF0, 0xE0, 0x1C, 0xDC, 0x00,
  0xE7, 0x00, 0x3B, 0x60, 0x03, 0x98, 0x00, 0x6F, 0x00, 0x06, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10, 0x0C,
  0x1F, 0xF0, 0xC3, 0xFF, 0x8C, 0x70, 0x1C, 0xCC, 0x00, 0xED, 0x80, 0x06,
  0xF0, 0x00, 0x6F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x0F, 0xFC,
  0x0C, 0x7F, 0xF8, 0x33, 0x80, 0xF0, 0xD8, 0x00, 0xE3, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C,
  0xE0, 0x00, 0x73, 0xC0, 0x01, 0x8F, 0x80, 0x0E, 0x37, 0x80, 0xF0, 0xC7,
  0xFF, 0x83, 0x0F, 0xFC, 0x0C, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC3, 0xFF,
  0xC6, 0x3C, 0x07, 0x33, 0x80, 0x0D, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xEC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x03, 0x98, 0x00, 0x3C,
  0xE0, 0x03, 0xE3, 0xC0, 0x7B, 0x0F, 0xFF, 0x98, 0x3F, 0xF0, 0xC0, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x2C, 0x3F,
  0xC7, 0xFC, 0xE0, 0xDC, 0x0D, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x38, 0x03, 0x83, 0x80,
  0x0E, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x76, 0x00, 0x03, 0x38, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x80, 0x3C,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x08, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x40, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00,
  0x1B, 0x3C, 0x07, 0x31, 0xFF, 0xE3, 0x0F, 0xFC, 0x30, 0x08, 0x00, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00,
  0x01, 0x8E, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xE0, 0x03, 0x00, 0xC0, 0x0E,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0xE0, 0x06, 0x01, 0x80,
  0x0E, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x70, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0xC6, 0x00, 0x01,
  0x9C, 0x00, 0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x76, 0x00, 0x07, 0x00, 0x07, 0x60, 0x00, 0x70, 0x00, 0x67,
  0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0xF0, 0x00, 0x63, 0x00, 0x0D, 0x80,
  0x0E, 0x30, 0x01, 0xD8, 0x00, 0xE3, 0x80, 0x19, 0x80, 0x0C, 0x38, 0x01,
  0x9C, 0x00, 0xC1, 0x80, 0x18, 0xC0, 0x1C, 0x18, 0x03, 0x8C, 0x01, 0xC1,
  0xC0, 0x30, 0xC0, 0x18, 0x1C, 0x03, 0x0E, 0x01, 0x80, 0xC0, 0x30, 0x60,
  0x38, 0x0C, 0x07, 0x06, 0x03, 0x80, 0xE0, 0x60, 0x60, 0x30, 0x0E, 0x06,
  0x07, 0x03, 0x00, 0x60, 0x60, 0x30, 0x70, 0x06, 0x0C, 0x03, 0x07, 0x00,
  0x70, 0xC0, 0x30, 0x60, 0x07, 0x0C, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x18,
  0x60, 0x03, 0x18, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x03, 0x98,
  0x00, 0xCC, 0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0xDC, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x03, 0x81, 0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x30, 0x03,
  0x00, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0E,
  0x30, 0x00, 0x0C, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0xC0,
  0x07, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x80, 0xE0, 0x03, 0x01,
  0x80, 0x07, 0x07, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0xE0,
  0x00, 0x1C, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x33, 0x00,
  0x00, 0xE6, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xE0, 0x03,
  0x00, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xE3, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xCF, 0x1E,
  0x00, 0x0C, 0x60, 0x3C, 0x00, 0x67, 0x00, 0xF0, 0x03, 0x30, 0x03, 0xC0,
  0x39, 0x80, 0x0F, 0x01, 0x8C, 0x00, 0x1E, 0x3C, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 45, 12, 4, -44 },
  { 24, 9, 13, 17, 4, -47 },
  { 39, 29, 44, 31, 2, -44 },
  { 199, 22, 58, 30, 4, -51 },
  { 359, 34, 46, 40, 3, -45 },
  { 555, 29, 46, 33, 3, -45 },
  { 722, 2, 13, 10, 4, -47 },
  { 726, 12, 63, 17, 4, -49 },
  { 821, 12, 63, 18, 1, -49 },
  { 916, 24, 24, 26, 1, -44 },
  { 988, 26, 32, 31, 2, -36 },
  { 1092, 6, 13, 12, 2, -5 },
  { 1102, 12, 2, 16, 2, -21 },
  { 1105, 5, 4, 14, 4, -3 },
  { 1108, 17, 48, 22, 2, -44 },
  { 1210, 22, 46, 30, 4, -45 },
  { 1337, 13, 44, 30, 5, -44 },
  { 1409, 24, 45, 30, 3, -45 },
  { 1544, 23, 46, 30, 3, -45 },
  { 1677, 27, 44, 30, 2, -44 },
  { 1826, 22, 45, 30, 5, -44 },
  { 1950, 23, 45, 30, 4, -44 },
  { 2080, 24, 44, 30, 3, -44 },
  { 2212, 24, 46, 30, 3, -45 },
  { 2350, 23, 45, 30, 3, -45 },
  { 2480, 4, 33, 11, 4, -32 },
  { 2497, 6, 40, 11, 2, -32 },
  { 2527, 21, 25, 28, 3, -33 },
  { 2593, 22, 14, 30, 4, -27 },
  { 2632, 21, 25, 28, 4, -33 },
  { 2698, 19, 46, 24, 3, -45 },
  { 2808, 42, 57, 49, 4, -43 },
  { 3108, 31, 44, 33, 1, -44 },
  { 3279, 24, 44, 33, 6, -44 },
  { 3411, 27, 46, 35, 4, -45 },
  { 3567, 25, 44, 35, 6, -44 },
  { 3705, 22, 44, 31, 6, -44 },
  { 3826, 23, 44, 31, 6, -44 },
  { 3953, 27, 46, 37, 5, -45 },
  { 4109, 27, 44, 38, 6, -44 },
  { 4258, 3, 44, 15, 6, -44 },
  { 4275, 22, 45, 30, 3, -44 },
  { 4399, 26, 44, 34, 6, -44 },
  { 4542, 21, 44, 29, 6, -44 },
  { 4658, 35, 44, 46, 6, -44 },
  { 4851, 27, 44, 38, 6, -44 },
  { 5000, 28, 46, 36, 4, -45 },
  { 5161, 24, 44, 33, 6, -44 },
  { 5293, 28, 53, 36, 4, -45 },
  { 5479, 26, 44, 35, 5, -44 },
  { 5622, 27, 46, 32, 3, -45 },
  { 5778, 29, 44, 32, 2, -44 },
  { 5938, 26, 45, 36, 5, -44 },
  { 6085, 31, 44, 33, 1, -44 },
  { 6256, 44, 44, 48, 2, -44 },
  { 6498, 29, 44, 33, 2, -44 },
  { 6658, 30, 44, 32, 1, -44 },
  { 6823, 27, 44, 33, 3, -44 },
  { 6972, 8, 59, 13, 5, -50 },
  { 7031, 18, 48, 21, 2, -44 },
  { 7139, 7, 59, 13, 1, -50 },
  { 7191, 17, 22, 23, 3, -44 },
  { 7238, 22, 2, 23, 1, 0 },
  { 7244, 9, 8, 17, 4, -46 },
  { 7253, 22, 35, 29, 3, -34 },
  { 7350, 22, 48, 30, 5, -47 },
  { 7482, 22, 35, 28, 3, -34 },
  { 7579, 21, 48, 30, 4, -47 },
  { 7705, 22, 35, 28, 3, -34 },
  { 7802, 16, 48, 18, 2, -48 },
  { 7898, 21, 47, 30, 4, -34 },
  { 8022, 20, 47, 30, 5, -47 },
  { 8140, 4, 45, 12, 4, -45 },
  { 8163, 11, 58, 13, -3, -45 },
  { 8243, 21, 47, 26, 5, -47 },
  { 8367, 2, 47, 12, 5, -47 },
  { 8379, 38, 34, 48, 5, -34 },
  { 8541, 20, 34, 30, 5, -34 },
  { 8626, 24, 35, 30, 3, -34 },
  { 8731, 22, 47, 30, 5, -34 },
  { 8861, 21, 47, 30, 4, -34 },
  { 8985, 12, 34, 19, 5, -34 },
  { 9036, 21, 35, 28, 3, -34 },
  { 9128, 14, 42, 18, 1, -41 },
  { 9202, 20, 34, 30, 5, -33 },
  { 9287, 23, 33, 26, 2, -33 },
  { 9382, 36, 33, 41, 2, -33 },
  { 9531, 23, 33, 26, 2, -33 },
  { 9626, 23, 46, 26, 2, -33 },
  { 9759, 22, 33, 26, 3, -33 },
  { 9850, 16, 61, 18, 2, -48 },
  { 9972, 3, 52, 13, 5, -44 },
  { 9992, 15, 61, 18, 1, -48 },
  { 10107, 29, 10, 37, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT62PT7B_H_
