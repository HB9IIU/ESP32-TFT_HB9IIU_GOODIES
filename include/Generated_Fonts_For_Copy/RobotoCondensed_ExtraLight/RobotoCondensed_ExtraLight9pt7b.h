#ifndef _ROBOTOCONDENSED_EXTRALIGHT9PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x07, 0x55, 0x56, 0x00, 0x1E, 0xC4, 0x4F, 0x00, 0xE5,
  0xBC, 0x43, 0x8C, 0x60, 0x62, 0x98, 0x8A, 0x49, 0xC0, 0x00, 0x7F, 0x00,
  0x95, 0x55, 0x80, 0x0F, 0x46, 0x06, 0x20, 0x00, 0x00, 0x00, 0x25, 0x24,
  0xA4, 0xD6, 0xDB, 0x70, 0xD5, 0x54, 0x71, 0x12, 0x24, 0x60, 0x71, 0x12,
  0x19, 0x70, 0x02, 0x55, 0x71, 0x00, 0xD2, 0x72, 0x78, 0x93, 0xDB, 0x78,
  0x71, 0x22, 0x24, 0x40, 0x79, 0x96, 0x99, 0x70, 0x69, 0x99, 0x71, 0x20,
  0x00, 0x00, 0x29, 0x10, 0x48, 0x89, 0x40, 0x74, 0x90, 0x00, 0x7A, 0x1B,
  0x75, 0x97, 0xE8, 0x1C, 0x23, 0x14, 0xA7, 0x46, 0x00, 0xF6, 0xF9, 0x58,
  0xE8, 0x88, 0x88, 0xE0, 0x69, 0x99, 0x99, 0x60, 0x52, 0x69, 0x10, 0x52,
  0x69, 0x00, 0xE9, 0x88, 0x99, 0xE0, 0x19, 0x9D, 0x99, 0x10, 0x7C, 0x11,
  0x11, 0x19, 0x60, 0x0A, 0xC8, 0xCA, 0x00, 0x12, 0x49, 0x10, 0x0C, 0x67,
  0x3D, 0xF4, 0x80, 0x99, 0x9D, 0xB9, 0x10, 0xE9, 0x99, 0x99, 0xE0, 0xF6,
  0xF9, 0x00, 0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x9E, 0x8A, 0x00, 0x78, 0x86,
  0x19, 0x70, 0x62, 0x22, 0x22, 0x20, 0x16, 0xDB, 0x78, 0x84, 0x94, 0xA5,
  0x30, 0x80, 0x93, 0x26, 0xAB, 0x66, 0xC8, 0x80, 0x00, 0x05, 0x62, 0x65,
  0x00, 0x82, 0x94, 0xC2, 0x10, 0x80, 0x31, 0x22, 0x44, 0x20, 0x7E, 0x91,
  0x24, 0x89, 0x7E, 0x48, 0x80, 0x40, 0x40, 0x31, 0x59, 0xF0, 0x13, 0xDB,
  0x78, 0x69, 0x89, 0x60, 0x27, 0xDB, 0x78, 0x7B, 0x88, 0x60, 0x49, 0x24,
  0x80, 0xF6, 0xDE, 0x58, 0x13, 0xDB, 0x48, 0x1C, 0x1F, 0x80, 0x12, 0x69,
  0x80, 0x7C, 0xFD, 0x6B, 0x52, 0x00, 0xF6, 0xD2, 0x79, 0x99, 0x70, 0xF6,
  0xDF, 0x00, 0xF6, 0xDE, 0x48, 0xAA, 0x00, 0x51, 0x96, 0x15, 0x40, 0x36,
  0xDE, 0x8A, 0x66, 0x20, 0x82, 0xA5, 0x92, 0x40, 0x06, 0x46, 0x00, 0x8A,
  0x66, 0x24, 0x40, 0x52, 0x44, 0x20, 0x09, 0x20, 0x12, 0x00, 0x7E, 0x15,
  0x55, 0x00, 0xD2,
};

const GFXglyph RobotoCondensed_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 0, -7 },
  { 2, 1, 2, 2, 1, -7 },
  { 3, 4, 7, 4, 0, -7 },
  { 7, 3, 9, 4, 1, -8 },
  { 11, 5, 7, 6, 0, -7 },
  { 16, 5, 7, 5, 0, -7 },
  { 21, 1, 2, 2, 0, -7 },
  { 22, 1, 9, 3, 1, -7 },
  { 24, 2, 9, 3, 0, -7 },
  { 27, 4, 4, 4, 0, -7 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -4 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 3, 8, 3, 0, -7 },
  { 37, 3, 7, 4, 1, -7 },
  { 40, 2, 7, 4, 1, -7 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 3, 7, 4, 1, -7 },
  { 57, 3, 7, 4, 1, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 1, 5, 2, 0, -5 },
  { 73, 1, 6, 2, 0, -5 },
  { 74, 3, 4, 4, 0, -5 },
  { 76, 3, 2, 4, 1, -4 },
  { 77, 3, 4, 4, 1, -5 },
  { 79, 3, 7, 4, 0, -7 },
  { 82, 6, 8, 7, 1, -6 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 3, 7, 5, 1, -7 },
  { 96, 4, 7, 5, 1, -7 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 3, 7, 5, 1, -7 },
  { 107, 3, 7, 4, 1, -7 },
  { 110, 4, 7, 5, 1, -7 },
  { 114, 4, 7, 6, 1, -7 },
  { 118, 1, 7, 2, 1, -7 },
  { 119, 4, 7, 4, 0, -7 },
  { 123, 4, 7, 5, 1, -7 },
  { 127, 3, 7, 4, 1, -7 },
  { 130, 5, 7, 7, 1, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 4, 7, 5, 1, -7 },
  { 143, 3, 7, 5, 1, -7 },
  { 146, 4, 8, 5, 1, -7 },
  { 150, 4, 7, 5, 1, -7 },
  { 154, 4, 7, 5, 0, -7 },
  { 158, 4, 7, 5, 0, -7 },
  { 162, 3, 7, 5, 1, -7 },
  { 165, 5, 7, 5, 0, -7 },
  { 170, 7, 7, 7, 0, -7 },
  { 177, 4, 7, 5, 0, -7 },
  { 181, 5, 7, 5, 0, -7 },
  { 186, 4, 7, 5, 0, -7 },
  { 190, 1, 8, 2, 1, -7 },
  { 191, 3, 8, 3, 0, -7 },
  { 194, 1, 8, 2, 0, -7 },
  { 195, 3, 3, 3, 0, -7 },
  { 197, 3, 1, 3, 0, 0 },
  { 198, 1, 2, 2, 1, -8 },
  { 199, 4, 5, 4, 0, -5 },
  { 202, 3, 7, 4, 1, -7 },
  { 205, 4, 5, 4, 0, -5 },
  { 208, 3, 7, 4, 1, -7 },
  { 211, 4, 5, 4, 0, -5 },
  { 214, 3, 7, 3, 0, -7 },
  { 217, 3, 7, 4, 1, -5 },
  { 220, 3, 7, 4, 1, -7 },
  { 223, 1, 7, 2, 0, -7 },
  { 224, 1, 9, 2, 0, -7 },
  { 226, 3, 7, 4, 1, -7 },
  { 229, 1, 7, 2, 0, -7 },
  { 230, 5, 5, 7, 1, -5 },
  { 234, 3, 5, 4, 1, -5 },
  { 236, 4, 5, 4, 0, -5 },
  { 239, 3, 7, 4, 1, -5 },
  { 242, 3, 7, 4, 1, -5 },
  { 245, 2, 5, 3, 1, -5 },
  { 247, 3, 5, 4, 0, -5 },
  { 249, 2, 6, 3, 0, -6 },
  { 251, 3, 5, 4, 1, -5 },
  { 253, 4, 5, 4, 0, -5 },
  { 256, 6, 5, 6, 0, -5 },
  { 260, 4, 5, 4, 0, -5 },
  { 263, 4, 7, 4, 0, -5 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 3, 9, 3, 0, -7 },
  { 274, 1, 8, 2, 0, -7 },
  { 275, 2, 9, 3, 0, -7 },
  { 278, 4, 2, 5, 1, -4 },
};

const GFXfont RobotoCondensed_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT9PT7B_H_
