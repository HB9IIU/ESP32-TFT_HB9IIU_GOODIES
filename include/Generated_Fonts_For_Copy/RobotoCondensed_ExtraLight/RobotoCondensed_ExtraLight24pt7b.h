#ifndef _ROBOTOCONDENSED_EXTRALIGHT24PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x80, 0xB6, 0xDA, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40,
  0x88, 0xFF, 0xC4, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x7F, 0xE2, 0x20,
  0x44, 0x08, 0x81, 0x10, 0x22, 0x00, 0x04, 0x02, 0x07, 0x84, 0x24, 0x0A,
  0x05, 0x02, 0x80, 0x60, 0x18, 0x03, 0x00, 0x60, 0x08, 0x06, 0x03, 0x01,
  0x40, 0xB0, 0x87, 0x80, 0x80, 0x40, 0x38, 0x02, 0x40, 0x21, 0x09, 0x08,
  0x88, 0x48, 0x42, 0x41, 0x24, 0x07, 0x20, 0x02, 0x00, 0x13, 0x81, 0x22,
  0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x20, 0x11, 0x00, 0x70, 0x1E, 0x04,
  0x40, 0x84, 0x10, 0x82, 0x20, 0x44, 0x05, 0x00, 0xC0, 0x38, 0x04, 0x85,
  0x10, 0xC1, 0x28, 0x15, 0x01, 0x90, 0x23, 0x0A, 0x3E, 0x20, 0xF8, 0x11,
  0x24, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x84, 0x44, 0x21, 0x10,
  0x88, 0x44, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48,
  0x80, 0x04, 0x01, 0x00, 0x43, 0x97, 0x1E, 0x03, 0x01, 0x20, 0x44, 0x21,
  0x80, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x55, 0x80, 0xF0, 0xC0, 0x04, 0x10,
  0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x00,
  0x1E, 0x10, 0x90, 0x48, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x14, 0x0A, 0x05, 0x04, 0x42, 0x1E, 0x00, 0x1B, 0x62, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x1E, 0x18, 0x44, 0x12, 0x02,
  0x80, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x7F, 0xC0, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x08, 0x04,
  0x02, 0x02, 0x1E, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x05, 0x02, 0xC2, 0x1E,
  0x00, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21,
  0x10, 0x44, 0x13, 0xFF, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F,
  0x40, 0x40, 0x40, 0x40, 0x40, 0xBC, 0xC2, 0x01, 0x01, 0x01, 0x01, 0x81,
  0x81, 0x81, 0x42, 0x3C, 0x0E, 0x30, 0x40, 0x40, 0x80, 0x80, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x20, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x42, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x05, 0x02, 0xC2, 0x3E,
  0x00, 0x1E, 0x11, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0xB1,
  0xCF, 0x20, 0x10, 0x08, 0x08, 0x04, 0x0C, 0x38, 0x00, 0x50, 0x00, 0x01,
  0x40, 0x10, 0x00, 0x01, 0x5E, 0x01, 0x02, 0x0C, 0x30, 0xC0, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00, 0x3C, 0x86, 0x0C,
  0x10, 0x20, 0x40, 0x82, 0x08, 0x10, 0x40, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x03, 0xF0, 0x06, 0x06, 0x06, 0x00, 0x82, 0x00, 0x42, 0x00, 0x11, 0x07,
  0x09, 0x04, 0x44, 0x84, 0x21, 0x44, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30,
  0x84, 0x18, 0x42, 0x0C, 0x21, 0x09, 0x10, 0x84, 0x88, 0xA4, 0x43, 0x9C,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x81, 0x00, 0x3F, 0x00, 0x04,
  0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x40, 0x88, 0x20, 0x84,
  0x10, 0x82, 0x3F, 0xE4, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0x80, 0x20, 0xFE,
  0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0xFE, 0x40, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0xFE, 0x00, 0x1F, 0x18, 0x24, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x14, 0x09, 0x86, 0x1E, 0x00, 0xFE, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x04, 0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x18, 0x24, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x04, 0x83, 0x1F, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x0A,
  0x04, 0x84, 0x3C, 0x00, 0x80, 0xD0, 0x12, 0x04, 0x41, 0x08, 0x41, 0x18,
  0x22, 0x04, 0x80, 0xB0, 0x19, 0x02, 0x10, 0x43, 0x08, 0x21, 0x02, 0x20,
  0x24, 0x04, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE8, 0x05, 0xA0, 0x16, 0x80, 0x59, 0x02, 0x64, 0x09, 0x90,
  0x46, 0x21, 0x18, 0x84, 0x61, 0x21, 0x84, 0x86, 0x12, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x04, 0x80, 0x38, 0x07, 0x00, 0xD0, 0x19, 0x03, 0x20, 0x62,
  0x0C, 0x41, 0x84, 0x30, 0xC6, 0x08, 0xC0, 0x98, 0x13, 0x01, 0x60, 0x2C,
  0x03, 0x80, 0x20, 0x1E, 0x18, 0x6C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x86, 0x1E,
  0x00, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81,
  0xBF, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1E,
  0x18, 0x6C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x0D, 0x86, 0x1F, 0x00, 0x60, 0x0C, 0x01,
  0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x3F,
  0x88, 0x22, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x40, 0x1F, 0x08,
  0x24, 0x05, 0x01, 0x40, 0x50, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x04,
  0x01, 0x80, 0x60, 0x14, 0x05, 0x82, 0x1F, 0x00, 0xFF, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x09, 0x86, 0x3E, 0x00, 0x80, 0x30, 0x06, 0x01, 0x20, 0x24,
  0x04, 0x80, 0x88, 0x21, 0x04, 0x20, 0x82, 0x20, 0x44, 0x08, 0x81, 0x20,
  0x14, 0x02, 0x80, 0x60, 0x04, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x50,
  0x48, 0x28, 0x24, 0x14, 0x12, 0x12, 0x09, 0x08, 0x84, 0x84, 0x44, 0x22,
  0x22, 0x12, 0x11, 0x09, 0x04, 0x84, 0x82, 0x81, 0x41, 0x40, 0xC0, 0xA0,
  0x60, 0x30, 0x30, 0x18, 0x08, 0x08, 0x00, 0x80, 0x68, 0x09, 0x02, 0x10,
  0x41, 0x10, 0x22, 0x02, 0x80, 0x60, 0x04, 0x01, 0x40, 0x28, 0x08, 0x82,
  0x10, 0x41, 0x10, 0x32, 0x02, 0x80, 0x20, 0x40, 0x14, 0x02, 0x20, 0x22,
  0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xFF, 0xC0, 0x10,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0xFF, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x27, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x4F, 0x10, 0x20, 0xA1, 0x44, 0x88, 0x91, 0x42,
  0x82, 0xFF, 0x80, 0x42, 0x10, 0x3E, 0x20, 0x90, 0x50, 0x20, 0x10, 0x08,
  0xFC, 0x82, 0x81, 0x40, 0xA0, 0x48, 0x63, 0xC8, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0xBC, 0x3E, 0x30, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x50, 0x4C, 0x21, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xF5,
  0x86, 0x81, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x02, 0x81, 0x61,
  0x8F, 0x40, 0x1E, 0x30, 0x90, 0x50, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x0C, 0x21, 0xE0, 0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E, 0xB0, 0xD0, 0x68, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x2C, 0x33, 0xE8, 0x04, 0x02,
  0x01, 0x61, 0x0F, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC7, 0xFF,
  0xC0, 0x01, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12,
  0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x88, 0x98, 0x90, 0xA0,
  0xE0, 0x90, 0x88, 0x88, 0x84, 0x82, 0x83, 0xFF, 0xFF, 0xC0, 0xBC, 0x79,
  0x85, 0x0A, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0xBC,
  0xC2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50,
  0x24, 0x21, 0xE0, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0xB0, 0xD0,
  0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x2C, 0x33, 0xC8,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x00, 0x3C, 0x43, 0x41, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01,
  0x01, 0x81, 0x43, 0x3E, 0x42, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x87, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x83, 0xC3, 0x7D, 0x81, 0x40, 0xA0, 0x48, 0x24, 0x22, 0x10, 0x88, 0x48,
  0x24, 0x0A, 0x06, 0x03, 0x00, 0x80, 0x82, 0x06, 0x0C, 0x24, 0x30, 0x91,
  0x42, 0x45, 0x09, 0x12, 0x44, 0x49, 0x0A, 0x24, 0x28, 0x50, 0xA1, 0x42,
  0x86, 0x04, 0x18, 0x10, 0x20, 0x81, 0x21, 0x10, 0x84, 0x81, 0x40, 0xC0,
  0x20, 0x30, 0x24, 0x12, 0x10, 0x88, 0x28, 0x10, 0x81, 0x40, 0xA0, 0x48,
  0x24, 0x22, 0x10, 0x88, 0x48, 0x24, 0x0A, 0x06, 0x03, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x70, 0x00, 0xFF, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x0F, 0xF8, 0x0C, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x86, 0x20, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x41, 0x81, 0xFF, 0xFF, 0xF0, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x40, 0x81, 0x08, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x30, 0x70,
  0x31, 0x06, 0x11, 0x41, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 3, 5, 6, 2, -18 },
  { 6, 11, 17, 12, 1, -17 },
  { 30, 9, 21, 12, 1, -19 },
  { 54, 13, 17, 16, 1, -17 },
  { 82, 11, 17, 13, 1, -17 },
  { 106, 1, 5, 4, 2, -18 },
  { 107, 4, 25, 7, 2, -19 },
  { 120, 4, 25, 7, 1, -19 },
  { 133, 10, 9, 10, 0, -17 },
  { 145, 10, 13, 12, 1, -15 },
  { 162, 2, 5, 5, 1, -2 },
  { 164, 4, 1, 6, 1, -8 },
  { 165, 1, 2, 5, 2, -2 },
  { 166, 6, 18, 8, 1, -17 },
  { 180, 9, 17, 12, 1, -17 },
  { 200, 5, 17, 12, 2, -17 },
  { 211, 10, 17, 12, 1, -17 },
  { 233, 9, 17, 12, 1, -17 },
  { 253, 10, 17, 12, 1, -17 },
  { 275, 8, 17, 12, 2, -17 },
  { 292, 8, 17, 12, 2, -17 },
  { 309, 9, 17, 12, 1, -17 },
  { 329, 9, 17, 12, 1, -17 },
  { 349, 9, 17, 12, 1, -17 },
  { 369, 2, 13, 4, 1, -13 },
  { 373, 2, 16, 4, 1, -13 },
  { 377, 8, 10, 11, 1, -13 },
  { 387, 8, 6, 12, 2, -11 },
  { 393, 9, 10, 11, 1, -13 },
  { 405, 7, 17, 9, 1, -17 },
  { 420, 17, 22, 19, 1, -17 },
  { 467, 11, 17, 13, 1, -17 },
  { 491, 9, 17, 13, 2, -17 },
  { 511, 10, 17, 14, 2, -17 },
  { 533, 10, 17, 14, 2, -17 },
  { 555, 9, 17, 12, 2, -17 },
  { 575, 9, 17, 12, 2, -17 },
  { 595, 10, 17, 14, 2, -17 },
  { 617, 11, 17, 15, 2, -17 },
  { 641, 1, 17, 6, 2, -17 },
  { 644, 9, 17, 12, 1, -17 },
  { 664, 11, 17, 13, 2, -17 },
  { 688, 8, 17, 11, 2, -17 },
  { 705, 14, 17, 18, 2, -17 },
  { 735, 11, 17, 15, 2, -17 },
  { 759, 10, 17, 14, 2, -17 },
  { 781, 10, 17, 13, 2, -17 },
  { 803, 10, 20, 14, 2, -17 },
  { 828, 10, 17, 14, 2, -17 },
  { 850, 10, 17, 12, 1, -17 },
  { 872, 11, 17, 13, 1, -17 },
  { 896, 10, 17, 14, 2, -17 },
  { 918, 11, 17, 13, 1, -17 },
  { 942, 17, 17, 19, 1, -17 },
  { 979, 11, 17, 13, 1, -17 },
  { 1003, 12, 17, 13, 0, -17 },
  { 1029, 10, 17, 13, 1, -17 },
  { 1051, 3, 24, 5, 2, -20 },
  { 1060, 7, 18, 8, 1, -17 },
  { 1076, 3, 24, 5, 0, -20 },
  { 1085, 7, 9, 9, 1, -17 },
  { 1093, 9, 1, 9, 0, 0 },
  { 1095, 4, 3, 7, 1, -18 },
  { 1097, 9, 13, 11, 1, -13 },
  { 1112, 8, 18, 12, 2, -18 },
  { 1130, 9, 13, 11, 1, -13 },
  { 1145, 9, 18, 12, 1, -18 },
  { 1166, 9, 13, 11, 1, -13 },
  { 1181, 6, 18, 7, 1, -18 },
  { 1195, 9, 18, 12, 1, -13 },
  { 1216, 8, 18, 12, 2, -18 },
  { 1234, 1, 18, 5, 2, -18 },
  { 1237, 4, 23, 5, -1, -18 },
  { 1249, 8, 18, 10, 2, -18 },
  { 1267, 1, 18, 5, 2, -18 },
  { 1270, 15, 13, 19, 2, -13 },
  { 1295, 8, 13, 12, 2, -13 },
  { 1308, 9, 13, 12, 1, -13 },
  { 1323, 8, 18, 12, 2, -13 },
  { 1341, 9, 18, 12, 1, -13 },
  { 1362, 5, 13, 7, 2, -13 },
  { 1371, 8, 13, 11, 1, -13 },
  { 1384, 5, 16, 7, 1, -16 },
  { 1394, 8, 13, 12, 2, -13 },
  { 1407, 9, 13, 10, 1, -13 },
  { 1422, 14, 13, 16, 1, -13 },
  { 1445, 9, 13, 10, 1, -13 },
  { 1460, 9, 18, 10, 1, -13 },
  { 1481, 9, 13, 10, 1, -13 },
  { 1496, 6, 24, 7, 1, -19 },
  { 1514, 1, 20, 5, 2, -17 },
  { 1517, 6, 24, 7, 0, -19 },
  { 1535, 11, 4, 14, 2, -9 },
};

const GFXfont RobotoCondensed_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT24PT7B_H_
