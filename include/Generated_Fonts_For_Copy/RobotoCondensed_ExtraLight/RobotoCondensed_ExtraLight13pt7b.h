#ifndef _ROBOTOCONDENSED_EXTRALIGHT13PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight13pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0x80, 0x74, 0x04, 0x93, 0x8A, 0x28, 0xA7, 0x92, 0x00, 0x03,
  0xA3, 0x08, 0x30, 0x41, 0x8A, 0x88, 0xC1, 0x52, 0xA6, 0x81, 0x05, 0x8C,
  0xA9, 0x0C, 0x62, 0x49, 0x18, 0x42, 0x89, 0xA2, 0xF8, 0x40, 0x1A, 0xAA,
  0xA9, 0x00, 0x89, 0x12, 0x49, 0x25, 0x28, 0x01, 0x1C, 0x64, 0x80, 0x01,
  0x1C, 0x42, 0x00, 0x58, 0x40, 0x80, 0x11, 0x22, 0x22, 0x44, 0x48, 0x74,
  0xA3, 0x18, 0xC6, 0x32, 0x70, 0x64, 0x92, 0x49, 0x20, 0x74, 0x82, 0x21,
  0x11, 0x10, 0xF0, 0x74, 0x82, 0x22, 0x08, 0x31, 0x70, 0x11, 0x8C, 0xA9,
  0x4B, 0xC2, 0x10, 0x74, 0x21, 0xE0, 0x86, 0x31, 0x70, 0x64, 0x21, 0xE8,
  0xC6, 0x31, 0x70, 0x78, 0x84, 0x22, 0x11, 0x08, 0x00, 0x74, 0x63, 0x17,
  0x4A, 0x31, 0xF0, 0x69, 0x99, 0x97, 0x11, 0x60, 0x82, 0x40, 0x05, 0x80,
  0x16, 0x86, 0x10, 0x66, 0x86, 0x16, 0x80, 0xE1, 0x12, 0x44, 0x00, 0x40,
  0x3E, 0x20, 0xA0, 0x53, 0x9A, 0x4D, 0x26, 0x93, 0x49, 0xBF, 0x40, 0x10,
  0x07, 0x80, 0x10, 0x60, 0xA1, 0x44, 0x8F, 0x91, 0x22, 0x82, 0xF4, 0x63,
  0x1F, 0x46, 0x31, 0xF0, 0x7A, 0x28, 0x60, 0x82, 0x08, 0x62, 0x78, 0xF2,
  0x28, 0x61, 0x86, 0x18, 0x62, 0xF0, 0xF4, 0x21, 0x0E, 0x42, 0x10, 0xF0,
  0xF4, 0x21, 0x0E, 0x42, 0x10, 0x80, 0x7A, 0x18, 0x60, 0x8A, 0x18, 0x61,
  0x78, 0x86, 0x18, 0x61, 0xF6, 0x18, 0x61, 0x84, 0xFF, 0x80, 0x01, 0x11,
  0x11, 0x99, 0xE0, 0x8A, 0x49, 0x28, 0xE2, 0x89, 0x22, 0x84, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xF0, 0x81, 0x83, 0xC3, 0xC5, 0xA5, 0xA5, 0xA9, 0x99,
  0x91, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE1, 0x84, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x78, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x80, 0x7A, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0x20, 0x40, 0xF2, 0x28, 0x62, 0xF2, 0x48, 0xA2,
  0x84, 0x74, 0x61, 0x07, 0x06, 0x31, 0x70, 0x78, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x84, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x82, 0x89, 0x12, 0x24,
  0x85, 0x0A, 0x18, 0x10, 0x00, 0x53, 0x14, 0xC9, 0x2A, 0x52, 0x94, 0xA3,
  0x30, 0x84, 0x21, 0x00, 0x45, 0x12, 0x8A, 0x10, 0xA2, 0x91, 0x84, 0x84,
  0x89, 0x21, 0x43, 0x02, 0x04, 0x08, 0x10, 0x78, 0x44, 0x42, 0x21, 0x10,
  0xF0, 0xAA, 0xAA, 0xAA, 0x80, 0x04, 0x44, 0x22, 0x21, 0x10, 0x55, 0x55,
  0x55, 0x40, 0x5A, 0xD0, 0x70, 0x90, 0xF1, 0x1F, 0x99, 0xE0, 0x04, 0x21,
  0xE8, 0xC6, 0x31, 0x8B, 0x80, 0x78, 0x88, 0x88, 0x70, 0x01, 0x17, 0x99,
  0x99, 0x96, 0x79, 0xF8, 0x88, 0x70, 0x34, 0x44, 0x44, 0x44, 0x44, 0x69,
  0x99, 0x99, 0x71, 0x17, 0x08, 0x8F, 0x99, 0x99, 0x90, 0x9F, 0xC0, 0x20,
  0x12, 0x49, 0x24, 0x9C, 0x08, 0x89, 0xAC, 0xCA, 0x91, 0xFF, 0xC0, 0x77,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x00, 0x79, 0x99, 0x99, 0x00, 0x74, 0x63,
  0x18, 0xC5, 0xC0, 0x74, 0x63, 0x18, 0xC7, 0xD0, 0x80, 0x00, 0x69, 0x99,
  0x99, 0x71, 0x10, 0x72, 0x49, 0x00, 0xE9, 0x86, 0x11, 0xE0, 0x49, 0x24,
  0x92, 0x20, 0x09, 0x99, 0x99, 0x60, 0x02, 0x52, 0xA5, 0x10, 0x80, 0x13,
  0x26, 0xCD, 0x6A, 0xC9, 0x90, 0x00, 0x4A, 0x8C, 0x43, 0x2A, 0x20, 0x8A,
  0x52, 0xA5, 0x18, 0x84, 0x22, 0x00, 0x72, 0x24, 0x48, 0xE0, 0x12, 0x22,
  0x24, 0xC4, 0x22, 0x22, 0x10, 0xFF, 0xE0, 0x89, 0x24, 0x89, 0x49, 0x28,
  0xE4, 0x60,
};

const GFXglyph RobotoCondensed_ExtraLight13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -10 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 5, 11, 6, 1, -10 },
  { 18, 7, 9, 8, 1, -9 },
  { 26, 6, 9, 7, 1, -9 },
  { 33, 1, 3, 2, 1, -10 },
  { 34, 2, 13, 4, 1, -10 },
  { 38, 3, 13, 4, 0, -10 },
  { 43, 5, 5, 5, 0, -9 },
  { 47, 5, 6, 6, 1, -7 },
  { 51, 2, 3, 2, 0, -1 },
  { 52, 3, 1, 3, 0, -5 },
  { 53, 1, 1, 3, 1, -1 },
  { 54, 4, 10, 5, 0, -9 },
  { 59, 5, 9, 6, 1, -9 },
  { 65, 3, 9, 6, 1, -9 },
  { 69, 5, 9, 6, 1, -9 },
  { 75, 5, 9, 6, 1, -9 },
  { 81, 5, 9, 6, 1, -9 },
  { 87, 5, 9, 6, 1, -9 },
  { 93, 5, 9, 6, 1, -9 },
  { 99, 5, 9, 6, 1, -9 },
  { 105, 5, 9, 6, 1, -9 },
  { 111, 4, 9, 6, 1, -9 },
  { 116, 1, 7, 2, 1, -7 },
  { 117, 2, 9, 2, 0, -7 },
  { 120, 4, 5, 6, 1, -7 },
  { 123, 4, 2, 6, 1, -5 },
  { 124, 4, 5, 6, 1, -7 },
  { 127, 4, 9, 5, 1, -9 },
  { 132, 9, 12, 10, 1, -9 },
  { 146, 7, 9, 7, 0, -9 },
  { 154, 5, 9, 7, 1, -9 },
  { 160, 6, 9, 7, 1, -9 },
  { 167, 6, 9, 7, 1, -9 },
  { 174, 5, 9, 7, 1, -9 },
  { 180, 5, 9, 6, 1, -9 },
  { 186, 6, 9, 8, 1, -9 },
  { 193, 6, 9, 8, 1, -9 },
  { 200, 1, 9, 3, 1, -9 },
  { 202, 4, 9, 6, 1, -9 },
  { 207, 6, 9, 7, 1, -9 },
  { 214, 5, 9, 6, 1, -9 },
  { 220, 8, 9, 10, 1, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 6, 9, 8, 1, -9 },
  { 243, 5, 9, 7, 1, -9 },
  { 249, 6, 11, 8, 1, -9 },
  { 258, 6, 9, 7, 1, -9 },
  { 265, 5, 9, 7, 1, -9 },
  { 271, 6, 9, 7, 0, -9 },
  { 278, 5, 9, 8, 1, -9 },
  { 284, 7, 9, 7, 0, -9 },
  { 292, 10, 9, 10, 0, -9 },
  { 304, 6, 9, 7, 0, -9 },
  { 311, 7, 9, 7, 0, -9 },
  { 319, 5, 9, 7, 1, -9 },
  { 325, 2, 13, 3, 1, -11 },
  { 329, 4, 10, 4, 0, -9 },
  { 334, 2, 13, 3, 0, -11 },
  { 338, 3, 5, 5, 1, -9 },
  { 340, 5, 1, 5, 0, 0 },
  { 341, 2, 2, 4, 1, -10 },
  { 342, 4, 7, 6, 1, -7 },
  { 346, 5, 10, 6, 1, -10 },
  { 353, 4, 7, 6, 1, -7 },
  { 357, 4, 10, 6, 1, -10 },
  { 362, 4, 7, 6, 1, -7 },
  { 366, 4, 10, 4, 0, -10 },
  { 371, 4, 10, 6, 1, -7 },
  { 376, 4, 10, 6, 1, -10 },
  { 381, 1, 10, 3, 1, -10 },
  { 383, 3, 13, 3, -1, -10 },
  { 388, 4, 10, 6, 1, -10 },
  { 393, 1, 10, 3, 1, -10 },
  { 395, 8, 7, 10, 1, -7 },
  { 402, 4, 7, 6, 1, -7 },
  { 406, 5, 7, 6, 1, -7 },
  { 411, 5, 10, 6, 1, -7 },
  { 418, 4, 10, 6, 1, -7 },
  { 423, 3, 7, 4, 1, -7 },
  { 426, 4, 7, 6, 1, -7 },
  { 430, 3, 9, 4, 0, -9 },
  { 434, 4, 7, 6, 1, -7 },
  { 438, 5, 7, 6, 0, -7 },
  { 443, 7, 7, 9, 1, -7 },
  { 450, 5, 7, 6, 0, -7 },
  { 455, 5, 10, 5, 0, -7 },
  { 462, 4, 7, 6, 1, -7 },
  { 466, 4, 13, 4, 0, -10 },
  { 473, 1, 11, 3, 1, -9 },
  { 475, 3, 13, 4, 0, -10 },
  { 480, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraLight13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT13PT7B_H_
