#ifndef _ROBOTOCONDENSED_EXTRALIGHT23PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x80, 0xB6, 0xDA, 0x08, 0x82, 0x20, 0x88, 0x22, 0x11,
  0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x42, 0x23, 0xFF, 0x22, 0x08, 0x82,
  0x20, 0x88, 0x22, 0x00, 0x08, 0x04, 0x07, 0x84, 0x24, 0x12, 0x05, 0x02,
  0x80, 0x40, 0x18, 0x03, 0x00, 0x60, 0x10, 0x06, 0x03, 0x01, 0x40, 0xB0,
  0x87, 0x81, 0x00, 0x80, 0x30, 0x02, 0x40, 0x21, 0x11, 0x08, 0x88, 0x48,
  0x42, 0x41, 0x24, 0x06, 0x40, 0x02, 0x00, 0x23, 0x01, 0x24, 0x12, 0x10,
  0x90, 0x88, 0x84, 0x44, 0x20, 0x12, 0x00, 0x60, 0x1C, 0x04, 0x40, 0x88,
  0x21, 0x02, 0x20, 0x48, 0x0B, 0x00, 0x80, 0x28, 0x09, 0x01, 0x11, 0x41,
  0x28, 0x15, 0x03, 0x10, 0x22, 0x0A, 0x3E, 0x40, 0xF8, 0x12, 0x24, 0x48,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x44, 0x22, 0x10, 0x88, 0x44, 0x22,
  0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x80, 0x08, 0x04, 0x02,
  0x1D, 0x31, 0xE0, 0x60, 0x48, 0x44, 0x21, 0x00, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x56,
  0x80, 0xF0, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x20, 0x82, 0x00, 0x1C, 0x11, 0x10, 0x48, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x09, 0x04, 0x44, 0x1C,
  0x00, 0x1B, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x3C, 0x21, 0x90, 0x50, 0x28, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x7F, 0x80, 0x1E, 0x10, 0x90, 0x48,
  0x18, 0x08, 0x04, 0x04, 0x04, 0x1C, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x05,
  0x04, 0xC2, 0x1E, 0x00, 0x02, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x81,
  0x20, 0x88, 0x22, 0x10, 0x88, 0x23, 0xFF, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x80, 0xBC, 0xC2, 0x01, 0x01,
  0x01, 0x01, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x0E, 0x08, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x79, 0x42, 0xC1, 0x40, 0x60, 0x30, 0x18, 0x0A, 0x05, 0x04,
  0x42, 0x1E, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x00, 0x1E,
  0x31, 0x90, 0x48, 0x18, 0x0A, 0x05, 0x04, 0x46, 0x1C, 0x31, 0x90, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x82, 0x3E, 0x00, 0x1C, 0x31, 0x10, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x41, 0xA1, 0x4F, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x0C, 0x38, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x68, 0x01, 0x06,
  0x18, 0x60, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x38, 0x8A, 0x0C,
  0x10, 0x20, 0x40, 0x82, 0x08, 0x20, 0x40, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x03, 0xF0, 0x0C, 0x08, 0x10, 0x04, 0x20, 0x02, 0x20, 0x02, 0x41, 0xC1,
  0x42, 0x21, 0x44, 0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x88, 0x21,
  0x88, 0x21, 0x84, 0x62, 0x44, 0x62, 0x43, 0x9C, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x04, 0x01, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x24, 0x04, 0x41, 0x08, 0x21, 0x04, 0x11, 0x02, 0x3F, 0xC4, 0x08,
  0x80, 0xA0, 0x14, 0x02, 0x80, 0x20, 0xFC, 0x41, 0xA0, 0x50, 0x28, 0x14,
  0x0A, 0x05, 0x06, 0xFC, 0x41, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02,
  0xFE, 0x00, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x28, 0x09, 0x04, 0x3E, 0x00,
  0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x0C, 0xFC, 0x00, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x00, 0x1E, 0x18, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x82, 0x1F, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xFF, 0xFF,
  0x80, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80, 0xA0, 0x48, 0x32, 0x08, 0x84,
  0x22, 0x09, 0x02, 0x40, 0xB0, 0x32, 0x08, 0x42, 0x10, 0x82, 0x20, 0x48,
  0x12, 0x02, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3A, 0x02, 0xD0, 0x16, 0x40, 0xB2, 0x09, 0x90, 0x4C,
  0x42, 0x62, 0x23, 0x11, 0x18, 0x48, 0xC2, 0x86, 0x14, 0x30, 0x41, 0x82,
  0x08, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x18, 0x86, 0x21, 0x84,
  0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x58, 0x0E, 0x03, 0x80, 0x40, 0x3E,
  0x10, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x04, 0x3E, 0x00, 0xFE, 0x40, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x7F, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x14, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80,
  0x50, 0x11, 0x04, 0x1F, 0x00, 0x10, 0x01, 0x00, 0x10, 0xFE, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x88, 0x42, 0x08,
  0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0x80, 0x1E, 0x18, 0x64, 0x0A, 0x01,
  0x80, 0x50, 0x04, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x08, 0x01, 0x80, 0x60,
  0x14, 0x05, 0x82, 0x1F, 0x00, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x82, 0x3E, 0x00, 0x80,
  0x30, 0x0A, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x21, 0x08, 0x21, 0x04,
  0x20, 0x44, 0x09, 0x01, 0x20, 0x14, 0x03, 0x00, 0x60, 0x04, 0x00, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x42, 0x42, 0x42, 0x42,
  0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x24, 0x24, 0x24, 0x24, 0x24, 0x28,
  0x14, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x80, 0x50, 0x24,
  0x08, 0x84, 0x21, 0x04, 0x80, 0xA0, 0x30, 0x0C, 0x03, 0x01, 0x20, 0x48,
  0x21, 0x08, 0x24, 0x09, 0x01, 0x80, 0x40, 0x40, 0x24, 0x02, 0x20, 0x42,
  0x04, 0x10, 0x81, 0x08, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xFF, 0xC0, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x38, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41,
  0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x78, 0x10, 0xC2, 0x92, 0x49, 0x18, 0x61, 0xFF, 0x42, 0x20,
  0x3E, 0x43, 0x81, 0x81, 0x01, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x43, 0x7D,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x3E, 0x43, 0x41, 0x81, 0x80, 0x80,
  0x80, 0x80, 0x81, 0x41, 0x43, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D,
  0x3C, 0x43, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x41, 0x3E,
  0x1C, 0x82, 0x10, 0x41, 0x0F, 0x90, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x00, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x43, 0x3D, 0x01, 0x01, 0x01, 0x41, 0x3E, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x2F, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x8F,
  0xFF, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xE0,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC2, 0x89, 0x22, 0x87, 0x09, 0x12,
  0x22, 0x42, 0x85, 0x04, 0xFF, 0xFF, 0xC0, 0xBC, 0x7B, 0x0A, 0x38, 0x30,
  0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08,
  0x18, 0x20, 0x60, 0x81, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0x1E, 0x30, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xA0, 0x98, 0x43, 0xC0, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01,
  0x01, 0x01, 0x01, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x88, 0x3C, 0x42, 0x81,
  0x80, 0x40, 0x38, 0x04, 0x02, 0x01, 0x81, 0x42, 0x3C, 0x20, 0x82, 0x3E,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0xC0, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1B, 0xD0, 0x81, 0x81, 0x82, 0x42,
  0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x82, 0x0C, 0x10, 0x61,
  0x42, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x22, 0x45, 0x14, 0x28, 0xA1, 0x83,
  0x04, 0x18, 0x20, 0x80, 0x81, 0x42, 0x44, 0x24, 0x18, 0x18, 0x18, 0x28,
  0x24, 0x42, 0x42, 0x81, 0x81, 0x81, 0x82, 0x42, 0x42, 0x44, 0x24, 0x24,
  0x24, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFF, 0x02, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0xFF, 0x08, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x84, 0x20, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x10, 0x40, 0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x03, 0x18, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x8C, 0x00,
  0x70, 0x62, 0x18, 0x46, 0x0E,
};

const GFXglyph RobotoCondensed_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 3, 5, 6, 2, -17 },
  { 6, 10, 17, 11, 1, -17 },
  { 28, 9, 21, 11, 1, -19 },
  { 52, 13, 17, 15, 1, -17 },
  { 80, 11, 17, 12, 1, -17 },
  { 104, 1, 5, 4, 1, -17 },
  { 105, 4, 23, 6, 2, -18 },
  { 117, 4, 23, 7, 1, -18 },
  { 129, 9, 9, 10, 0, -17 },
  { 140, 9, 13, 11, 1, -14 },
  { 155, 2, 5, 4, 1, -2 },
  { 157, 4, 1, 6, 1, -8 },
  { 158, 1, 1, 5, 2, -1 },
  { 159, 6, 18, 8, 1, -17 },
  { 173, 9, 17, 11, 1, -17 },
  { 193, 5, 17, 11, 2, -17 },
  { 204, 9, 17, 11, 1, -17 },
  { 224, 9, 17, 11, 1, -17 },
  { 244, 10, 17, 11, 1, -17 },
  { 266, 8, 17, 11, 2, -17 },
  { 283, 9, 17, 11, 1, -17 },
  { 303, 9, 17, 11, 1, -17 },
  { 323, 9, 17, 11, 1, -17 },
  { 343, 9, 17, 11, 1, -17 },
  { 363, 2, 12, 4, 1, -12 },
  { 366, 2, 15, 4, 1, -12 },
  { 370, 8, 9, 10, 1, -12 },
  { 379, 8, 5, 11, 2, -10 },
  { 384, 8, 9, 10, 1, -12 },
  { 393, 7, 17, 9, 1, -17 },
  { 408, 16, 21, 18, 1, -16 },
  { 450, 11, 17, 12, 1, -17 },
  { 474, 9, 17, 12, 2, -17 },
  { 494, 10, 17, 13, 2, -17 },
  { 516, 10, 17, 13, 2, -17 },
  { 538, 9, 17, 12, 2, -17 },
  { 558, 9, 17, 11, 2, -17 },
  { 578, 10, 17, 14, 2, -17 },
  { 600, 10, 17, 14, 2, -17 },
  { 622, 1, 17, 6, 2, -17 },
  { 625, 8, 17, 11, 1, -17 },
  { 642, 10, 17, 13, 2, -17 },
  { 664, 8, 17, 11, 2, -17 },
  { 681, 13, 17, 17, 2, -17 },
  { 709, 10, 17, 14, 2, -17 },
  { 731, 10, 17, 13, 2, -17 },
  { 753, 9, 17, 12, 2, -17 },
  { 773, 11, 20, 13, 1, -17 },
  { 801, 10, 17, 13, 2, -17 },
  { 823, 10, 17, 12, 1, -17 },
  { 845, 10, 17, 12, 1, -17 },
  { 867, 9, 17, 13, 2, -17 },
  { 887, 11, 17, 12, 1, -17 },
  { 911, 16, 17, 18, 1, -17 },
  { 945, 10, 17, 12, 1, -17 },
  { 967, 12, 17, 12, 0, -17 },
  { 993, 10, 17, 12, 1, -17 },
  { 1015, 3, 23, 5, 2, -19 },
  { 1024, 6, 18, 8, 1, -17 },
  { 1038, 3, 23, 5, 0, -19 },
  { 1047, 6, 8, 9, 1, -17 },
  { 1053, 8, 1, 9, 0, 0 },
  { 1054, 4, 3, 6, 1, -17 },
  { 1056, 8, 12, 11, 1, -12 },
  { 1068, 8, 18, 11, 2, -18 },
  { 1086, 8, 12, 10, 1, -12 },
  { 1098, 8, 18, 11, 1, -18 },
  { 1116, 8, 12, 10, 1, -12 },
  { 1128, 6, 18, 7, 1, -18 },
  { 1142, 8, 17, 11, 1, -12 },
  { 1159, 7, 18, 11, 2, -18 },
  { 1175, 1, 16, 5, 2, -16 },
  { 1177, 4, 21, 5, -1, -16 },
  { 1188, 7, 18, 10, 2, -18 },
  { 1204, 1, 18, 5, 2, -18 },
  { 1207, 14, 12, 18, 2, -12 },
  { 1228, 7, 12, 11, 2, -12 },
  { 1239, 9, 12, 11, 1, -12 },
  { 1253, 8, 17, 11, 2, -12 },
  { 1270, 8, 17, 11, 1, -12 },
  { 1287, 4, 12, 7, 2, -12 },
  { 1293, 8, 12, 10, 1, -12 },
  { 1305, 6, 15, 7, 0, -15 },
  { 1317, 7, 12, 11, 2, -12 },
  { 1328, 8, 12, 10, 1, -12 },
  { 1340, 13, 12, 15, 1, -12 },
  { 1360, 8, 12, 10, 1, -12 },
  { 1372, 8, 17, 10, 1, -12 },
  { 1389, 8, 12, 10, 1, -12 },
  { 1401, 6, 23, 7, 1, -18 },
  { 1419, 1, 20, 5, 2, -17 },
  { 1422, 6, 23, 7, 0, -18 },
  { 1440, 10, 4, 14, 2, -9 },
};

const GFXfont RobotoCondensed_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT23PT7B_H_
