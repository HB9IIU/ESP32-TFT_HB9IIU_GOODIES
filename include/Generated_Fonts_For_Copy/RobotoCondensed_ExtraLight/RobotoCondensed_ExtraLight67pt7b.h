#ifndef _ROBOTOCONDENSED_EXTRALIGHT67PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0xFF, 0x60, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x03, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xC0, 0x18, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x80, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x0E, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x81,
  0xC0, 0x00, 0x1F, 0xF0, 0x18, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x7E, 0x00, 0x00, 0x38, 0x1F, 0xF8, 0x00,
  0x03, 0x03, 0xC3, 0x80, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x06, 0x07, 0x00,
  0xE0, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x01, 0x80,
  0xE0, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x70, 0x0C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0xE0, 0x1C, 0x00, 0xC7, 0x00, 0x38,
  0x03, 0x1C, 0x00, 0xE0, 0x0C, 0x60, 0x01, 0xC0, 0x33, 0x80, 0x03, 0x80,
  0xCE, 0x00, 0x07, 0x07, 0x30, 0x00, 0x1C, 0x18, 0xC0, 0x00, 0x38, 0x63,
  0x00, 0x00, 0x73, 0x8C, 0x00, 0x00, 0xEC, 0x30, 0x00, 0x03, 0xF0, 0xE0,
  0x00, 0x07, 0xC3, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0xF0, 0x38, 0x00, 0x1E, 0xE0, 0xF0, 0x00, 0xF1, 0xC1, 0xE0, 0x0F,
  0x87, 0x03, 0xFF, 0xF8, 0x0E, 0x03, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x18, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x0E, 0x00, 0xFC, 0x03, 0x00,
  0xFF, 0xE0, 0xC1, 0xFC, 0x7F, 0x31, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0xC6, 0x31, 0x9C, 0xE7, 0x39, 0x9D, 0xCE, 0x20, 0xFF, 0xFF, 0xFF,
  0xC0, 0x2F, 0xFF, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x80,
  0xE0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08, 0x03,
  0xC0, 0x7E, 0x0F, 0xB1, 0xF1, 0xFE, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x07, 0x81, 0xC0, 0x01, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x70,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x03, 0x80, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x80, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x18, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x7F, 0x00, 0x39, 0xFF, 0xC0, 0x37, 0xFF, 0xF0, 0x3E,
  0x00, 0xF8, 0x38, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x18, 0x3F, 0xF8, 0x0C, 0x7E,
  0x7E, 0x06, 0x78, 0x07, 0x87, 0x70, 0x00, 0xE3, 0xF0, 0x00, 0x39, 0xF0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0xC0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x0F, 0xCF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x0F,
  0x80, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07,
  0x80, 0x03, 0x80, 0xF8, 0x03, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0xCE, 0x00, 0x03, 0x63, 0x80, 0x03, 0xB0, 0xE0, 0x03, 0x98, 0x78,
  0x03, 0x8C, 0x1F, 0x9F, 0x8E, 0x03, 0xFF, 0x87, 0x00, 0x7E, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x23, 0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xF7, 0xFC,
  0xC0, 0x08, 0x78, 0xF9, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C,
  0x70, 0xC1, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x38, 0x01, 0xC3,
  0x80, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x0C,
  0x18, 0x00, 0x3E, 0x3E, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0xC3,
  0x00, 0x07, 0x00, 0x70, 0x01, 0x8C, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x19, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x66, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x98, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x1B, 0x80, 0x1C, 0x00, 0x18, 0x00, 0x6E, 0x00, 0x70,
  0x00, 0x60, 0x01, 0xB8, 0x01, 0x80, 0x01, 0x80, 0x06, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x1B, 0x00, 0x18, 0x00, 0x18, 0x00, 0x6C, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xB0, 0x03, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x1B, 0x00, 0x38, 0x00, 0x30, 0x00, 0x6C, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xB0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0xC0, 0x0E, 0x00, 0x0C, 0x00,
  0x33, 0x00, 0x38, 0x00, 0x70, 0x00, 0xCE, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x38, 0x01, 0x80, 0x07, 0x00, 0x18, 0x60, 0x06, 0x00, 0x3C, 0x00, 0x61,
  0x80, 0x1C, 0x01, 0xB8, 0x03, 0x06, 0x00, 0x30, 0x0E, 0x60, 0x1C, 0x1C,
  0x00, 0xE0, 0x71, 0xC0, 0xE0, 0x70, 0x01, 0xFF, 0x83, 0xCF, 0x00, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x7F, 0x03, 0x00,
  0x01, 0xE0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x78, 0x30, 0x00, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x7C, 0x30, 0x00,
  0x07, 0x8C, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x3E, 0x30, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x07,
  0xF0, 0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x7C, 0x0C, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x1E, 0x01, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x0F, 0x0C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x30, 0x1E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x18, 0xEE, 0x00, 0x00, 0xCE,
  0x70, 0x00, 0x06, 0x71, 0xC0, 0x00, 0x37, 0x07, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x1E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x60, 0x00, 0x00, 0x01,
  0xBD, 0xC0, 0x00, 0x00, 0x0E, 0xF7, 0x00, 0x00, 0x00, 0x3B, 0xCC, 0x00,
  0x00, 0x00, 0xCF, 0x38, 0x00, 0x00, 0x07, 0x3C, 0x60, 0x00, 0x00, 0x18,
  0xF1, 0x80, 0x00, 0x00, 0x63, 0xC7, 0x00, 0x00, 0x03, 0x8F, 0x0C, 0x00,
  0x00, 0x0C, 0x3C, 0x30, 0x00, 0x00, 0x70, 0xF0, 0xE0, 0x00, 0x01, 0xC3,
  0xC1, 0x80, 0x00, 0x06, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x1C, 0x00,
  0x00, 0xE0, 0xF0, 0x30, 0x00, 0x03, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0F,
  0x03, 0x80, 0x00, 0x60, 0x3C, 0x06, 0x00, 0x01, 0x80, 0xF0, 0x1C, 0x00,
  0x0E, 0x03, 0xC0, 0x30, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x00, 0xC0, 0x3C,
  0x03, 0x80, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x18, 0x00,
  0x60, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xF0,
  0x03, 0x80, 0x70, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x18, 0x06,
  0x00, 0x3C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0xC0, 0x03, 0xC0,
  0x03, 0x03, 0x00, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x00, 0x18, 0x60,
  0x00, 0xF0, 0x00, 0x61, 0x80, 0x03, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x00,
  0x03, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7D, 0xC0, 0x00,
  0x03, 0xE6, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x07,
  0xC7, 0x00, 0x00, 0x3E, 0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0x7C, 0x0C, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x01, 0x80,
  0x00, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x3E, 0x01, 0xC0, 0x01,
  0xF0, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0xE0,
  0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x70, 0x07, 0xC0, 0x03,
  0x80, 0x3E, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x70, 0x0F, 0x80, 0x01, 0xC0,
  0x7C, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x38, 0x1F, 0x00, 0x00, 0xE0, 0xF8,
  0x00, 0x07, 0x07, 0xC0, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0x03, 0x8F, 0x80, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x01,
  0x9F, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0C, 0x00,
  0x3F, 0xC3, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x3C, 0xC0, 0x00,
  0x1E, 0x30, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0xF8, 0x0C,
  0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x01, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x60, 0x00,
  0x0E, 0x30, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x70, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x03, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0x81,
  0x80, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0x80, 0x01, 0xC3,
  0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xC3,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x67, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x66, 0x00, 0x00, 0x76, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x07, 0x18, 0x01,
  0x87, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0E, 0x03, 0x01, 0x81, 0xC0,
  0x60, 0x60, 0x1C, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x39, 0xC0, 0x06,
  0x70, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0x06,
  0x1E, 0x00, 0x06, 0x3C, 0x00, 0x06, 0x38, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x1E, 0x60, 0x00, 0x1E,
  0x70, 0x00, 0x36, 0x38, 0x00, 0xE6, 0x3C, 0x03, 0xC6, 0x1F, 0xFF, 0x87,
  0x0F, 0xFE, 0x07, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE7, 0xFF, 0xE0, 0xEF, 0x00, 0xF0,
  0xEC, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x0C,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x38,
  0xFC, 0x00, 0x38, 0xCF, 0x00, 0xF0, 0xC7, 0xFF, 0xE0, 0xC1, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x06, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x0C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1F,
  0x01, 0x81, 0xFF, 0xC3, 0x0F, 0xFF, 0xC6, 0x3C, 0x01, 0xCC, 0x70, 0x01,
  0xD9, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x80, 0x00,
  0x73, 0x00, 0x00, 0xE7, 0x00, 0x03, 0xC7, 0x00, 0x0D, 0x8F, 0x00, 0x73,
  0x0F, 0xFF, 0xC6, 0x07, 0xFF, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x78, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x0E,
  0x07, 0x80, 0x3C, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xFF, 0xFE,
  0x7F, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x0C, 0x3F, 0xFF, 0x18, 0xF0, 0x07,
  0x31, 0xC0, 0x07, 0x67, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07,
  0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6E, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x36,
  0x3C, 0x01, 0xCC, 0x3F, 0xFF, 0x18, 0x1F, 0xFC, 0x30, 0x07, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x63, 0x00, 0x01, 0xC7, 0x00,
  0x07, 0x07, 0x80, 0x1E, 0x07, 0xE1, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x38, 0x3F, 0xF0, 0xE3, 0xFF, 0xE3,
  0x9E, 0x03, 0xCE, 0x60, 0x07, 0xBB, 0x00, 0x0E, 0xF8, 0x00, 0x1B, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0xEF, 0xF6, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0xCC,
  0xF8, 0xFF, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x77, 0xE0, 0x00,
  0xFD, 0xC0, 0x01, 0xF1, 0xC0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x30, 0x3F,
  0xF0, 0x07, 0xFE, 0x0C, 0x3F, 0xFE, 0x07, 0xFF, 0xE3, 0x1C, 0x03, 0xC3,
  0xC0, 0x3C, 0xCE, 0x00, 0x71, 0xC0, 0x07, 0x33, 0x00, 0x0E, 0x60, 0x00,
  0xED, 0x80, 0x01, 0xB0, 0x00, 0x3B, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x1E, 0x03, 0x83, 0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xE0,
  0x3C, 0xE6, 0x00, 0x7B, 0xB0, 0x00, 0xEF, 0x80, 0x01, 0xBE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0xFF, 0xE0, 0xEF, 0x00,
  0xF0, 0xEC, 0x00, 0x38, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x1C, 0xF8, 0x00,
  0x38, 0xFC, 0x00, 0x38, 0xEF, 0x00, 0xF0, 0xE7, 0xFF, 0xE0, 0xE1, 0xFF,
  0xC0, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x0C, 0x3F, 0xFF, 0x18, 0xF0, 0x07, 0x31, 0xC0, 0x07, 0x67, 0x00, 0x03,
  0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xCC, 0x00, 0x03,
  0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x36, 0x3C, 0x01, 0xCC, 0x3F, 0xFF, 0x18,
  0x1F, 0xFC, 0x30, 0x07, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x87, 0xFE, 0x3F,
  0xF9, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x03,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C,
  0xE0, 0x00, 0x19, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x3C, 0x01, 0xF0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3E, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xCE, 0x00, 0x3B, 0x1E, 0x01, 0xCC,
  0x7F, 0xFE, 0x30, 0x7F, 0xF0, 0xC0, 0x7C, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0x70, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x60, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0xE0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x1E, 0x00, 0x06, 0x60, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x03,
  0xE0, 0x00, 0xE7, 0x00, 0x0D, 0xC0, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x0C,
  0x30, 0x01, 0xCC, 0x00, 0x70, 0xE0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x18,
  0xE0, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x18, 0x18, 0x03, 0x86, 0x00, 0xE0,
  0x70, 0x0C, 0x1C, 0x03, 0x81, 0xC0, 0x30, 0x30, 0x0E, 0x07, 0x00, 0xC0,
  0xC0, 0x30, 0x0C, 0x07, 0x03, 0x00, 0xC0, 0x38, 0x18, 0x0E, 0x07, 0x00,
  0xE0, 0x60, 0x18, 0x1C, 0x03, 0x83, 0x80, 0x60, 0x60, 0x06, 0x0E, 0x01,
  0xC1, 0x80, 0x1C, 0x30, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01,
  0xC7, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x0C, 0x60, 0x01,
  0x9C, 0x00, 0x39, 0x80, 0x06, 0x70, 0x00, 0xEE, 0x00, 0x19, 0x80, 0x01,
  0xB0, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x03, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x03, 0x38, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x18,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x01, 0x80, 0x07,
  0x00, 0xC0, 0x03, 0x80, 0x70, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x33, 0xEF, 0xC0, 0x00, 0xDC, 0x07, 0x80, 0x03,
  0x70, 0x0F, 0x00, 0x1D, 0x80, 0x1E, 0x00, 0x6E, 0x00, 0x3C, 0x03, 0xB0,
  0x00, 0x78, 0x0C, 0xC0, 0x00, 0xFD, 0xF3, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 49, 13, 5, -48 },
  { 26, 9, 14, 18, 5, -50 },
  { 42, 30, 48, 33, 3, -48 },
  { 222, 25, 62, 32, 4, -55 },
  { 416, 36, 50, 43, 4, -49 },
  { 641, 30, 50, 36, 4, -49 },
  { 829, 3, 14, 11, 4, -50 },
  { 835, 12, 68, 19, 5, -53 },
  { 937, 13, 68, 19, 1, -53 },
  { 1048, 26, 26, 28, 1, -48 },
  { 1133, 27, 34, 33, 3, -39 },
  { 1248, 5, 14, 13, 3, -6 },
  { 1257, 13, 2, 18, 2, -22 },
  { 1261, 4, 5, 15, 5, -4 },
  { 1264, 19, 52, 23, 2, -48 },
  { 1388, 25, 50, 32, 4, -49 },
  { 1545, 13, 48, 32, 6, -48 },
  { 1623, 25, 49, 32, 4, -49 },
  { 1777, 26, 50, 32, 3, -49 },
  { 1940, 28, 48, 32, 3, -48 },
  { 2108, 24, 49, 32, 5, -48 },
  { 2255, 25, 49, 32, 4, -48 },
  { 2409, 26, 48, 32, 3, -48 },
  { 2565, 26, 50, 32, 3, -49 },
  { 2728, 25, 49, 32, 3, -49 },
  { 2882, 5, 36, 12, 4, -35 },
  { 2905, 7, 43, 12, 2, -35 },
  { 2943, 23, 27, 30, 3, -35 },
  { 3021, 23, 15, 33, 5, -29 },
  { 3065, 23, 27, 31, 4, -35 },
  { 3143, 20, 50, 26, 3, -49 },
  { 3268, 46, 61, 53, 4, -46 },
  { 3619, 33, 48, 36, 1, -48 },
  { 3817, 26, 48, 36, 6, -48 },
  { 3973, 29, 50, 38, 5, -49 },
  { 4155, 28, 48, 38, 6, -48 },
  { 4323, 25, 48, 34, 6, -48 },
  { 4473, 25, 48, 33, 6, -48 },
  { 4623, 30, 50, 40, 5, -49 },
  { 4811, 29, 48, 41, 6, -48 },
  { 4985, 2, 48, 16, 7, -48 },
  { 4997, 24, 49, 32, 3, -48 },
  { 5144, 29, 48, 37, 6, -48 },
  { 5318, 23, 48, 31, 6, -48 },
  { 5456, 38, 48, 50, 6, -48 },
  { 5684, 29, 48, 41, 6, -48 },
  { 5858, 31, 50, 39, 4, -49 },
  { 6052, 26, 48, 36, 6, -48 },
  { 6208, 31, 58, 39, 4, -49 },
  { 6433, 28, 48, 38, 6, -48 },
  { 6601, 29, 50, 35, 3, -49 },
  { 6783, 31, 48, 35, 2, -48 },
  { 6969, 28, 49, 39, 5, -48 },
  { 7141, 32, 48, 36, 2, -48 },
  { 7333, 48, 48, 52, 2, -48 },
  { 7621, 31, 48, 36, 2, -48 },
  { 7807, 33, 48, 35, 1, -48 },
  { 8005, 29, 48, 35, 3, -48 },
  { 8179, 9, 64, 14, 5, -54 },
  { 8251, 19, 52, 23, 2, -48 },
  { 8375, 8, 64, 14, 1, -54 },
  { 8439, 18, 24, 25, 3, -48 },
  { 8493, 24, 2, 25, 1, 0 },
  { 8499, 10, 9, 18, 4, -50 },
  { 8511, 24, 37, 31, 3, -36 },
  { 8622, 24, 51, 32, 5, -50 },
  { 8775, 24, 37, 30, 3, -36 },
  { 8886, 23, 51, 33, 4, -50 },
  { 9033, 24, 37, 30, 3, -36 },
  { 9144, 17, 51, 20, 2, -51 },
  { 9253, 23, 50, 33, 4, -36 },
  { 9397, 22, 50, 32, 5, -50 },
  { 9535, 4, 48, 13, 5, -48 },
  { 9559, 12, 62, 14, -3, -48 },
  { 9652, 23, 50, 29, 5, -50 },
  { 9796, 2, 50, 13, 6, -50 },
  { 9809, 42, 36, 52, 5, -36 },
  { 9998, 22, 36, 32, 5, -36 },
  { 10097, 25, 37, 33, 4, -36 },
  { 10213, 24, 50, 32, 5, -36 },
  { 10363, 23, 50, 33, 4, -36 },
  { 10507, 14, 36, 20, 5, -36 },
  { 10570, 23, 37, 30, 3, -36 },
  { 10677, 16, 46, 19, 1, -45 },
  { 10769, 22, 36, 32, 5, -35 },
  { 10868, 25, 35, 28, 2, -35 },
  { 10978, 38, 35, 44, 3, -35 },
  { 11145, 25, 35, 29, 2, -35 },
  { 11255, 25, 49, 28, 2, -35 },
  { 11409, 24, 35, 29, 3, -35 },
  { 11514, 16, 66, 20, 3, -52 },
  { 11646, 2, 57, 14, 6, -48 },
  { 11661, 16, 66, 20, 1, -52 },
  { 11793, 30, 11, 40, 5, -25 },
};

const GFXfont RobotoCondensed_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT67PT7B_H_
