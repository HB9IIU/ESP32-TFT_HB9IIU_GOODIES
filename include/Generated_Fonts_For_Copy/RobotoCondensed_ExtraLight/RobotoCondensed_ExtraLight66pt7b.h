#ifndef _ROBOTOCONDENSED_EXTRALIGHT66PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEE,
  0xE6, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x0F,
  0x00, 0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x08, 0x06,
  0x00, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x38, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x0C, 0x01, 0x81, 0x80, 0x01,
  0xC0, 0x60, 0x70, 0x00, 0x1C, 0x1C, 0x0C, 0x00, 0x01, 0xFF, 0x03, 0x80,
  0x00, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x30, 0x1F, 0xF0,
  0x00, 0x06, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x70, 0x00, 0x30, 0x30,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x60, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x38, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x38,
  0x03, 0x80, 0x40, 0x03, 0x00, 0x60, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x03, 0x80,
  0x0C, 0x38, 0x0E, 0x00, 0x30, 0xC0, 0x1C, 0x00, 0xC7, 0x00, 0x38, 0x07,
  0x18, 0x00, 0x70, 0x1C, 0xE0, 0x01, 0xC0, 0x63, 0x80, 0x03, 0x81, 0x8C,
  0x00, 0x07, 0x06, 0x30, 0x00, 0x0E, 0x38, 0xC0, 0x00, 0x38, 0xC3, 0x00,
  0x00, 0x77, 0x0C, 0x00, 0x00, 0xFC, 0x30, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x07,
  0x70, 0x3C, 0x00, 0x38, 0xE0, 0x78, 0x03, 0xC1, 0xC0, 0xFF, 0xFE, 0x03,
  0x80, 0xFF, 0xE0, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xED, 0x80, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x40, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0xBC, 0x03, 0x00, 0xFF, 0xE0, 0xC1, 0xFC, 0x7E, 0x31, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0x9D, 0xCE,
  0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF6, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xB3,
  0xF1, 0xFE, 0x0F, 0x80, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xC0, 0x1E, 0x01, 0xC0,
  0x07, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xE0, 0x01,
  0xC0, 0x7C, 0x01, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x0C,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x33,
  0xFF, 0xC0, 0x37, 0xE7, 0xE0, 0x3E, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x30,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x3F, 0x00, 0x30, 0xFF,
  0xF0, 0x18, 0xFC, 0xFC, 0x0C, 0xE0, 0x0F, 0x0E, 0xE0, 0x03, 0xC7, 0xE0,
  0x00, 0xE3, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x78,
  0x07, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xE3, 0xC0, 0x07, 0x70, 0xF0, 0x07,
  0x38, 0x3F, 0x1F, 0x1C, 0x07, 0xFE, 0x0C, 0x00, 0xFC, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x77, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0xF3, 0x00, 0x3C, 0xF3,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x18, 0xE3, 0x9C, 0x61, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0E,
  0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1F, 0x80, 0x01,
  0x83, 0x00, 0x03, 0xFF, 0x00, 0x0C, 0x18, 0x00, 0x3C, 0x3C, 0x00, 0x61,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0x8C, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x67, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x19, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x7C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x06, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0x30, 0x00, 0xD8, 0x01, 0x80, 0x01, 0x80, 0x06,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x60, 0x00, 0x60, 0x01, 0xB0,
  0x03, 0x00, 0x03, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x18, 0x00, 0x6C, 0x00,
  0xC0, 0x01, 0xC0, 0x07, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x33, 0x80, 0x38,
  0x00, 0x70, 0x01, 0x9C, 0x01, 0xC0, 0x07, 0x80, 0x0C, 0x60, 0x06, 0x00,
  0x2C, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x60, 0x0E, 0x18, 0x01, 0xC0, 0x33,
  0x80, 0x60, 0xC0, 0x07, 0x03, 0x8C, 0x06, 0x07, 0x00, 0x1F, 0xF8, 0x79,
  0xF0, 0x18, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0E, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x7F, 0x03, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x3C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x78, 0x30, 0x00, 0xFC, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xF0, 0xC0, 0x03, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x3C,
  0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x3C, 0x0C, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xF0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0xE1, 0xE0, 0x03, 0x81, 0xE0, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x01, 0xE0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0,
  0x3C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC7, 0xE0, 0x00, 0x0C,
  0x77, 0x00, 0x00, 0xCE, 0x78, 0x00, 0x0D, 0xC3, 0x80, 0x00, 0xF8, 0x1C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEC, 0x00, 0x00,
  0x00, 0x7F, 0x70, 0x00, 0x00, 0x03, 0x7B, 0x80, 0x00, 0x00, 0x3B, 0xCC,
  0x00, 0x00, 0x01, 0x9E, 0x70, 0x00, 0x00, 0x0C, 0xF3, 0x80, 0x00, 0x00,
  0xE7, 0x8C, 0x00, 0x00, 0x06, 0x3C, 0x70, 0x00, 0x00, 0x31, 0xE1, 0x80,
  0x00, 0x03, 0x8F, 0x0C, 0x00, 0x00, 0x18, 0x78, 0x70, 0x00, 0x01, 0xC3,
  0xC1, 0x80, 0x00, 0x0E, 0x1E, 0x0C, 0x00, 0x00, 0x60, 0xF0, 0x70, 0x00,
  0x07, 0x07, 0x81, 0x80, 0x00, 0x38, 0x3C, 0x0E, 0x00, 0x01, 0x81, 0xE0,
  0x70, 0x00, 0x1C, 0x0F, 0x01, 0x80, 0x00, 0xC0, 0x78, 0x0E, 0x00, 0x06,
  0x03, 0xC0, 0x30, 0x00, 0x70, 0x1E, 0x01, 0x80, 0x03, 0x00, 0xF0, 0x0E,
  0x00, 0x18, 0x07, 0x80, 0x30, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x0C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x30, 0x07, 0x00, 0x78, 0x01, 0x80,
  0x30, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x1E, 0x00, 0x30, 0x18, 0x00, 0xF0,
  0x01, 0xC0, 0xC0, 0x07, 0x80, 0x06, 0x0E, 0x00, 0x3C, 0x00, 0x30, 0x60,
  0x01, 0xE0, 0x01, 0xC3, 0x00, 0x0F, 0x00, 0x06, 0x38, 0x00, 0x78, 0x00,
  0x31, 0x80, 0x03, 0xC0, 0x01, 0xCC, 0x00, 0x1E, 0x00, 0x06, 0xE0, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1F, 0x70, 0x00,
  0x00, 0xF9, 0xC0, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x01,
  0xF0, 0xC0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x3E, 0x01, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0x80, 0x38, 0x00,
  0x7C, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x1F, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0xE0, 0x07, 0xC0, 0x03, 0x00, 0x3E, 0x00, 0x1C, 0x01, 0xF0, 0x00,
  0x70, 0x0F, 0x80, 0x03, 0x80, 0x7C, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x70,
  0x1F, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x38, 0x3E,
  0x00, 0x00, 0xE1, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x1C, 0x7C, 0x00,
  0x00, 0xE3, 0xE0, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x0C, 0xF8, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x0C, 0x00, 0x3F, 0x83, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0E, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0xF8, 0xC0, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x0F, 0xE0, 0x60, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E,
  0x30, 0x00, 0x03, 0x86, 0x00, 0x01, 0xE0, 0xC0, 0x01, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x98, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x06,
  0x60, 0x00, 0x18, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x06, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x18,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x07, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x06, 0x01,
  0xC0, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0xC3, 0x80, 0x01, 0x83, 0x00,
  0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x37, 0x00, 0x00, 0x76, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xE0, 0x06, 0x18, 0x01, 0x86, 0x00,
  0xE1, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x81, 0x80, 0x60, 0x60,
  0x18, 0x38, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x39, 0xC0, 0x06, 0x60, 0x01,
  0xB8, 0x00, 0x7E, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0x0E, 0x1E, 0x00, 0x0E, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0x60, 0x00, 0x3E, 0x70, 0x00, 0x7E, 0x78,
  0x00, 0xEE, 0x3C, 0x03, 0xCE, 0x1F, 0xFF, 0x86, 0x0F, 0xFE, 0x06, 0x01,
  0xF0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F, 0x80, 0x60, 0xFF, 0xC0,
  0xC7, 0xFF, 0xE1, 0x9C, 0x01, 0xE3, 0x70, 0x01, 0xE6, 0xC0, 0x01, 0xCF,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xDF,
  0x00, 0x07, 0x37, 0x00, 0x1C, 0x67, 0x00, 0x78, 0xC7, 0xFF, 0xE1, 0x83,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x1F, 0x01, 0x81, 0xFF, 0x83, 0x0F, 0xFF, 0xC6, 0x3C, 0x01, 0xCC,
  0xF0, 0x01, 0xD9, 0xC0, 0x01, 0xB7, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xE7, 0x00, 0x06, 0xC7, 0x00, 0x1D, 0x8F,
  0x00, 0x73, 0x0F, 0xFF, 0xC6, 0x07, 0xFE, 0x0C, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x0E,
  0x00, 0x0E, 0x0F, 0x80, 0x3C, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x0C, 0x3F, 0xFF, 0x18,
  0xF0, 0x07, 0x33, 0xC0, 0x07, 0x67, 0x00, 0x06, 0xDC, 0x00, 0x07, 0xB8,
  0x00, 0x0F, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x1F, 0x1C,
  0x00, 0x7E, 0x3C, 0x01, 0xDC, 0x3F, 0xFF, 0x38, 0x1F, 0xF8, 0x70, 0x0F,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x80, 0x03,
  0x83, 0xC0, 0x0E, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0xE0, 0x38, 0x3F, 0xE0, 0xE3, 0xFF, 0xE3, 0x9C,
  0x03, 0xCE, 0xE0, 0x07, 0x3B, 0x00, 0x0E, 0xF8, 0x00, 0x3B, 0xC0, 0x00,
  0x6F, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0xCF, 0x8F, 0xF0,
  0x7C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00,
  0x73, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03,
  0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81,
  0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00,
  0x0E, 0x78, 0x00, 0x3B, 0xE0, 0x00, 0xFD, 0xC0, 0x03, 0xE3, 0x80, 0x0F,
  0x06, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x60, 0xFF, 0xC0, 0x0F,
  0xFC, 0x30, 0xFF, 0xF8, 0x1F, 0xFF, 0x18, 0xE0, 0x1C, 0x1C, 0x03, 0xCC,
  0xE0, 0x07, 0x1C, 0x00, 0xF6, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x60, 0x00,
  0xEC, 0x00, 0x0D, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x3E, 0x03, 0x03,
  0xFE, 0x0C, 0x3F, 0xFE, 0x31, 0xC0, 0x3C, 0xCE, 0x00, 0x73, 0x30, 0x00,
  0xED, 0x80, 0x03, 0xBC, 0x00, 0x06, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x01, 0x83, 0xFF, 0x03, 0x1F, 0xFF, 0x86, 0x70,
  0x07, 0x8D, 0xC0, 0x07, 0x9B, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x1C, 0xDC, 0x00,
  0x71, 0x9C, 0x01, 0xE3, 0x1F, 0xFF, 0x86, 0x0F, 0xFC, 0x0C, 0x07, 0xE0,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFE, 0x0C, 0x3F, 0xFF, 0x18, 0xF0, 0x07, 0x33, 0xC0,
  0x07, 0x67, 0x00, 0x06, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x60, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x7E, 0x3C, 0x01,
  0xDC, 0x3F, 0xFF, 0x38, 0x1F, 0xF8, 0x70, 0x0F, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x7B, 0x07, 0xEC,
  0x7F, 0xB1, 0xC0, 0xEC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0x80, 0x3C, 0x38, 0x00,
  0x78, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x37, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x37, 0x00, 0x01,
  0xDC, 0x00, 0x06, 0x38, 0x00, 0x38, 0x78, 0x03, 0xC0, 0xFF, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60,
  0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xCE, 0x00, 0x3F, 0x3C, 0x03,
  0xDC, 0x7F, 0xFE, 0x70, 0x7F, 0xE1, 0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30,
  0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1B, 0x80,
  0x01, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0x00,
  0x0E, 0x60, 0x00, 0xD8, 0x00, 0x31, 0x80, 0x03, 0x60, 0x00, 0xC7, 0x00,
  0x0D, 0x80, 0x07, 0x1C, 0x00, 0x77, 0x00, 0x1C, 0x30, 0x01, 0xDC, 0x00,
  0x60, 0xC0, 0x06, 0x30, 0x01, 0x83, 0x80, 0x18, 0xC0, 0x0E, 0x0E, 0x00,
  0xE3, 0x80, 0x38, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x18, 0x03,
  0x01, 0xC0, 0x30, 0x70, 0x1C, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x00, 0xE0, 0xE0, 0x38, 0x18,
  0x03, 0x83, 0x80, 0x60, 0xE0, 0x06, 0x0C, 0x01, 0x83, 0x80, 0x18, 0x30,
  0x06, 0x0C, 0x00, 0x71, 0xC0, 0x1C, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x3B, 0x80,
  0x0E, 0x60, 0x00, 0xEC, 0x00, 0x1B, 0x80, 0x01, 0xB0, 0x00, 0x6E, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xC3, 0x80, 0x01, 0xC1, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x18, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x00,
  0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x47, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x73, 0xEF, 0x80, 0x01, 0xDC, 0x07, 0x00, 0x06, 0x60, 0x0E, 0x00, 0x1B,
  0x80, 0x1C, 0x00, 0x6C, 0x00, 0x38, 0x03, 0xB0, 0x00, 0x78, 0x1C, 0xC0,
  0x00, 0xF9, 0xE3, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 48, 13, 5, -47 },
  { 25, 9, 14, 18, 5, -50 },
  { 41, 30, 47, 33, 3, -47 },
  { 218, 24, 61, 32, 4, -54 },
  { 401, 35, 49, 43, 4, -48 },
  { 616, 30, 49, 35, 4, -48 },
  { 800, 3, 14, 11, 4, -50 },
  { 806, 12, 67, 19, 5, -52 },
  { 907, 13, 67, 19, 1, -52 },
  { 1016, 26, 26, 28, 1, -47 },
  { 1101, 27, 34, 33, 3, -39 },
  { 1216, 5, 14, 13, 3, -5 },
  { 1225, 13, 2, 17, 2, -22 },
  { 1229, 4, 4, 15, 5, -3 },
  { 1231, 18, 51, 23, 2, -47 },
  { 1346, 24, 49, 32, 4, -48 },
  { 1493, 13, 47, 32, 6, -47 },
  { 1570, 25, 48, 32, 4, -48 },
  { 1720, 25, 49, 32, 3, -48 },
  { 1874, 27, 47, 32, 3, -47 },
  { 2033, 24, 48, 32, 5, -47 },
  { 2177, 25, 48, 32, 4, -47 },
  { 2327, 25, 47, 32, 3, -47 },
  { 2474, 26, 49, 32, 3, -48 },
  { 2634, 25, 48, 32, 3, -48 },
  { 2784, 5, 34, 12, 4, -33 },
  { 2806, 6, 42, 12, 2, -33 },
  { 2838, 22, 27, 30, 3, -35 },
  { 2913, 22, 15, 32, 5, -29 },
  { 2955, 23, 27, 30, 4, -35 },
  { 3033, 20, 49, 26, 3, -48 },
  { 3156, 45, 61, 53, 4, -46 },
  { 3500, 33, 47, 35, 1, -47 },
  { 3694, 26, 47, 35, 6, -47 },
  { 3847, 28, 49, 37, 5, -48 },
  { 4019, 27, 47, 38, 6, -47 },
  { 4178, 24, 47, 33, 6, -47 },
  { 4319, 24, 47, 33, 6, -47 },
  { 4460, 29, 49, 39, 5, -48 },
  { 4638, 29, 47, 41, 6, -47 },
  { 4809, 2, 47, 16, 7, -47 },
  { 4821, 23, 48, 32, 3, -47 },
  { 4959, 28, 47, 37, 6, -47 },
  { 5124, 22, 47, 30, 6, -47 },
  { 5254, 37, 47, 49, 6, -47 },
  { 5472, 29, 47, 41, 6, -47 },
  { 5643, 30, 49, 39, 4, -48 },
  { 5827, 26, 47, 35, 6, -47 },
  { 5980, 30, 56, 39, 4, -48 },
  { 6190, 27, 47, 37, 6, -47 },
  { 6349, 28, 49, 34, 3, -48 },
  { 6521, 30, 47, 35, 2, -47 },
  { 6698, 28, 48, 38, 5, -47 },
  { 6866, 32, 47, 35, 2, -47 },
  { 7054, 47, 47, 52, 2, -47 },
  { 7331, 31, 47, 35, 2, -47 },
  { 7514, 32, 47, 35, 1, -47 },
  { 7702, 28, 47, 35, 3, -47 },
  { 7867, 9, 64, 14, 5, -54 },
  { 7939, 19, 51, 23, 2, -47 },
  { 8061, 8, 64, 14, 1, -54 },
  { 8125, 18, 23, 24, 3, -47 },
  { 8177, 23, 2, 25, 1, 0 },
  { 8183, 10, 9, 18, 4, -50 },
  { 8195, 24, 37, 31, 3, -36 },
  { 8306, 23, 51, 32, 5, -50 },
  { 8453, 24, 37, 30, 3, -36 },
  { 8564, 23, 51, 32, 4, -50 },
  { 8711, 24, 37, 30, 3, -36 },
  { 8822, 17, 51, 19, 2, -51 },
  { 8931, 23, 49, 32, 4, -36 },
  { 9072, 22, 50, 32, 5, -50 },
  { 9210, 4, 48, 13, 5, -48 },
  { 9234, 12, 61, 14, -3, -48 },
  { 9326, 22, 50, 28, 5, -50 },
  { 9464, 3, 50, 13, 5, -50 },
  { 9483, 41, 36, 51, 5, -36 },
  { 9668, 22, 36, 32, 5, -36 },
  { 9767, 24, 37, 32, 4, -36 },
  { 9878, 23, 49, 32, 5, -36 },
  { 10019, 23, 49, 32, 4, -36 },
  { 10160, 14, 36, 20, 5, -36 },
  { 10223, 22, 37, 29, 3, -36 },
  { 10325, 15, 45, 19, 1, -44 },
  { 10410, 22, 36, 32, 5, -35 },
  { 10509, 24, 35, 28, 2, -35 },
  { 10614, 38, 35, 43, 3, -35 },
  { 10781, 24, 35, 28, 2, -35 },
  { 10886, 24, 48, 28, 2, -35 },
  { 11030, 23, 35, 28, 3, -35 },
  { 11131, 16, 65, 19, 3, -51 },
  { 11261, 2, 56, 14, 6, -47 },
  { 11275, 16, 65, 19, 1, -51 },
  { 11405, 30, 11, 40, 5, -25 },
};

const GFXfont RobotoCondensed_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT66PT7B_H_
