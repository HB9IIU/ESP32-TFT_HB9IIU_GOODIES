#ifndef _ROBOTOCONDENSED_EXTRALIGHT71PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x60, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x80, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x01, 0x80,
  0x1C, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x81, 0xC0,
  0x00, 0x3C, 0x3C, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x00, 0x7E,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0x01, 0xFF,
  0x80, 0x00, 0x1C, 0x0F, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0x01, 0x80, 0xC0, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x1C, 0x03, 0x80,
  0x0C, 0x38, 0x01, 0xC0, 0x0C, 0x70, 0x01, 0xE0, 0x0C, 0x70, 0x00, 0xE0,
  0x0C, 0x60, 0x00, 0x70, 0x1C, 0xE0, 0x00, 0x38, 0x1C, 0xE0, 0x00, 0x3C,
  0x18, 0xE0, 0x00, 0x1C, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0xE0, 0x00, 0x07,
  0x38, 0xE0, 0x00, 0x07, 0x70, 0xE0, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x07, 0x38, 0x1E, 0x00, 0x1E, 0x1C, 0x0F, 0x80, 0x7C,
  0x1C, 0x07, 0xFF, 0xF0, 0x0E, 0x01, 0xFF, 0xE0, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB7, 0xF8, 0x00, 0x08, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x60, 0x06,
  0xF8, 0x06, 0x01, 0xFF, 0xF0, 0x60, 0xFE, 0x1F, 0xE6, 0x3F, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6,
  0x38, 0xE3, 0x9C, 0x73, 0x84, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x07,
  0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8,
  0x1F, 0xF0, 0xF8, 0xEF, 0xC1, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xF0, 0x0E, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x0F, 0x80, 0x3C,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x06, 0x7F, 0xF8, 0x03, 0x7F, 0xFF, 0x03,
  0xF0, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x7F, 0x00, 0x38, 0x7F, 0xF8, 0x06, 0x1F, 0xFF, 0xC0, 0xC7, 0x80, 0x7C,
  0x19, 0xC0, 0x03, 0x83, 0x70, 0x00, 0x38, 0x7C, 0x00, 0x03, 0x9F, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x06, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x3C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0xE0, 0x01, 0xE0,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7C, 0xE0, 0x00,
  0x3F, 0x3C, 0x00, 0x1D, 0xC7, 0x80, 0x0E, 0x70, 0xF0, 0x07, 0x1C, 0x1F,
  0xFF, 0x87, 0x03, 0xFF, 0xC1, 0x80, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x9F, 0xF7, 0x98, 0x38, 0xF7, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x39, 0xC7,
  0x38, 0xE1, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78,
  0x1C, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0xFE, 0x00, 0x06, 0x1C, 0x00, 0x0F, 0x9F, 0x00, 0x06,
  0x18, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x70, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x60, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x60, 0x03, 0x80, 0x01, 0x80, 0x03, 0x60, 0x03, 0x00, 0x01, 0x80, 0x03,
  0xE0, 0x03, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x03, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x07, 0x00, 0x03, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x06,
  0xE0, 0x07, 0x00, 0x03, 0x00, 0x06, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x60, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x60, 0x03, 0x00, 0x07, 0x00, 0x0C,
  0x60, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x60, 0x03, 0x80, 0x0F, 0x80, 0x1C,
  0x70, 0x03, 0x80, 0x19, 0x80, 0x38, 0x70, 0x01, 0xC0, 0x31, 0x80, 0x30,
  0x30, 0x01, 0xE0, 0x71, 0xC0, 0x70, 0x30, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x38, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3E, 0x0E,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x3E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0xE0, 0x78, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF8,
  0x00, 0x00, 0xE3, 0xB8, 0x00, 0x01, 0xCE, 0x70, 0x00, 0x03, 0xB8, 0x70,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xB0, 0x00, 0x00, 0x00,
  0x6F, 0xDC, 0x00, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x00, 0x3B, 0xF3,
  0x00, 0x00, 0x00, 0x19, 0xF9, 0xC0, 0x00, 0x00, 0x1C, 0xFC, 0xE0, 0x00,
  0x00, 0x0E, 0x7E, 0x30, 0x00, 0x00, 0x06, 0x3F, 0x1C, 0x00, 0x00, 0x07,
  0x1F, 0x8E, 0x00, 0x00, 0x03, 0x0F, 0xC3, 0x80, 0x00, 0x03, 0x87, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0xF0, 0x60, 0x00, 0x00, 0xC1, 0xF8, 0x38, 0x00,
  0x00, 0xE0, 0xFC, 0x1C, 0x00, 0x00, 0x70, 0x7E, 0x06, 0x00, 0x00, 0x30,
  0x3F, 0x03, 0x80, 0x00, 0x38, 0x1F, 0x81, 0xC0, 0x00, 0x1C, 0x0F, 0xC0,
  0x60, 0x00, 0x0C, 0x07, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0xF0, 0x0C, 0x00,
  0x06, 0x01, 0xF8, 0x06, 0x00, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x03, 0x80,
  0x7E, 0x00, 0xC0, 0x01, 0x80, 0x3F, 0x00, 0x70, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x00, 0xE0, 0x0F, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0xF0, 0x03, 0x80, 0x38, 0x01, 0xF8, 0x00, 0xC0, 0x18, 0x00,
  0xFC, 0x00, 0x70, 0x1C, 0x00, 0x7E, 0x00, 0x18, 0x0C, 0x00, 0x3F, 0x00,
  0x0C, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x07, 0x00, 0x0F, 0xC0, 0x01, 0x83,
  0x00, 0x07, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xF0, 0x00, 0x71, 0xC0, 0x01,
  0xF8, 0x00, 0x18, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xB0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x07, 0xEE, 0x00,
  0x00, 0x07, 0xE7, 0x00, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x07, 0xE3, 0x80,
  0x00, 0x07, 0xE1, 0xC0, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x07, 0xE0, 0xE0,
  0x00, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x07, 0xE0, 0x38,
  0x00, 0x07, 0xE0, 0x38, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x07, 0xE0, 0x1C,
  0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x07,
  0x00, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x00,
  0x60, 0x07, 0xE0, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x38, 0x07, 0xE0, 0x00,
  0x38, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xE0, 0x00,
  0x0E, 0x07, 0xE0, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x07, 0x07, 0xE0, 0x00,
  0x03, 0x87, 0xE0, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x01, 0xC7, 0xE0, 0x00,
  0x01, 0xC7, 0xE0, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0x77, 0xE0, 0x00,
  0x00, 0x77, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x98, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x30, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x06, 0x01, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x30,
  0x00, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00,
  0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x38, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xF8, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF,
  0xF8, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x39, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x07, 0x0E, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x70,
  0x0C, 0x03, 0x01, 0xC0, 0x30, 0x1C, 0x03, 0x81, 0x80, 0x18, 0x38, 0x01,
  0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00,
  0x06, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0xE1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x39,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0x70, 0x00,
  0x1F, 0x9C, 0x00, 0x1D, 0xCF, 0x00, 0x1C, 0xE3, 0xC0, 0x3C, 0x70, 0xFF,
  0xFC, 0x38, 0x3F, 0xF8, 0x0C, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x01, 0xC1, 0xFF, 0xC0, 0xE3, 0xFF,
  0xF0, 0x73, 0xC0, 0x3C, 0x3B, 0x80, 0x07, 0x1D, 0x80, 0x01, 0xCF, 0x80,
  0x00, 0xE7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x37, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xF0,
  0x00, 0x1C, 0xFC, 0x00, 0x0E, 0x77, 0x00, 0x1E, 0x39, 0xE0, 0x1E, 0x1C,
  0x7F, 0xFE, 0x0E, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x07, 0xC0, 0x3C, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0xF8, 0x0E, 0x03, 0xFF, 0x87, 0x07, 0xFF, 0xE3,
  0x87, 0xC0, 0x39, 0xC7, 0x80, 0x0E, 0xE3, 0x80, 0x03, 0xF3, 0x80, 0x00,
  0xF9, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x0F, 0x1C, 0x00, 0x0F, 0x8F, 0x00, 0x1D, 0xC3, 0xE0, 0x1C, 0xE0, 0xFF,
  0xFC, 0x70, 0x1F, 0xFC, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0xE0,
  0x00, 0x38, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xE1, 0xC1, 0xFF, 0xF8, 0xE1, 0xF0, 0x0E, 0x71, 0xE0, 0x03, 0xB8,
  0xE0, 0x00, 0xFC, 0xE0, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xE3, 0xC0, 0x07,
  0x70, 0xF8, 0x07, 0x38, 0x3F, 0xFF, 0x1C, 0x07, 0xFF, 0x0E, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x40, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x01, 0xFD, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x7F, 0xE0, 0xE1, 0xFF, 0xF0, 0xE3, 0xC0, 0x78,
  0xE7, 0x00, 0x3C, 0xE6, 0x00, 0x1C, 0xEC, 0x00, 0x0E, 0xFC, 0x00, 0x0E,
  0xF8, 0x00, 0x06, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF6, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0xFF, 0x8F, 0xF0, 0x7C,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0x80,
  0x00, 0xE7, 0xC0, 0x00, 0xEE, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0xF8, 0x70,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x38,
  0x7F, 0xFC, 0x07, 0xFF, 0xE1, 0xC7, 0x00, 0xF0, 0x78, 0x07, 0x8E, 0x70,
  0x03, 0xC7, 0x80, 0x1E, 0x77, 0x00, 0x0E, 0x30, 0x00, 0x73, 0xB0, 0x00,
  0x3B, 0x80, 0x01, 0xDF, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x77, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xBC, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x7F, 0xE0, 0xE1, 0xFF,
  0xF0, 0xE3, 0xC0, 0x78, 0xE7, 0x00, 0x3C, 0xE6, 0x00, 0x1C, 0xEC, 0x00,
  0x0E, 0xFC, 0x00, 0x0E, 0xF8, 0x00, 0x06, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x07, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x07,
  0x80, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x7F, 0xF0, 0x38, 0xFF,
  0xFC, 0x1C, 0xF0, 0x0F, 0x0E, 0xE0, 0x03, 0xC7, 0x60, 0x00, 0x73, 0xE0,
  0x00, 0x39, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x7C,
  0x00, 0x07, 0x3F, 0x00, 0x03, 0x9D, 0xC0, 0x03, 0x8E, 0x78, 0x07, 0x87,
  0x1F, 0xFF, 0x83, 0x83, 0xFF, 0x81, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE1, 0xC1, 0xFF, 0xF8, 0xE1,
  0xF0, 0x1E, 0x71, 0xE0, 0x03, 0xB8, 0xE0, 0x00, 0xFC, 0xE0, 0x00, 0x3E,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03,
  0xC7, 0x00, 0x03, 0xE3, 0xC0, 0x03, 0x70, 0xF8, 0x07, 0xB8, 0x3F, 0xFF,
  0x1C, 0x07, 0xFF, 0x0E, 0x00, 0xFC, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x1F, 0xC1, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x70, 0x1D, 0xC0, 0x3B,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF0,
  0x07, 0x83, 0xC0, 0x07, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC1, 0xE0, 0x0F,
  0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F,
  0x38, 0x00, 0x3F, 0x1C, 0x00, 0x77, 0x1F, 0x01, 0xE7, 0x0F, 0xFF, 0xC7,
  0x03, 0xFF, 0x87, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x07,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x0C,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x00,
  0x01, 0xCC, 0x00, 0x07, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xF0, 0x00, 0x71, 0xC0, 0x01, 0xD8, 0x00, 0x38, 0x60, 0x00,
  0xCC, 0x00, 0x1C, 0x38, 0x00, 0x67, 0x00, 0x0E, 0x1C, 0x00, 0x73, 0x80,
  0x06, 0x0E, 0x00, 0x38, 0xC0, 0x07, 0x03, 0x00, 0x18, 0x60, 0x03, 0x81,
  0xC0, 0x0C, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0xC0, 0x70, 0x07,
  0x06, 0x00, 0xE0, 0x18, 0x03, 0x03, 0x00, 0x70, 0x0C, 0x01, 0x81, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x00,
  0xC0, 0x60, 0x1C, 0x0E, 0x00, 0x60, 0x30, 0x0E, 0x07, 0x00, 0x38, 0x38,
  0x03, 0x03, 0x00, 0x1C, 0x1C, 0x01, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0xE1,
  0xC0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x19, 0xC0,
  0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x66,
  0x00, 0x03, 0xB0, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x07, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80,
  0x70, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x1F, 0xFC,
  0x00, 0x03, 0x38, 0x0F, 0x00, 0x03, 0x70, 0x07, 0x80, 0x07, 0x70, 0x03,
  0x80, 0x07, 0x60, 0x01, 0xC0, 0x06, 0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x00,
  0x78, 0x1C, 0xE0, 0x00, 0x3F, 0xFC, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 51, 14, 5, -50 },
  { 27, 10, 15, 19, 5, -53 },
  { 46, 32, 50, 35, 3, -50 },
  { 246, 26, 65, 34, 4, -58 },
  { 458, 38, 52, 46, 4, -51 },
  { 705, 32, 52, 38, 4, -51 },
  { 913, 3, 15, 12, 4, -53 },
  { 919, 13, 72, 20, 5, -56 },
  { 1036, 13, 72, 20, 2, -56 },
  { 1153, 28, 28, 30, 1, -50 },
  { 1251, 29, 37, 35, 3, -42 },
  { 1386, 6, 15, 13, 3, -6 },
  { 1398, 14, 2, 19, 2, -24 },
  { 1402, 5, 5, 16, 5, -4 },
  { 1406, 20, 54, 25, 2, -50 },
  { 1541, 26, 52, 34, 4, -51 },
  { 1710, 15, 50, 34, 6, -50 },
  { 1804, 27, 51, 34, 4, -51 },
  { 1977, 26, 52, 34, 4, -51 },
  { 2146, 30, 50, 34, 3, -50 },
  { 2334, 25, 51, 34, 6, -50 },
  { 2494, 27, 51, 34, 4, -50 },
  { 2667, 28, 50, 34, 3, -50 },
  { 2842, 27, 52, 34, 4, -51 },
  { 3018, 26, 51, 34, 4, -51 },
  { 3184, 5, 38, 13, 4, -37 },
  { 3208, 6, 46, 13, 3, -37 },
  { 3243, 24, 28, 32, 3, -37 },
  { 3327, 24, 18, 35, 5, -32 },
  { 3381, 25, 28, 32, 4, -37 },
  { 3469, 22, 52, 28, 3, -51 },
  { 3612, 48, 65, 57, 4, -49 },
  { 4002, 34, 50, 38, 2, -50 },
  { 4215, 28, 50, 38, 6, -50 },
  { 4390, 31, 52, 40, 5, -51 },
  { 4592, 30, 50, 41, 6, -50 },
  { 4780, 27, 50, 36, 6, -50 },
  { 4949, 27, 50, 35, 6, -50 },
  { 5118, 31, 52, 42, 6, -51 },
  { 5320, 31, 50, 44, 6, -50 },
  { 5514, 3, 50, 17, 7, -50 },
  { 5533, 25, 51, 34, 3, -50 },
  { 5693, 31, 50, 39, 6, -50 },
  { 5887, 24, 50, 33, 6, -50 },
  { 6037, 41, 50, 53, 6, -50 },
  { 6294, 32, 50, 44, 6, -50 },
  { 6494, 32, 52, 42, 5, -51 },
  { 6702, 28, 50, 38, 6, -50 },
  { 6877, 32, 60, 42, 5, -51 },
  { 7117, 30, 50, 40, 6, -50 },
  { 7305, 31, 52, 37, 3, -51 },
  { 7507, 33, 50, 37, 2, -50 },
  { 7714, 29, 51, 41, 6, -50 },
  { 7899, 34, 50, 38, 2, -50 },
  { 8112, 51, 50, 55, 2, -50 },
  { 8431, 33, 50, 38, 2, -50 },
  { 8638, 35, 50, 37, 1, -50 },
  { 8857, 31, 50, 37, 3, -50 },
  { 9051, 9, 69, 15, 6, -58 },
  { 9129, 21, 54, 25, 2, -50 },
  { 9271, 9, 69, 15, 1, -58 },
  { 9349, 20, 25, 26, 3, -50 },
  { 9412, 25, 3, 27, 1, 0 },
  { 9422, 11, 9, 19, 4, -53 },
  { 9435, 25, 40, 33, 4, -39 },
  { 9560, 25, 54, 34, 5, -53 },
  { 9729, 26, 40, 32, 3, -39 },
  { 9859, 25, 54, 34, 4, -53 },
  { 10028, 26, 40, 32, 3, -39 },
  { 10158, 18, 54, 21, 3, -54 },
  { 10280, 25, 53, 34, 4, -39 },
  { 10446, 24, 53, 34, 5, -53 },
  { 10605, 4, 51, 14, 5, -51 },
  { 10631, 12, 65, 15, -3, -51 },
  { 10729, 24, 53, 30, 5, -53 },
  { 10888, 3, 53, 14, 6, -53 },
  { 10908, 45, 39, 55, 5, -39 },
  { 11128, 24, 39, 34, 5, -39 },
  { 11245, 27, 40, 35, 4, -39 },
  { 11380, 25, 53, 34, 5, -39 },
  { 11546, 25, 53, 35, 4, -39 },
  { 11712, 15, 39, 22, 5, -39 },
  { 11786, 23, 40, 32, 4, -39 },
  { 11901, 16, 48, 20, 2, -47 },
  { 11997, 24, 39, 34, 5, -38 },
  { 12114, 26, 38, 30, 2, -38 },
  { 12238, 41, 38, 47, 3, -38 },
  { 12433, 26, 38, 30, 2, -38 },
  { 12557, 26, 52, 30, 2, -38 },
  { 12726, 25, 38, 30, 3, -38 },
  { 12845, 17, 70, 21, 3, -55 },
  { 12994, 3, 59, 15, 6, -50 },
  { 13017, 17, 70, 21, 1, -55 },
  { 13166, 32, 12, 43, 5, -27 },
};

const GFXfont RobotoCondensed_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT71PT7B_H_
