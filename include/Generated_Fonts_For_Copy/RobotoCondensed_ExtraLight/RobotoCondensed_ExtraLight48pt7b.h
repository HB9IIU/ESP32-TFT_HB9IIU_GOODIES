#ifndef _ROBOTOCONDENSED_EXTRALIGHT48PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x00,
  0x03, 0xEC, 0x42, 0x85, 0x0A, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0x84, 0x00,
  0x40, 0x60, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0xC0, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x80, 0x81,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x01, 0x01, 0x80, 0x04,
  0x06, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x20, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x10, 0x18, 0x00, 0x40,
  0x60, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x70, 0x38, 0x30, 0x07, 0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x09, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x01, 0xB0,
  0x00, 0x66, 0x00, 0x18, 0xC0, 0x0C, 0x38, 0x0E, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x04,
  0x00, 0x04, 0x03, 0x01, 0x82, 0x01, 0x81, 0x81, 0x00, 0xC0, 0xC0, 0x80,
  0x60, 0xC0, 0x40, 0x30, 0x60, 0x20, 0x18, 0x60, 0x18, 0x08, 0x20, 0x0C,
  0x0C, 0x30, 0x03, 0x04, 0x10, 0x00, 0xFE, 0x18, 0x00, 0x3C, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0F, 0x00, 0x06, 0x1F,
  0xC0, 0x02, 0x0C, 0x30, 0x03, 0x0C, 0x0C, 0x01, 0x04, 0x06, 0x01, 0x82,
  0x01, 0x00, 0x83, 0x00, 0x80, 0xC1, 0x80, 0x40, 0xC0, 0xC0, 0x20, 0x60,
  0x60, 0x10, 0x60, 0x10, 0x08, 0x30, 0x08, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x18, 0x04, 0x00, 0xC0,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x30,
  0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x18, 0x04, 0x60, 0x70, 0x31, 0x00, 0xC0, 0xCC, 0x01, 0x83,
  0x30, 0x03, 0x0C, 0xC0, 0x0C, 0x22, 0x00, 0x19, 0x8C, 0x00, 0x36, 0x30,
  0x00, 0x70, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x36, 0x0E, 0x03,
  0x8C, 0x1F, 0xFC, 0x30, 0x1F, 0xC0, 0x60, 0xFF, 0xFF, 0xF0, 0x00, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x81, 0x81, 0x80,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x20, 0x30, 0x17, 0x86, 0x1F, 0x3E, 0xCF, 0x00,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x33, 0x00, 0x06, 0x30, 0x01,
  0x86, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x03, 0x00, 0xE0, 0x40, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x33, 0x33, 0x33, 0x66, 0xCC, 0xFF, 0xFF, 0xC0, 0x6F,
  0x60, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0x03,
  0x06, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x04, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xD0, 0x00, 0x6C, 0x00, 0x26, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18,
  0x38, 0x18, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0xF0, 0xFD, 0xE3,
  0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0x80, 0xC0, 0xC0, 0x18, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01, 0xA0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x81,
  0xC0, 0x70, 0x60, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x16, 0x00, 0x05, 0x80, 0x03, 0x60, 0x00,
  0xCC, 0x00, 0x23, 0x80, 0x18, 0x70, 0x1C, 0x07, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x1A,
  0x00, 0x03, 0x20, 0x00, 0x32, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x0C,
  0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x06,
  0x02, 0x00, 0x60, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x02, 0x03,
  0x00, 0x20, 0x30, 0x02, 0x06, 0x00, 0x20, 0x60, 0x02, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x3F, 0xFF, 0x9F, 0xFF, 0xCC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x3E, 0x03, 0x7F, 0xC1, 0xE0, 0x70, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x24, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x18, 0x70, 0x18, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC1, 0xF0, 0x31, 0xFF, 0x0D, 0xC0, 0xE3,
  0x40, 0x0C, 0xE0, 0x03, 0x38, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x02, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x34, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x70,
  0x70, 0x38, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0x80, 0xE0, 0xC0,
  0x1C, 0x60, 0x03, 0x18, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x0C, 0x01, 0xC1,
  0x80, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0x07, 0x83, 0x00, 0x71, 0x80,
  0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x67,
  0x00, 0x30, 0xE0, 0x38, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0xC0, 0xE0, 0x60, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x73, 0x00, 0x3C, 0x60, 0x0B, 0x1C, 0x0E, 0xC3, 0xFE, 0x30, 0x3F,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x0F, 0xF0, 0x03,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33,
  0x33, 0x36, 0x6C, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0x63, 0x80, 0x66, 0x00, 0xC8, 0x00,
  0xB0, 0x01, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x01, 0xF0,
  0x02, 0x30, 0x07, 0xF8, 0x02, 0x20, 0x0E, 0x0E, 0x03, 0x60, 0x0C, 0x04,
  0x03, 0x60, 0x18, 0x04, 0x01, 0x40, 0x30, 0x04, 0x01, 0x40, 0x30, 0x04,
  0x01, 0xC0, 0x20, 0x04, 0x01, 0xC0, 0x60, 0x0C, 0x01, 0xC0, 0x60, 0x0C,
  0x01, 0xC0, 0x60, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x40, 0x0C,
  0x01, 0x80, 0x40, 0x0C, 0x01, 0x80, 0x40, 0x0C, 0x03, 0xC0, 0x40, 0x0C,
  0x03, 0xC0, 0x40, 0x1C, 0x02, 0xC0, 0x60, 0x1C, 0x02, 0xC0, 0x60, 0x3C,
  0x06, 0xC0, 0x60, 0x2C, 0x0C, 0x40, 0x30, 0x66, 0x18, 0x40, 0x1F, 0xC7,
  0xF8, 0x60, 0x0F, 0x01, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x46,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81,
  0x00, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00,
  0xC0, 0x02, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0x00, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0xC7, 0xFF, 0xE0, 0xFF, 0xFC, 0x18,
  0x00, 0xE3, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x38, 0xFF,
  0xFE, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0x70,
  0x38, 0x00, 0xC3, 0x80, 0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x23, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x70,
  0x01, 0x81, 0xC0, 0x38, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC, 0xFF,
  0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0x80, 0x70, 0x70, 0x01, 0xC3, 0x00, 0x06, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xD8, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x60, 0x01, 0xC1, 0xC0, 0x3C, 0x07, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x18,
  0x70, 0x18, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x76, 0x00, 0x07,
  0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00,
  0x38, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01,
  0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xE0,
  0x00, 0xCF, 0x80, 0x06, 0xEC, 0x00, 0x3E, 0x30, 0x01, 0xE0, 0xC0, 0x0E,
  0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x30, 0x30, 0x01, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xBD, 0x80, 0x00, 0x1B, 0xD8,
  0x00, 0x01, 0xBC, 0x80, 0x00, 0x33, 0xCC, 0x00, 0x03, 0x3C, 0xC0, 0x00,
  0x33, 0xC4, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x63, 0xC6, 0x00, 0x04, 0x3C,
  0x30, 0x00, 0xC3, 0xC3, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x83, 0xC1, 0x80,
  0x18, 0x3C, 0x18, 0x01, 0x83, 0xC0, 0x80, 0x30, 0x3C, 0x0C, 0x03, 0x03,
  0xC0, 0xC0, 0x30, 0x3C, 0x04, 0x06, 0x03, 0xC0, 0x60, 0x60, 0x3C, 0x06,
  0x04, 0x03, 0xC0, 0x30, 0xC0, 0x3C, 0x03, 0x0C, 0x03, 0xC0, 0x30, 0x80,
  0x3C, 0x01, 0x98, 0x03, 0xC0, 0x19, 0x80, 0x3C, 0x00, 0xB0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x01, 0xC6, 0x00,
  0x0E, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE0,
  0x60, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x06, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x07, 0x00,
  0x18, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x80, 0x01, 0x9C, 0x00, 0x0C, 0xE0, 0x00, 0x37, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x26, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x30, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0xC0, 0x06, 0x03, 0x80, 0x70, 0x07,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x00, 0x0E,
  0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x73,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x26, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x30, 0xE0, 0x00,
  0xC1, 0xC0, 0x06, 0x03, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xC0, 0x07, 0x0C,
  0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00,
  0x30, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C,
  0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80,
  0x70, 0x30, 0x01, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xE0, 0x01, 0x83, 0xC0, 0x38, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x60,
  0x00, 0x66, 0x00, 0x0E, 0x30, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0x41, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x40, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x06, 0x60, 0x01, 0x60,
  0x01, 0x98, 0x00, 0x58, 0x00, 0x66, 0x00, 0x32, 0x00, 0x11, 0x80, 0x0C,
  0xC0, 0x0C, 0x20, 0x02, 0x30, 0x03, 0x0C, 0x00, 0x8C, 0x00, 0xC3, 0x00,
  0x61, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x04, 0x18, 0x06, 0x06,
  0x01, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x02, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x40,
  0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x08, 0x03, 0x0C, 0x01,
  0x86, 0x00, 0x63, 0x00, 0x21, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x20,
  0x03, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x13, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x68, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x67, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x03, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x06,
  0x03, 0x00, 0x38, 0x06, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x31,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC0, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0B, 0x00, 0xD8, 0x06, 0x40, 0x23, 0x03, 0x18, 0x18, 0x40, 0x83,
  0x0C, 0x18, 0x60, 0x42, 0x03, 0x30, 0x19, 0x80, 0x68, 0x03, 0xC0, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x80, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0x01, 0x86, 0x00, 0x62, 0x00, 0x33, 0x00, 0x0D,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x7F,
  0xF0, 0xFF, 0xF9, 0xE0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3B, 0x00, 0x3D, 0x80, 0x36,
  0x60, 0x33, 0x3F, 0xF1, 0x87, 0xE0, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0xF8, 0x11, 0xFF, 0x09, 0x81, 0xC5, 0x00,
  0x33, 0x80, 0x19, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x0C, 0xA0, 0x06, 0x5C, 0x0E, 0x27, 0xFE, 0x10, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x01, 0x86, 0x00, 0x63, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x0C, 0x38, 0x0C, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC1, 0xF8, 0x63, 0xFF, 0x33, 0x80, 0xDB,
  0x80, 0x2D, 0x80, 0x0E, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D,
  0x00, 0x06, 0xC0, 0x07, 0x70, 0x07, 0x9C, 0x06, 0xC7, 0xFE, 0x60, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x0C, 0x30, 0x03,
  0x98, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x18, 0x70, 0x0C, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x7F, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0xFF, 0xEF, 0xFE, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x07, 0xE1, 0x8F, 0xFC, 0xCE, 0x07,
  0x6E, 0x00, 0xB6, 0x00, 0x3A, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x34, 0x00, 0x3B, 0x00, 0x1D, 0xC0, 0x1E, 0x70, 0x1B, 0x1F, 0xF9, 0x83,
  0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x60, 0x06, 0x1C, 0x07, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83, 0xF0, 0x8F, 0xF8, 0x98,
  0x1C, 0x90, 0x0E, 0xA0, 0x06, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x7D,
  0x80, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0x80, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x0E, 0xFC, 0xF0, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x0E, 0x80, 0x1C, 0x80, 0x18,
  0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x81, 0x80, 0x83, 0x80, 0x83, 0x00,
  0x86, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB6, 0x00, 0xE6, 0x00, 0xC3, 0x00,
  0x81, 0x80, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x60, 0x80, 0x30,
  0x80, 0x18, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x07, 0xE1, 0x8F,
  0xF8, 0x3F, 0xE3, 0x30, 0x38, 0xC0, 0xE6, 0xC0, 0x33, 0x00, 0xED, 0x00,
  0x3C, 0x00, 0xDE, 0x00, 0x70, 0x01, 0xB8, 0x00, 0xE0, 0x01, 0x70, 0x00,
  0xC0, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x04,
  0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x20,
  0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x00,
  0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x08, 0x00,
  0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x40, 0x01,
  0xE0, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0C,
  0x83, 0xF0, 0x8F, 0xF8, 0x98, 0x1C, 0x90, 0x0E, 0xA0, 0x06, 0xE0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0x80, 0xE0, 0xC0,
  0x1C, 0x60, 0x03, 0x18, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00,
  0x06, 0x60, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x70, 0x60, 0x38, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x87, 0xE0, 0x47, 0xFC, 0x26, 0x07, 0x14, 0x00, 0xCE,
  0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x32, 0x80, 0x19, 0x70, 0x38, 0x9F, 0xF8, 0x43, 0xF0, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE1, 0x8F, 0xFC,
  0xCE, 0x03, 0x6E, 0x00, 0xF6, 0x00, 0x3B, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D, 0xC0, 0x1E, 0x70, 0x1B, 0x1F,
  0xF9, 0x83, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x87, 0xC7, 0xE6, 0x16, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x38,
  0x0E, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x60, 0x03, 0x70, 0x03, 0x38, 0x0E, 0x1F, 0xFC, 0x07, 0xF0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xF7, 0xFE, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x60, 0x0B, 0x70, 0x3B, 0x3F, 0xF3, 0x0F, 0xC3, 0xC0,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x43, 0x00, 0x30, 0x40, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x80, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x20, 0x06,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x68,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xB0, 0x07, 0x00, 0x36,
  0x00, 0xB0, 0x04, 0xC0, 0x36, 0x01, 0x98, 0x06, 0xC0, 0x31, 0x80, 0xC8,
  0x06, 0x30, 0x11, 0x80, 0x86, 0x06, 0x30, 0x30, 0xC0, 0xC6, 0x06, 0x08,
  0x18, 0x40, 0xC1, 0x82, 0x0C, 0x10, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x10,
  0xC0, 0x42, 0x03, 0x18, 0x0C, 0x40, 0x63, 0x01, 0x98, 0x0C, 0x40, 0x33,
  0x00, 0x98, 0x02, 0x40, 0x1B, 0x00, 0x68, 0x03, 0x60, 0x0F, 0x00, 0x68,
  0x01, 0xE0, 0x05, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18,
  0x06, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x06, 0xC0, 0x03, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C,
  0x06, 0x06, 0x01, 0x83, 0x80, 0x30, 0xC0, 0x0E, 0x60, 0x01, 0x98, 0x00,
  0x30, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0x43, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x80,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x01, 0x03, 0x00, 0x60, 0xC0, 0x18,
  0x20, 0x02, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0xB0,
  0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x0E, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x38, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x01, 0xC0, 0x20, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x13, 0x0E, 0x00, 0xD8, 0x0C, 0x03, 0x40, 0x18, 0x0D, 0x00, 0x30,
  0x6C, 0x00, 0x7F, 0x00, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 34, 9, 3, -34 },
  { 14, 7, 10, 13, 3, -36 },
  { 23, 22, 34, 24, 2, -34 },
  { 117, 18, 43, 23, 3, -39 },
  { 214, 25, 34, 31, 3, -34 },
  { 321, 22, 34, 26, 3, -34 },
  { 415, 2, 10, 8, 3, -36 },
  { 418, 9, 49, 13, 3, -38 },
  { 474, 9, 49, 14, 1, -38 },
  { 530, 19, 19, 20, 1, -34 },
  { 576, 20, 25, 24, 2, -28 },
  { 639, 4, 10, 9, 2, -4 },
  { 644, 9, 2, 13, 2, -17 },
  { 647, 4, 3, 11, 3, -3 },
  { 649, 14, 37, 17, 1, -34 },
  { 714, 17, 34, 23, 3, -34 },
  { 787, 10, 34, 23, 4, -34 },
  { 830, 18, 34, 23, 3, -34 },
  { 907, 18, 34, 23, 2, -34 },
  { 984, 20, 34, 23, 2, -34 },
  { 1069, 17, 34, 23, 4, -34 },
  { 1142, 18, 34, 23, 3, -34 },
  { 1219, 19, 34, 23, 2, -34 },
  { 1300, 18, 34, 23, 3, -34 },
  { 1377, 18, 34, 23, 2, -34 },
  { 1454, 3, 25, 9, 3, -25 },
  { 1464, 4, 31, 8, 2, -25 },
  { 1480, 17, 19, 22, 2, -25 },
  { 1521, 17, 12, 23, 3, -22 },
  { 1547, 16, 19, 22, 3, -25 },
  { 1585, 15, 34, 19, 2, -34 },
  { 1649, 32, 44, 38, 3, -33 },
  { 1825, 24, 34, 26, 1, -34 },
  { 1927, 19, 34, 26, 4, -34 },
  { 2008, 21, 34, 27, 3, -34 },
  { 2098, 20, 34, 27, 4, -34 },
  { 2183, 18, 34, 24, 4, -34 },
  { 2260, 18, 34, 24, 4, -34 },
  { 2337, 21, 34, 29, 4, -34 },
  { 2427, 21, 34, 29, 4, -34 },
  { 2517, 2, 34, 12, 5, -34 },
  { 2526, 17, 34, 23, 2, -34 },
  { 2599, 21, 34, 27, 4, -34 },
  { 2689, 17, 34, 22, 4, -34 },
  { 2762, 28, 34, 36, 4, -34 },
  { 2881, 21, 34, 30, 4, -34 },
  { 2971, 22, 34, 28, 3, -34 },
  { 3065, 19, 34, 26, 4, -34 },
  { 3146, 22, 40, 28, 3, -34 },
  { 3256, 20, 34, 27, 4, -34 },
  { 3341, 21, 34, 25, 2, -34 },
  { 3431, 23, 34, 25, 1, -34 },
  { 3529, 20, 34, 28, 4, -34 },
  { 3614, 23, 34, 26, 1, -34 },
  { 3712, 34, 34, 37, 2, -34 },
  { 3857, 22, 34, 25, 2, -34 },
  { 3951, 23, 34, 25, 1, -34 },
  { 4049, 21, 34, 25, 2, -34 },
  { 4139, 6, 46, 10, 4, -39 },
  { 4174, 14, 37, 17, 1, -34 },
  { 4239, 7, 46, 10, 0, -39 },
  { 4280, 13, 17, 18, 2, -34 },
  { 4308, 18, 2, 18, 0, 0 },
  { 4313, 7, 6, 13, 3, -36 },
  { 4319, 17, 26, 23, 2, -26 },
  { 4375, 17, 36, 23, 4, -36 },
  { 4452, 17, 26, 22, 2, -26 },
  { 4508, 17, 36, 23, 3, -36 },
  { 4585, 18, 26, 22, 2, -26 },
  { 4644, 12, 36, 14, 2, -36 },
  { 4698, 17, 36, 23, 3, -26 },
  { 4775, 16, 36, 23, 4, -36 },
  { 4847, 3, 35, 10, 3, -35 },
  { 4861, 8, 45, 10, -2, -35 },
  { 4906, 16, 36, 20, 4, -36 },
  { 4978, 2, 36, 10, 4, -36 },
  { 4987, 31, 26, 37, 3, -26 },
  { 5088, 16, 26, 23, 4, -26 },
  { 5140, 18, 26, 23, 3, -26 },
  { 5199, 17, 36, 23, 4, -26 },
  { 5276, 17, 36, 23, 3, -26 },
  { 5353, 9, 26, 15, 4, -26 },
  { 5383, 16, 26, 21, 2, -26 },
  { 5435, 11, 32, 14, 1, -32 },
  { 5479, 16, 26, 23, 4, -26 },
  { 5531, 18, 26, 20, 1, -26 },
  { 5590, 27, 26, 32, 2, -26 },
  { 5678, 18, 26, 20, 1, -26 },
  { 5737, 18, 36, 20, 1, -26 },
  { 5818, 17, 26, 20, 2, -26 },
  { 5874, 12, 47, 14, 2, -37 },
  { 5945, 2, 40, 10, 4, -34 },
  { 5955, 11, 47, 14, 1, -37 },
  { 6020, 22, 8, 29, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT48PT7B_H_
