#ifndef _ROBOTOCONDENSED_EXTRALIGHT33PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x00, 0x3C, 0xCE, 0x73, 0x9C, 0xC6, 0x20,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x80, 0x42, 0x01,
  0x84, 0x3F, 0xFF, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x00, 0xC2,
  0x01, 0x04, 0x02, 0x08, 0x7F, 0xFE, 0x08, 0x60, 0x10, 0x80, 0x21, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x00, 0x02, 0x00, 0x20, 0x02,
  0x00, 0xF8, 0x30, 0xC6, 0x06, 0x40, 0x24, 0x03, 0x40, 0x14, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x36, 0x02, 0x30, 0xC0, 0xF8, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x38, 0x00, 0x11, 0x00, 0x08, 0x20, 0x02, 0x08,
  0x10, 0x82, 0x08, 0x20, 0x86, 0x08, 0x21, 0x02, 0x08, 0xC0, 0x82, 0x20,
  0x11, 0x10, 0x03, 0x84, 0x00, 0x02, 0x00, 0x00, 0x8F, 0x00, 0x44, 0x60,
  0x33, 0x08, 0x08, 0x82, 0x04, 0x20, 0x81, 0x08, 0x30, 0x82, 0x0C, 0x20,
  0x82, 0x00, 0x30, 0x80, 0x04, 0x60, 0x00, 0xE0, 0x0F, 0x00, 0x33, 0x00,
  0xC3, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x18, 0xC0, 0x13,
  0x00, 0x3C, 0x00, 0x20, 0x00, 0xA0, 0x02, 0x20, 0x48, 0x60, 0xB0, 0x41,
  0x40, 0x46, 0x80, 0x49, 0x00, 0xD2, 0x00, 0xC6, 0x01, 0x84, 0x06, 0x8E,
  0x19, 0x87, 0xC1, 0x00, 0xFE, 0x04, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x10,
  0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0xC0, 0x81, 0x03, 0x02, 0x06, 0x04, 0x04, 0x08, 0x83,
  0x04, 0x08, 0x20, 0x41, 0x06, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x82, 0x10, 0xC2,
  0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x04, 0x30, 0xBD, 0xBC, 0x3F,
  0x00, 0x60, 0x07, 0x80, 0x66, 0x02, 0x10, 0x30, 0x41, 0x02, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x24, 0x96, 0xB0, 0xFE, 0xC8, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x00, 0x0F, 0x03, 0x0C, 0x20, 0x44, 0x02, 0x40, 0x2C, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0x40, 0x24, 0x02, 0x20, 0x63, 0x0C,
  0x0F, 0x00, 0x06, 0x3F, 0x9C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1F,
  0x03, 0x0C, 0x60, 0x64, 0x02, 0x80, 0x28, 0x02, 0x80, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xF0, 0x1F, 0x03,
  0x0C, 0x60, 0x6C, 0x02, 0x80, 0x28, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x01, 0xC0, 0xF8, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x03, 0x60, 0x23, 0x0C, 0x1F, 0x80, 0x00, 0x60, 0x01,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x88, 0x04,
  0x20, 0x20, 0x80, 0x82, 0x04, 0x08, 0x30, 0x20, 0x80, 0x86, 0x02, 0x10,
  0x08, 0xFF, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x7F, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x5F, 0x1E, 0x33, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x34, 0x04, 0x63, 0x87, 0xC0, 0x03, 0xC0,
  0xE0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xCF, 0x89,
  0x8C, 0xA0, 0x6C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C,
  0x01, 0x40, 0x34, 0x02, 0x20, 0x61, 0x8C, 0x0F, 0x80, 0xFF, 0xF8, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x1F,
  0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x1C, 0x03, 0x40,
  0x26, 0x06, 0x30, 0xC1, 0xF8, 0x30, 0xC4, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x03, 0x40, 0x23, 0x0C, 0x1F, 0x80, 0x1F, 0x03,
  0x1C, 0x60, 0x44, 0x02, 0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x3C, 0x03, 0x60, 0x53, 0x19, 0x1F, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0x70, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x09, 0x25, 0xA8, 0x00, 0x10,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x08, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x08, 0x00, 0x3E,
  0x18, 0xCC, 0x1A, 0x02, 0x80, 0xA0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x30, 0x18, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x0E, 0x07, 0x00, 0x60, 0x06,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x88,
  0x0F, 0x01, 0x40, 0x62, 0x05, 0x02, 0x0C, 0x14, 0x18, 0x20, 0x60, 0x40,
  0x81, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x20, 0x20, 0x60, 0x80, 0x81,
  0x82, 0x02, 0x06, 0x08, 0x08, 0x18, 0x20, 0x60, 0x60, 0x81, 0x82, 0xC1,
  0x0A, 0x09, 0x06, 0x6C, 0x44, 0x0E, 0x1E, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02,
  0x40, 0x06, 0x40, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x08,
  0x10, 0x18, 0x10, 0x10, 0x18, 0x10, 0x08, 0x30, 0x08, 0x3F, 0xF8, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80,
  0x03, 0xFF, 0x84, 0x06, 0x20, 0x19, 0x00, 0x68, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x34, 0x01, 0x20, 0x31, 0xFF, 0x08, 0x06, 0x40, 0x1A,
  0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x28, 0x03, 0x40,
  0x73, 0xFE, 0x00, 0x07, 0xE0, 0x38, 0x60, 0xC0, 0x63, 0x00, 0x64, 0x00,
  0x48, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x80,
  0x09, 0x00, 0x13, 0x00, 0x63, 0x00, 0x83, 0x86, 0x01, 0xF8, 0x00, 0xFF,
  0x82, 0x03, 0x08, 0x02, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x22,
  0x03, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x0F, 0xC0, 0xE1, 0xC6, 0x01, 0x90, 0x02, 0xC0, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81,
  0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x50,
  0x01, 0x60, 0x0C, 0x61, 0xE0, 0xFC, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x34, 0x02,
  0x60, 0x63, 0x0C, 0x0F, 0x80, 0x80, 0x0A, 0x00, 0x48, 0x02, 0x20, 0x18,
  0x80, 0xC2, 0x06, 0x08, 0x10, 0x20, 0x80, 0x84, 0x02, 0x30, 0x09, 0x80,
  0x2F, 0x00, 0xE6, 0x03, 0x08, 0x08, 0x10, 0x20, 0x60, 0x80, 0xC2, 0x01,
  0x08, 0x06, 0x20, 0x0C, 0x80, 0x12, 0x00, 0x28, 0x00, 0xC0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x02, 0xD0, 0x00, 0x5A, 0x00, 0x1B, 0x60, 0x02, 0x64, 0x00, 0x4C, 0x80,
  0x19, 0x98, 0x02, 0x31, 0x00, 0x4E, 0x20, 0x11, 0xC2, 0x02, 0x38, 0x40,
  0xC7, 0x0C, 0x10, 0xE0, 0x82, 0x1C, 0x10, 0xC3, 0x83, 0x10, 0x70, 0x22,
  0x0E, 0x04, 0x81, 0xC0, 0x50, 0x38, 0x0A, 0x07, 0x01, 0x80, 0xE0, 0x10,
  0x18, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x68, 0x01, 0xB0, 0x06, 0x40, 0x18,
  0x80, 0x63, 0x01, 0x84, 0x06, 0x18, 0x18, 0x20, 0x60, 0x41, 0x81, 0x06,
  0x02, 0x18, 0x0C, 0x60, 0x11, 0x80, 0x66, 0x00, 0x98, 0x01, 0x60, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x07, 0xC0, 0x38, 0x60, 0xC0, 0x23,
  0x00, 0x24, 0x00, 0x48, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x02, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x23, 0x00, 0x83, 0x86, 0x01,
  0xF8, 0x00, 0xFF, 0x84, 0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0xCF, 0xF8, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x38, 0x60, 0xC0, 0x23, 0x00, 0x64,
  0x00, 0x58, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x02,
  0x80, 0x0D, 0x00, 0x13, 0x00, 0x63, 0x00, 0x83, 0x86, 0x01, 0xFC, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xFF, 0x82, 0x03, 0x88, 0x03,
  0x20, 0x04, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00,
  0x48, 0x03, 0x20, 0x18, 0xFF, 0x82, 0x02, 0x08, 0x08, 0x20, 0x10, 0x80,
  0x62, 0x00, 0x88, 0x03, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xC0,
  0x0F, 0xC0, 0xE1, 0x86, 0x01, 0x10, 0x06, 0xC0, 0x0A, 0x00, 0x28, 0x00,
  0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x02, 0x60,
  0x18, 0xE1, 0xC0, 0xFC, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x36, 0x01, 0x1C,
  0x30, 0x7E, 0x00, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60,
  0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x08, 0x10, 0x18, 0x10,
  0x10, 0x18, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x04,
  0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40, 0x38,
  0x02, 0x40, 0x24, 0x06, 0x60, 0x24, 0x04, 0x20, 0x24, 0x04, 0x20, 0x64,
  0x04, 0x20, 0x42, 0x0C, 0x30, 0x42, 0x0C, 0x10, 0x42, 0x08, 0x10, 0xC2,
  0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x18, 0x18, 0x81, 0x10, 0x09, 0x81,
  0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0xB0, 0x0D, 0x00, 0xB0, 0x06, 0x00,
  0xA0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x40, 0x06,
  0xC0, 0x08, 0x80, 0x31, 0x80, 0x41, 0x01, 0x81, 0x06, 0x03, 0x08, 0x02,
  0x30, 0x06, 0x40, 0x05, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x58,
  0x01, 0x90, 0x06, 0x10, 0x08, 0x30, 0x30, 0x20, 0x40, 0x61, 0x80, 0x42,
  0x00, 0xC8, 0x00, 0xF0, 0x00, 0x80, 0x80, 0x02, 0xC0, 0x06, 0x40, 0x04,
  0x60, 0x0C, 0x20, 0x08, 0x30, 0x18, 0x10, 0x10, 0x08, 0x30, 0x08, 0x20,
  0x04, 0x60, 0x04, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x0C, 0x03, 0x00, 0xC0, 0x48, 0x12, 0x04, 0x82, 0x10, 0x84, 0x21,
  0x18, 0x24, 0x09, 0x02, 0xFF, 0xF0, 0xC3, 0x0C, 0x20, 0x1F, 0x06, 0x39,
  0x01, 0x60, 0x38, 0x02, 0x00, 0x40, 0x08, 0xFF, 0x70, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x2B, 0x19, 0x3E, 0x20, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x16, 0x33, 0x01,
  0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xB0, 0x15, 0x8C, 0x9F, 0x00, 0x1F, 0x06, 0x39, 0x01,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x80, 0x50, 0x11, 0x8E, 0x1F, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1F, 0x26, 0x35, 0x01, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0x50, 0x19, 0x8D, 0x1F, 0x20, 0x1F, 0x06, 0x19, 0x01, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x18, 0x09, 0x86, 0x1F, 0x80, 0x07, 0x86, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0xFF, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x1F, 0x26, 0x35, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x50, 0x19, 0x8D, 0x1F, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x80, 0xCC, 0x30, 0xF8, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x8F, 0x2C, 0x6E, 0x0F, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0xD0, 0x05, 0x55, 0x55, 0x55, 0x54, 0x18,
  0x40, 0x00, 0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x33, 0x70, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xD0, 0x32, 0x0C, 0x43, 0x08, 0xC1,
  0x10, 0x24, 0x05, 0x80, 0xD8, 0x11, 0x02, 0x30, 0x43, 0x08, 0x21, 0x02,
  0x20, 0x64, 0x06, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0x80, 0xCF, 0x83, 0xE6,
  0xC6, 0x31, 0xB8, 0x1A, 0x05, 0xC0, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x10,
  0x07, 0x00, 0x80, 0x38, 0x04, 0x01, 0xC0, 0x20, 0x0E, 0x01, 0x00, 0x70,
  0x08, 0x03, 0x80, 0x40, 0x1C, 0x02, 0x00, 0xE0, 0x10, 0x07, 0x00, 0x80,
  0x38, 0x04, 0x01, 0xC0, 0x20, 0x08, 0x8F, 0x2C, 0x6E, 0x0F, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x1F, 0x83, 0x8C, 0x60, 0x64, 0x02, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14,
  0x02, 0x60, 0x63, 0x9C, 0x0F, 0x80, 0x9F, 0x16, 0x33, 0x01, 0x40, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xB0, 0x17, 0x0C, 0x9F, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x1F, 0x26, 0x35, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x02, 0x80, 0x50, 0x19,
  0x87, 0x1F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x9E, 0xCC, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x1F, 0x0C, 0x33, 0x01, 0x40, 0x28, 0x05, 0x80, 0x18, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x07, 0x00, 0xF0, 0x13, 0x0E, 0x1F,
  0x00, 0x30, 0x60, 0xC1, 0x83, 0x1F, 0xCC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x81, 0xC0, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x14, 0x02, 0x80, 0x58, 0x19, 0x8D, 0x1F, 0x20, 0x80, 0x1C, 0x03,
  0x40, 0x24, 0x02, 0x60, 0x62, 0x04, 0x20, 0x43, 0x0C, 0x10, 0x81, 0x08,
  0x19, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x40, 0x28, 0x0C, 0x05, 0x01, 0x81, 0xA0, 0x50, 0x26, 0x0B, 0x04, 0x41,
  0x20, 0x88, 0x64, 0x31, 0x08, 0x84, 0x31, 0x18, 0x82, 0x21, 0x10, 0x48,
  0x26, 0x09, 0x04, 0x81, 0xA0, 0x50, 0x14, 0x0A, 0x03, 0x01, 0x40, 0x60,
  0x30, 0x0C, 0x02, 0x00, 0x40, 0x26, 0x06, 0x20, 0x43, 0x0C, 0x10, 0x80,
  0x90, 0x0D, 0x00, 0x60, 0x06, 0x00, 0x60, 0x09, 0x01, 0x98, 0x10, 0x83,
  0x0C, 0x20, 0x64, 0x02, 0xC0, 0x30, 0x80, 0x1C, 0x03, 0x40, 0x24, 0x02,
  0x60, 0x62, 0x04, 0x20, 0x43, 0x0C, 0x10, 0x81, 0x08, 0x18, 0x80, 0x90,
  0x09, 0x00, 0xD0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x07, 0x00, 0x7F, 0xE0, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xF0, 0x01, 0x02, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x60,
  0xC0, 0x30, 0x10, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04,
  0x06, 0x03, 0x06, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x30, 0x60, 0x40, 0x1C, 0x02, 0x4C, 0x05, 0x04, 0x0A,
  0x04, 0x3C, 0x0C, 0x58, 0x07, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 23, 7, 2, -23 },
  { 7, 5, 7, 9, 2, -25 },
  { 12, 15, 23, 16, 1, -23 },
  { 56, 12, 29, 16, 2, -26 },
  { 100, 18, 23, 21, 2, -23 },
  { 152, 15, 23, 18, 2, -23 },
  { 196, 1, 7, 6, 2, -25 },
  { 197, 7, 34, 9, 2, -26 },
  { 227, 6, 34, 9, 1, -26 },
  { 253, 13, 13, 14, 0, -23 },
  { 275, 14, 17, 16, 1, -19 },
  { 305, 3, 7, 6, 1, -3 },
  { 308, 7, 1, 9, 1, -11 },
  { 309, 3, 2, 7, 2, -2 },
  { 310, 9, 25, 11, 1, -23 },
  { 339, 12, 23, 16, 2, -23 },
  { 374, 7, 23, 16, 3, -23 },
  { 395, 12, 23, 16, 2, -23 },
  { 430, 12, 23, 16, 2, -23 },
  { 465, 14, 23, 16, 1, -23 },
  { 506, 11, 23, 16, 3, -23 },
  { 538, 12, 23, 16, 2, -23 },
  { 573, 13, 23, 16, 1, -23 },
  { 611, 12, 23, 16, 2, -23 },
  { 646, 12, 23, 16, 2, -23 },
  { 681, 2, 17, 6, 2, -17 },
  { 686, 3, 21, 6, 1, -17 },
  { 694, 12, 13, 15, 1, -17 },
  { 714, 12, 7, 16, 2, -14 },
  { 725, 11, 13, 15, 2, -17 },
  { 743, 10, 23, 13, 2, -23 },
  { 772, 22, 30, 26, 2, -23 },
  { 855, 16, 23, 18, 1, -23 },
  { 901, 13, 23, 18, 3, -23 },
  { 939, 15, 23, 19, 2, -23 },
  { 983, 14, 23, 19, 3, -23 },
  { 1024, 12, 23, 17, 3, -23 },
  { 1059, 12, 23, 16, 3, -23 },
  { 1094, 14, 23, 20, 3, -23 },
  { 1135, 14, 23, 20, 3, -23 },
  { 1176, 2, 23, 8, 3, -23 },
  { 1182, 12, 23, 16, 1, -23 },
  { 1217, 14, 23, 18, 3, -23 },
  { 1258, 11, 23, 15, 3, -23 },
  { 1290, 19, 23, 25, 3, -23 },
  { 1345, 14, 23, 20, 3, -23 },
  { 1386, 15, 23, 19, 2, -23 },
  { 1430, 13, 23, 18, 3, -23 },
  { 1468, 15, 27, 19, 2, -23 },
  { 1519, 14, 23, 19, 3, -23 },
  { 1560, 14, 23, 17, 2, -23 },
  { 1601, 15, 23, 17, 1, -23 },
  { 1645, 13, 23, 19, 3, -23 },
  { 1683, 16, 23, 18, 1, -23 },
  { 1729, 24, 23, 26, 1, -23 },
  { 1798, 15, 23, 18, 1, -23 },
  { 1842, 16, 23, 17, 1, -23 },
  { 1888, 14, 23, 17, 2, -23 },
  { 1929, 4, 32, 7, 3, -27 },
  { 1945, 10, 25, 11, 1, -23 },
  { 1977, 4, 32, 7, 0, -27 },
  { 1993, 10, 12, 12, 1, -23 },
  { 2008, 12, 1, 12, 0, 0 },
  { 2010, 5, 4, 9, 2, -24 },
  { 2013, 11, 17, 15, 2, -17 },
  { 2037, 11, 25, 16, 3, -25 },
  { 2072, 11, 17, 15, 2, -17 },
  { 2096, 11, 25, 16, 2, -25 },
  { 2131, 11, 17, 15, 2, -17 },
  { 2155, 9, 25, 10, 1, -25 },
  { 2184, 11, 24, 16, 2, -17 },
  { 2217, 10, 25, 16, 3, -25 },
  { 2249, 2, 23, 7, 2, -23 },
  { 2255, 5, 30, 7, -1, -23 },
  { 2274, 11, 25, 14, 3, -25 },
  { 2309, 1, 25, 7, 3, -25 },
  { 2313, 21, 17, 25, 2, -17 },
  { 2358, 10, 17, 16, 3, -17 },
  { 2380, 12, 17, 16, 2, -17 },
  { 2406, 11, 24, 16, 3, -17 },
  { 2439, 11, 24, 16, 2, -17 },
  { 2472, 6, 17, 10, 3, -17 },
  { 2485, 11, 17, 15, 2, -17 },
  { 2509, 7, 22, 10, 1, -22 },
  { 2529, 11, 17, 16, 2, -17 },
  { 2553, 12, 17, 14, 1, -17 },
  { 2579, 19, 17, 22, 1, -17 },
  { 2620, 12, 17, 14, 1, -17 },
  { 2646, 12, 24, 14, 1, -17 },
  { 2682, 12, 17, 14, 1, -17 },
  { 2708, 8, 33, 10, 1, -26 },
  { 2741, 1, 27, 7, 3, -23 },
  { 2745, 8, 33, 10, 0, -26 },
  { 2778, 15, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT33PT7B_H_
