#ifndef _ROBOTOCONDENSED_EXTRALIGHT31PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x8C, 0x63, 0x18, 0xC4, 0x02,
  0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0x87, 0xFF, 0xC1,
  0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00,
  0x84, 0x3F, 0xFE, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x42, 0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x83, 0x18, 0xC0, 0x90, 0x1E,
  0x01, 0xC0, 0x38, 0x05, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x40, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x50, 0x19, 0x86, 0x1F,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x38, 0x00, 0x44, 0x00, 0x86, 0x00, 0x82,
  0x08, 0x82, 0x10, 0x82, 0x10, 0x82, 0x20, 0x86, 0x60, 0x44, 0x40, 0x38,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x1E, 0x02, 0x23, 0x02, 0x21, 0x04,
  0x41, 0x0C, 0x41, 0x08, 0x41, 0x10, 0x41, 0x10, 0x21, 0x00, 0x23, 0x00,
  0x1E, 0x0F, 0x00, 0xC6, 0x02, 0x08, 0x08, 0x20, 0x60, 0x81, 0x82, 0x02,
  0x18, 0x08, 0xC0, 0x16, 0x00, 0x70, 0x01, 0x80, 0x09, 0x00, 0x46, 0x09,
  0x0C, 0x28, 0x10, 0xA0, 0x26, 0x80, 0xD2, 0x01, 0xC8, 0x02, 0x30, 0x14,
  0x61, 0x98, 0x7C, 0x20, 0xFC, 0x04, 0x20, 0x84, 0x30, 0x82, 0x10, 0x41,
  0x04, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x40,
  0x82, 0x0C, 0x10, 0x20, 0x81, 0x82, 0x04, 0x08, 0x20, 0x41, 0x04, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x86, 0x10,
  0x41, 0x08, 0x21, 0x08, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x06,
  0x23, 0x9D, 0x70, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x46, 0x04, 0x10, 0x60,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x24, 0xB4, 0xA0, 0xFC, 0xF0, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x1F,
  0x06, 0x31, 0x83, 0x20, 0x2C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x0D,
  0x01, 0x30, 0x63, 0x18, 0x3E, 0x00, 0x04, 0xFE, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1F,
  0x03, 0x18, 0x40, 0xCC, 0x04, 0x80, 0x68, 0x06, 0x80, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x1F, 0x06, 0x31, 0x01,
  0x60, 0x38, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0x3C, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x27,
  0x08, 0x3E, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x34, 0x01,
  0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04, 0x10, 0x60, 0x82, 0x04,
  0x30, 0x21, 0x01, 0x1F, 0xFF, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x9E, 0x1C, 0x32, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x80, 0x50, 0x0A, 0x01, 0x20, 0x66, 0x18, 0x3E, 0x00, 0x03, 0x81,
  0x80, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x8F, 0x16, 0x1B,
  0x81, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x05, 0x01,
  0xB0, 0x23, 0x08, 0x1E, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x1F, 0x06, 0x31, 0x01, 0x60, 0x38, 0x03, 0x00, 0x60, 0x0E,
  0x03, 0x40, 0x46, 0x30, 0x7C, 0x10, 0x64, 0x05, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xA0, 0x36, 0x0C, 0x3E, 0x00, 0x1F, 0x06, 0x31,
  0x03, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x34, 0x0A, 0x43, 0x47, 0x88, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00,
  0xC0, 0x70, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0xDB, 0x69, 0x40, 0x00, 0x20, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x40, 0x00,
  0x1E, 0x0C, 0x64, 0x09, 0x03, 0xC0, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x1C, 0x03, 0x00, 0x30,
  0x30, 0x00, 0xC1, 0x00, 0x02, 0x10, 0x00, 0x08, 0x81, 0xE0, 0x48, 0x18,
  0x82, 0x41, 0x84, 0x0E, 0x08, 0x20, 0x60, 0x81, 0x03, 0x04, 0x08, 0x18,
  0x20, 0x40, 0xC1, 0x02, 0x06, 0x08, 0x10, 0x30, 0x40, 0x81, 0x82, 0x04,
  0x14, 0x10, 0x60, 0xA0, 0x83, 0x0D, 0x06, 0x2C, 0x44, 0x1E, 0x3C, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x81, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x48, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x60, 0x10,
  0x40, 0x60, 0x80, 0x81, 0x81, 0x01, 0x06, 0x02, 0x08, 0x06, 0x1F, 0xFC,
  0x60, 0x08, 0x80, 0x11, 0x00, 0x16, 0x00, 0x28, 0x00, 0x50, 0x00, 0x40,
  0xFF, 0x08, 0x1C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x18, 0xFF, 0x08, 0x0C, 0x80, 0x28, 0x02, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80, 0xCF, 0xF8, 0x0F, 0xC0, 0x61,
  0xC2, 0x01, 0x18, 0x02, 0x40, 0x0B, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x03, 0xC0, 0x0D, 0x00, 0x26, 0x00, 0x88, 0x04, 0x18, 0x70, 0x3F, 0x00,
  0xFF, 0x04, 0x0E, 0x20, 0x19, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0xC8, 0x1C, 0x7F, 0x80,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x98, 0x02, 0x40, 0x05, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x16, 0x00, 0x4C,
  0x03, 0x1C, 0x38, 0x1F, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x38, 0x05, 0x01, 0xA0, 0x23,
  0x18, 0x3E, 0x00, 0x80, 0x14, 0x01, 0x20, 0x19, 0x01, 0x88, 0x18, 0x40,
  0x82, 0x08, 0x10, 0x80, 0x8C, 0x04, 0xC0, 0x2E, 0x01, 0x58, 0x0C, 0x40,
  0x41, 0x02, 0x0C, 0x10, 0x30, 0x80, 0x84, 0x02, 0x20, 0x19, 0x00, 0x48,
  0x01, 0x40, 0x0C, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3A, 0x00, 0x2D, 0x00, 0x16, 0xC0, 0x1B, 0x20, 0x09,
  0x90, 0x04, 0xC4, 0x06, 0x62, 0x02, 0x31, 0x01, 0x18, 0x41, 0x0C, 0x20,
  0x86, 0x18, 0x43, 0x04, 0x41, 0x82, 0x20, 0xC1, 0x90, 0x60, 0x50, 0x30,
  0x28, 0x18, 0x0C, 0x0C, 0x04, 0x04, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40,
  0x1B, 0x00, 0xC8, 0x06, 0x60, 0x31, 0x01, 0x84, 0x0C, 0x20, 0x60, 0x83,
  0x06, 0x18, 0x10, 0xC0, 0xC6, 0x02, 0x30, 0x09, 0x80, 0x4C, 0x01, 0x60,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x04, 0x0F, 0xC0, 0x61, 0xC2, 0x01, 0x10,
  0x02, 0x40, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05,
  0x00, 0x34, 0x00, 0x88, 0x04, 0x18, 0x70, 0x3F, 0x00, 0xFF, 0x88, 0x0C,
  0x80, 0x68, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x28, 0x0C, 0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xC0, 0x61, 0xC2, 0x01, 0x10,
  0x02, 0x40, 0x0B, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05,
  0x00, 0x24, 0x00, 0x88, 0x04, 0x18, 0x70, 0x3F, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0xFF, 0x04, 0x06, 0x20, 0x19, 0x00, 0x48, 0x03,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01, 0x20, 0x19, 0x01, 0x8F,
  0xF0, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x20, 0x09, 0x00,
  0x68, 0x01, 0x40, 0x0C, 0x0F, 0xC0, 0x61, 0xC2, 0x01, 0x98, 0x02, 0x40,
  0x09, 0x00, 0x34, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xB0, 0x03, 0x40, 0x05, 0x00, 0x36,
  0x00, 0x88, 0x06, 0x18, 0x30, 0x3F, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x02, 0x70, 0xE1, 0xF8, 0x80, 0x07, 0x00, 0x09, 0x00,
  0x12, 0x00, 0x64, 0x00, 0x8C, 0x01, 0x08, 0x02, 0x10, 0x08, 0x30, 0x10,
  0x20, 0x20, 0x40, 0xC0, 0xC1, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x02,
  0x20, 0x04, 0xC0, 0x09, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x14, 0x03, 0x00, 0xD0, 0x0A, 0x02,
  0x40, 0x68, 0x09, 0x01, 0x20, 0x22, 0x04, 0x80, 0x88, 0x11, 0x06, 0x20,
  0xC4, 0x10, 0x82, 0x10, 0x43, 0x08, 0x41, 0x04, 0x20, 0x8C, 0x11, 0x82,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x02, 0x40, 0x48, 0x0B, 0x01, 0x60,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x05, 0x00, 0x22, 0x01, 0x8C, 0x04, 0x10, 0x30, 0x60,
  0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x80, 0x13, 0x00, 0xC4, 0x02, 0x18, 0x18, 0x20, 0x40, 0xC2, 0x01, 0x18,
  0x02, 0x40, 0x0F, 0x00, 0x10, 0x80, 0x05, 0x80, 0x19, 0x00, 0x23, 0x00,
  0xC2, 0x01, 0x06, 0x06, 0x04, 0x08, 0x0C, 0x10, 0x08, 0x40, 0x18, 0x80,
  0x12, 0x00, 0x34, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F,
  0xF8, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0xFF, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00,
  0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08,
  0x06, 0x05, 0x02, 0x81, 0x21, 0x10, 0x88, 0x42, 0x41, 0x20, 0x90, 0x20,
  0xFF, 0xE0, 0xC6, 0x21, 0x1F, 0x18, 0x6C, 0x0E, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x7F, 0x60, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0F, 0x0D,
  0x3C, 0x40, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xC7,
  0x86, 0xE0, 0x58, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x05, 0x61, 0xA3, 0xC0, 0x1F, 0x0C,
  0x31, 0x03, 0x40, 0x28, 0x05, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x07, 0x00, 0x90, 0x13, 0x0C, 0x1F, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0x8B, 0x0D, 0x40, 0xB8, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x34, 0x06, 0xC3, 0x47, 0x88, 0x0F, 0x83, 0x0C, 0x20, 0x64, 0x02,
  0x40, 0x24, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x21, 0x86, 0x0F, 0x80, 0x0F, 0x18, 0x10, 0x10,
  0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x2C, 0x35, 0x03, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xD0, 0x1B, 0x0F, 0x1E, 0x60, 0x0C, 0x01, 0x80, 0x24, 0x04,
  0xC3, 0x07, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33,
  0xC6, 0x84, 0xE0, 0x58, 0x0B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0xF0,
  0x05, 0x55, 0x55, 0x55, 0x54, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x18, 0xC4, 0x6E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x36, 0x04, 0xC1,
  0x18, 0x43, 0x18, 0x66, 0x0D, 0x81, 0xA0, 0x3A, 0x06, 0x60, 0xC4, 0x18,
  0x43, 0x0C, 0x60, 0x8C, 0x09, 0x81, 0xB0, 0x10, 0xFF, 0xFF, 0xFE, 0x8F,
  0x07, 0x89, 0x08, 0x86, 0xA0, 0x50, 0x2C, 0x06, 0x02, 0xC0, 0x60, 0x3C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0xCF, 0x1A, 0x13, 0x81, 0x60, 0x2C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0x1F, 0x06, 0x31, 0x01, 0x60, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0xD0, 0x11, 0x8C, 0x1F, 0x00, 0x8F, 0x16, 0x1B, 0x81, 0x60, 0x3C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x17, 0x86, 0xCF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x1E, 0x2C, 0x35, 0x02, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xD0, 0x1B, 0x0F,
  0x1E, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0xCF, 0xA3,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x3E, 0x18, 0x6C, 0x0A, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x18, 0x0D, 0x86, 0x3E, 0x00, 0x20,
  0x40, 0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xC0, 0x81, 0xE0, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x06,
  0x80, 0xD0, 0x39, 0x0F, 0x1E, 0x60, 0x80, 0x30, 0x05, 0x01, 0xA0, 0x24,
  0x04, 0x41, 0x88, 0x21, 0x04, 0x30, 0x82, 0x20, 0x44, 0x0C, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0x30, 0x04, 0x00, 0xC0, 0xC0, 0x50, 0x30, 0x34, 0x0C,
  0x09, 0x03, 0x82, 0x41, 0xA0, 0x88, 0x48, 0x22, 0x12, 0x18, 0x84, 0xC4,
  0x22, 0x11, 0x0C, 0x84, 0x41, 0x21, 0x30, 0x48, 0x28, 0x14, 0x0A, 0x07,
  0x02, 0x80, 0xC0, 0xA0, 0x30, 0x10, 0x08, 0x04, 0x00, 0xC0, 0x68, 0x08,
  0x83, 0x10, 0x41, 0x10, 0x32, 0x02, 0x80, 0x70, 0x04, 0x01, 0x40, 0x2C,
  0x08, 0x81, 0x18, 0x41, 0x18, 0x32, 0x02, 0xC0, 0x20, 0x80, 0x30, 0x05,
  0x01, 0xA0, 0x24, 0x04, 0x41, 0x88, 0x21, 0x04, 0x10, 0x82, 0x20, 0x44,
  0x04, 0x80, 0xA0, 0x14, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x20, 0x38, 0x00, 0x7F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xFF, 0xE0, 0x03, 0x06, 0x0C, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x40, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x0C, 0x06, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x60, 0xC0, 0x3C, 0x05, 0x98,
  0x14, 0x30, 0x60, 0x22, 0x80, 0x70,
};

const GFXglyph RobotoCondensed_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 5, 6, 8, 2, -23 },
  { 11, 14, 22, 15, 1, -22 },
  { 50, 11, 28, 15, 2, -25 },
  { 89, 16, 22, 20, 2, -22 },
  { 133, 14, 22, 17, 2, -22 },
  { 172, 1, 6, 5, 2, -23 },
  { 173, 6, 32, 9, 2, -25 },
  { 197, 6, 32, 9, 1, -25 },
  { 221, 13, 12, 13, 0, -22 },
  { 241, 13, 16, 15, 1, -18 },
  { 267, 3, 7, 6, 1, -3 },
  { 270, 6, 1, 8, 1, -10 },
  { 271, 2, 2, 7, 2, -2 },
  { 272, 9, 24, 11, 1, -22 },
  { 299, 11, 22, 15, 2, -22 },
  { 330, 6, 22, 15, 3, -22 },
  { 347, 12, 22, 15, 2, -22 },
  { 380, 11, 22, 15, 2, -22 },
  { 411, 13, 22, 15, 1, -22 },
  { 447, 11, 22, 15, 3, -22 },
  { 478, 11, 22, 15, 2, -22 },
  { 509, 12, 22, 15, 1, -22 },
  { 542, 11, 22, 15, 2, -22 },
  { 573, 11, 22, 15, 2, -22 },
  { 604, 2, 16, 6, 2, -16 },
  { 608, 3, 20, 5, 1, -16 },
  { 616, 11, 12, 14, 1, -16 },
  { 633, 11, 7, 15, 2, -14 },
  { 643, 11, 12, 14, 2, -16 },
  { 660, 10, 22, 12, 1, -22 },
  { 688, 21, 28, 25, 2, -21 },
  { 762, 15, 22, 17, 1, -22 },
  { 804, 12, 22, 17, 3, -22 },
  { 837, 14, 22, 18, 2, -22 },
  { 876, 13, 22, 18, 3, -22 },
  { 912, 11, 22, 16, 3, -22 },
  { 943, 11, 22, 15, 3, -22 },
  { 974, 14, 22, 19, 2, -22 },
  { 1013, 13, 22, 19, 3, -22 },
  { 1049, 1, 22, 8, 3, -22 },
  { 1052, 11, 22, 15, 1, -22 },
  { 1083, 13, 22, 17, 3, -22 },
  { 1119, 10, 22, 14, 3, -22 },
  { 1147, 17, 22, 23, 3, -22 },
  { 1194, 13, 22, 19, 3, -22 },
  { 1230, 14, 22, 18, 2, -22 },
  { 1269, 12, 22, 17, 3, -22 },
  { 1302, 14, 26, 18, 2, -22 },
  { 1348, 13, 22, 17, 3, -22 },
  { 1384, 14, 22, 16, 1, -22 },
  { 1423, 14, 22, 16, 1, -22 },
  { 1462, 12, 22, 18, 3, -22 },
  { 1495, 15, 22, 17, 1, -22 },
  { 1537, 22, 22, 24, 1, -22 },
  { 1598, 14, 22, 16, 1, -22 },
  { 1637, 15, 22, 16, 1, -22 },
  { 1679, 14, 22, 16, 1, -22 },
  { 1718, 4, 30, 7, 2, -25 },
  { 1733, 9, 24, 11, 1, -22 },
  { 1760, 4, 30, 7, 0, -25 },
  { 1775, 9, 11, 11, 1, -22 },
  { 1788, 11, 1, 12, 0, 0 },
  { 1790, 4, 4, 8, 2, -23 },
  { 1792, 10, 17, 15, 2, -17 },
  { 1814, 11, 23, 15, 2, -23 },
  { 1846, 11, 17, 14, 2, -17 },
  { 1870, 11, 23, 15, 2, -23 },
  { 1902, 12, 17, 14, 1, -17 },
  { 1928, 8, 23, 9, 1, -23 },
  { 1951, 11, 23, 15, 2, -17 },
  { 1983, 11, 23, 15, 2, -23 },
  { 2015, 2, 23, 6, 2, -23 },
  { 2021, 5, 29, 6, -1, -23 },
  { 2040, 11, 23, 13, 2, -23 },
  { 2072, 1, 23, 6, 3, -23 },
  { 2075, 20, 17, 24, 2, -17 },
  { 2118, 11, 17, 15, 2, -17 },
  { 2142, 11, 17, 15, 2, -17 },
  { 2166, 11, 23, 15, 2, -17 },
  { 2198, 11, 23, 15, 2, -17 },
  { 2230, 7, 17, 9, 2, -17 },
  { 2245, 10, 17, 14, 2, -17 },
  { 2267, 7, 21, 9, 1, -21 },
  { 2286, 11, 17, 15, 2, -17 },
  { 2310, 11, 17, 13, 1, -17 },
  { 2334, 18, 17, 20, 1, -17 },
  { 2373, 11, 17, 13, 1, -17 },
  { 2397, 11, 23, 13, 1, -17 },
  { 2429, 11, 17, 13, 1, -17 },
  { 2453, 8, 30, 9, 1, -24 },
  { 2483, 1, 26, 6, 3, -22 },
  { 2487, 8, 30, 9, 0, -24 },
  { 2517, 14, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT31PT7B_H_
