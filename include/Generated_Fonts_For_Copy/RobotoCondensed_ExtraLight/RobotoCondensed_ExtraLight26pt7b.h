#ifndef _ROBOTOCONDENSED_EXTRALIGHT26PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x60, 0x99, 0x99, 0x90, 0x04, 0x40, 0x44, 0x08, 0x40,
  0x84, 0x08, 0x47, 0xFF, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x11, 0x0F, 0xFE, 0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x22, 0x00,
  0x04, 0x01, 0x01, 0xF0, 0x86, 0x60, 0x90, 0x14, 0x05, 0x01, 0x40, 0x08,
  0x01, 0x80, 0x38, 0x01, 0x00, 0x20, 0x06, 0x01, 0x40, 0x50, 0x14, 0x0C,
  0x82, 0x1F, 0x01, 0x00, 0x40, 0x38, 0x01, 0x10, 0x04, 0x40, 0x21, 0x08,
  0x82, 0x22, 0x11, 0x04, 0x48, 0x11, 0x20, 0x39, 0x00, 0x04, 0x00, 0x23,
  0x80, 0x91, 0x04, 0x44, 0x12, 0x10, 0x88, 0x42, 0x21, 0x10, 0x44, 0x01,
  0x10, 0x03, 0x80, 0x0E, 0x01, 0x10, 0x21, 0x02, 0x08, 0x21, 0x02, 0x10,
  0x32, 0x01, 0x40, 0x08, 0x01, 0x80, 0x24, 0x04, 0x21, 0x43, 0x1C, 0x12,
  0x80, 0xA4, 0x06, 0x40, 0x42, 0x1A, 0x1E, 0x10, 0xF8, 0x08, 0x88, 0x44,
  0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21, 0x04,
  0x20, 0x82, 0x84, 0x10, 0x82, 0x10, 0x42, 0x10, 0x84, 0x21, 0x04, 0x42,
  0x10, 0x84, 0x21, 0x10, 0x88, 0x44, 0x20, 0x04, 0x00, 0x80, 0x10, 0x22,
  0x23, 0x58, 0x1C, 0x02, 0x80, 0xC8, 0x11, 0x84, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x55, 0x80, 0xF8, 0xB0, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x00, 0x3C, 0x31, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x41, 0x31, 0x0F, 0x00,
  0x0C, 0xDC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x40, 0x1E, 0x08, 0x64, 0x09, 0x02, 0x40, 0x60, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x10, 0x07, 0xFC, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x40, 0x40, 0x10, 0x04,
  0x02, 0x01, 0x03, 0x80, 0x18, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x40,
  0xC8, 0x21, 0xF0, 0x01, 0x00, 0x20, 0x0C, 0x02, 0x80, 0x50, 0x12, 0x02,
  0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x20, 0x84, 0x11, 0xFF, 0xC0, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xBC, 0x63, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01,
  0x40, 0xB0, 0x87, 0x80, 0x0E, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x3C, 0xE3, 0x40, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x31,
  0x87, 0x80, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x40, 0x50, 0x14, 0x05, 0x02,
  0x21, 0x87, 0x82, 0x19, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01, 0x40, 0x48,
  0x21, 0xF0, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x40, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x14, 0x0C, 0x85, 0x1E, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x83, 0xC0, 0xC0, 0x0C, 0x50, 0x00, 0x00, 0x55, 0x80, 0x00, 0x81, 0x81,
  0x83, 0x06, 0x04, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x20, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x0C, 0x18, 0x30, 0x60, 0x20, 0x00, 0x3C, 0x62, 0x41, 0x81, 0x81,
  0x01, 0x01, 0x03, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x26, 0x00,
  0x12, 0x0F, 0x05, 0x08, 0x43, 0x04, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61,
  0x04, 0x31, 0x02, 0x18, 0x82, 0x0C, 0x41, 0x06, 0x20, 0x83, 0x08, 0x42,
  0x84, 0x51, 0x41, 0xC7, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x40, 0x0F, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x09,
  0x00, 0x90, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x3F,
  0xC4, 0x02, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFE, 0x20,
  0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81, 0xBF, 0xC8, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x2F, 0xF0, 0x1F, 0x04,
  0x19, 0x01, 0x60, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0E, 0x01, 0x40, 0x44, 0x18, 0x7C,
  0x00, 0xFE, 0x10, 0x32, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80,
  0x50, 0x33, 0xF8, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x1F, 0x04, 0x19, 0x00, 0xA0, 0x18, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0A, 0x01, 0x40, 0x26, 0x0C, 0x3E, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x41, 0xB0, 0x8F,
  0x80, 0x80, 0x68, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x60, 0x84, 0x08,
  0x80, 0x90, 0x0A, 0x80, 0xEC, 0x0C, 0x40, 0x82, 0x08, 0x10, 0x81, 0x08,
  0x08, 0x80, 0x48, 0x06, 0x80, 0x20, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x3F, 0xE0, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1D, 0x00, 0x3A,
  0x00, 0xB2, 0x01, 0x64, 0x04, 0xC8, 0x09, 0x88, 0x13, 0x10, 0x46, 0x20,
  0x8C, 0x21, 0x18, 0x44, 0x30, 0x88, 0x60, 0x90, 0xC1, 0x41, 0x82, 0x83,
  0x03, 0x06, 0x04, 0x08, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19,
  0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x61, 0x82, 0x18, 0x11, 0x81, 0x18,
  0x09, 0x80, 0x98, 0x05, 0x80, 0x58, 0x03, 0x80, 0x30, 0x1F, 0x02, 0x0C,
  0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0x28, 0x02, 0x40, 0x42, 0x0C,
  0x1F, 0x00, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x02, 0x80, 0x50, 0x13, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x02, 0x0C, 0x40, 0x48, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x40, 0x42, 0x0C, 0x1F, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0x60, 0x14,
  0x02, 0x80, 0x50, 0x13, 0xFC, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24, 0x06,
  0x80, 0x50, 0x0E, 0x00, 0x80, 0x1F, 0x04, 0x19, 0x01, 0xA0, 0x14, 0x02,
  0x80, 0x10, 0x01, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x0A, 0x01, 0x40, 0x26, 0x18, 0x7E, 0x00, 0xFF, 0xF0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40,
  0x4C, 0x18, 0x7C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x08, 0x10, 0x81, 0x08, 0x11, 0x00,
  0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x12,
  0x08, 0x84, 0x42, 0x21, 0x10, 0x88, 0x84, 0x42, 0x21, 0x10, 0x88, 0x24,
  0x12, 0x09, 0x05, 0x02, 0x41, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x06, 0x02,
  0x01, 0x80, 0x80, 0x40, 0x80, 0x24, 0x02, 0x60, 0x42, 0x04, 0x10, 0x81,
  0x08, 0x09, 0x00, 0xB0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x19, 0x01,
  0x08, 0x30, 0x82, 0x04, 0x40, 0x64, 0x02, 0x80, 0x30, 0x80, 0x18, 0x02,
  0x40, 0x24, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x10, 0x09, 0x00, 0xA0,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x7F, 0xE0, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x03, 0xFF, 0x80, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0xE0, 0x81, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10,
  0x30, 0xA1, 0x42, 0x48, 0x91, 0x21, 0x82, 0xFF, 0xC0, 0x88, 0x80, 0x1E,
  0x30, 0x90, 0x28, 0x10, 0x08, 0x04, 0x7E, 0xC1, 0x40, 0xC0, 0x60, 0x30,
  0x34, 0x39, 0xE4, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0xC2,
  0xC1, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xB0,
  0x57, 0xC0, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x09, 0x02, 0x21, 0x87, 0x80, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x11, 0xE4, 0x85, 0x40, 0xD0, 0x14, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x01, 0x40, 0x50, 0x32, 0x14, 0x79, 0x1E, 0x08, 0x44,
  0x09, 0x02, 0x80, 0x60, 0x1F, 0xFE, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x87, 0xC0, 0x1E, 0x60, 0x81, 0x02, 0x04, 0x3F, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x1E, 0x48, 0x54,
  0x0D, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x05, 0x03,
  0x21, 0x47, 0x90, 0x04, 0x02, 0x00, 0x88, 0x61, 0xF0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x79, 0x42, 0xC1, 0x40, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0xC7, 0xFF, 0xE0, 0x11,
  0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x05, 0x04, 0x84, 0x44, 0x24, 0x16,
  0x0F, 0x06, 0x82, 0x21, 0x18, 0x84, 0x41, 0x20, 0x50, 0x20, 0xFF, 0xFF,
  0xF0, 0x9E, 0x3C, 0xA3, 0x42, 0xC1, 0x81, 0x81, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x9E, 0x50, 0xB0, 0x50, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x1F, 0x08, 0x64,
  0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x05, 0x02,
  0x21, 0x87, 0xC0, 0x9E, 0x70, 0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x2C, 0x15, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x00, 0x1E, 0x48, 0x54, 0x0D, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x50, 0x14, 0x05, 0x03, 0x21, 0x47, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x9D, 0x31, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x3E, 0x30,
  0x90, 0x28, 0x14, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x28, 0x14,
  0x11, 0xF0, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x18, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x34, 0x29, 0xE4, 0x80, 0xC0, 0x60, 0x28, 0x24, 0x12, 0x08,
  0x88, 0x44, 0x22, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x40, 0x81, 0x03, 0x02,
  0x05, 0x0A, 0x12, 0x14, 0x24, 0x28, 0x48, 0x50, 0x89, 0x12, 0x12, 0x24,
  0x24, 0x48, 0x50, 0x90, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x02, 0x00,
  0x80, 0xA0, 0x98, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x14, 0x11, 0x08,
  0x88, 0x24, 0x14, 0x04, 0x80, 0xC0, 0x70, 0x28, 0x24, 0x12, 0x08, 0x88,
  0x44, 0x22, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18,
  0x38, 0x00, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x07, 0xFC, 0x04, 0x21, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x08, 0xC0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x02,
  0x04, 0xFF, 0xFF, 0xFC, 0xC0, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x40, 0x61, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x10, 0xC0, 0x78, 0x1C, 0xC1, 0x82, 0x28, 0x1C,
};

const GFXglyph RobotoCondensed_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 5, 7, 2, -20 },
  { 7, 12, 19, 13, 1, -19 },
  { 36, 10, 23, 13, 1, -21 },
  { 65, 14, 19, 17, 1, -19 },
  { 99, 12, 19, 14, 1, -19 },
  { 128, 1, 5, 4, 2, -20 },
  { 129, 5, 27, 7, 2, -21 },
  { 146, 5, 27, 7, 1, -21 },
  { 163, 11, 10, 11, 0, -19 },
  { 177, 11, 13, 13, 1, -15 },
  { 195, 2, 5, 5, 1, -2 },
  { 197, 5, 1, 7, 1, -9 },
  { 198, 2, 2, 6, 2, -2 },
  { 199, 7, 21, 9, 1, -19 },
  { 218, 9, 19, 13, 2, -19 },
  { 240, 6, 19, 13, 2, -19 },
  { 255, 10, 19, 13, 1, -19 },
  { 279, 10, 19, 13, 1, -19 },
  { 303, 11, 19, 13, 1, -19 },
  { 330, 9, 19, 13, 2, -19 },
  { 352, 9, 19, 13, 2, -19 },
  { 374, 10, 19, 13, 1, -19 },
  { 398, 10, 19, 13, 1, -19 },
  { 422, 10, 19, 13, 1, -19 },
  { 446, 1, 14, 5, 2, -14 },
  { 448, 2, 17, 5, 1, -14 },
  { 453, 9, 11, 12, 1, -14 },
  { 466, 9, 7, 13, 2, -12 },
  { 474, 9, 11, 12, 2, -14 },
  { 487, 8, 19, 10, 1, -19 },
  { 506, 17, 24, 21, 2, -18 },
  { 557, 12, 19, 14, 1, -19 },
  { 586, 10, 19, 14, 2, -19 },
  { 610, 11, 19, 15, 2, -19 },
  { 637, 11, 19, 15, 2, -19 },
  { 664, 10, 19, 13, 2, -19 },
  { 688, 10, 19, 13, 2, -19 },
  { 712, 11, 19, 16, 2, -19 },
  { 739, 12, 19, 16, 2, -19 },
  { 768, 1, 19, 6, 3, -19 },
  { 771, 9, 19, 13, 1, -19 },
  { 793, 12, 19, 14, 2, -19 },
  { 822, 9, 19, 12, 2, -19 },
  { 844, 15, 19, 19, 2, -19 },
  { 880, 12, 19, 16, 2, -19 },
  { 909, 12, 19, 15, 2, -19 },
  { 938, 11, 19, 14, 2, -19 },
  { 965, 12, 22, 15, 2, -19 },
  { 998, 11, 19, 15, 2, -19 },
  { 1025, 11, 19, 13, 1, -19 },
  { 1052, 12, 19, 14, 1, -19 },
  { 1081, 11, 19, 15, 2, -19 },
  { 1108, 12, 19, 14, 1, -19 },
  { 1137, 18, 19, 20, 1, -19 },
  { 1180, 12, 19, 14, 1, -19 },
  { 1209, 12, 19, 14, 1, -19 },
  { 1238, 11, 19, 14, 1, -19 },
  { 1265, 3, 25, 6, 2, -21 },
  { 1275, 7, 21, 9, 1, -19 },
  { 1294, 4, 25, 6, 0, -21 },
  { 1307, 7, 9, 10, 1, -19 },
  { 1315, 10, 1, 10, 0, 0 },
  { 1317, 3, 3, 7, 2, -19 },
  { 1319, 9, 14, 12, 1, -14 },
  { 1335, 9, 20, 13, 2, -20 },
  { 1358, 10, 14, 12, 1, -14 },
  { 1376, 10, 20, 13, 1, -20 },
  { 1401, 10, 14, 12, 1, -14 },
  { 1419, 7, 20, 8, 1, -20 },
  { 1437, 10, 19, 13, 1, -14 },
  { 1461, 9, 20, 13, 2, -20 },
  { 1484, 1, 19, 5, 2, -19 },
  { 1487, 4, 24, 5, -1, -19 },
  { 1499, 9, 20, 11, 2, -20 },
  { 1522, 1, 20, 5, 2, -20 },
  { 1525, 16, 14, 20, 2, -14 },
  { 1553, 9, 14, 13, 2, -14 },
  { 1569, 10, 14, 13, 1, -14 },
  { 1587, 9, 19, 13, 2, -14 },
  { 1609, 10, 19, 13, 1, -14 },
  { 1633, 5, 14, 8, 2, -14 },
  { 1642, 9, 14, 12, 1, -14 },
  { 1658, 5, 17, 8, 1, -17 },
  { 1669, 9, 14, 13, 2, -14 },
  { 1685, 9, 14, 11, 1, -14 },
  { 1701, 15, 14, 17, 1, -14 },
  { 1728, 9, 14, 11, 1, -14 },
  { 1744, 9, 19, 11, 1, -14 },
  { 1766, 9, 14, 11, 1, -14 },
  { 1782, 6, 25, 8, 1, -20 },
  { 1801, 1, 22, 5, 2, -19 },
  { 1804, 7, 25, 8, 0, -20 },
  { 1826, 12, 4, 16, 2, -10 },
};

const GFXfont RobotoCondensed_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT26PT7B_H_
