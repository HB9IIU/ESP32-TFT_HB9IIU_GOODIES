#ifndef _ROBOTOCONDENSED_EXTRALIGHT42PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0xC7, 0x1C, 0x71,
  0xC7, 0x38, 0xE3, 0x8C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0x81, 0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x10, 0x03,
  0x06, 0x0F, 0xFF, 0xFC, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C,
  0x08, 0x01, 0x83, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x10,
  0x20, 0x06, 0x04, 0x0F, 0xFF, 0xFC, 0x18, 0x30, 0x02, 0x06, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x03, 0xE0, 0x0F, 0x78, 0x18, 0x0C, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x60, 0x02, 0x30, 0x06, 0x38, 0x0C, 0x0F, 0x78, 0x07, 0xE0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x66,
  0x00, 0x01, 0x82, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x04, 0x18, 0x08,
  0x18, 0x30, 0x10, 0x60, 0x60, 0x20, 0x80, 0xC0, 0x43, 0x01, 0x81, 0x84,
  0x01, 0x03, 0x18, 0x03, 0x04, 0x20, 0x03, 0x30, 0xC0, 0x03, 0xC1, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0xF0, 0x00, 0xC3, 0x30,
  0x01, 0x0C, 0x30, 0x06, 0x10, 0x20, 0x08, 0x60, 0x60, 0x30, 0xC0, 0x40,
  0x41, 0x80, 0x81, 0x83, 0x01, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x10,
  0x08, 0x10, 0x00, 0x18, 0x60, 0x00, 0x19, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x01, 0xFE, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0x21,
  0x80, 0x06, 0x60, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x4C,
  0x00, 0x18, 0xC0, 0x46, 0x18, 0x09, 0x81, 0x81, 0x30, 0x18, 0x24, 0x01,
  0x0D, 0x80, 0x31, 0xB0, 0x03, 0x26, 0x00, 0x3C, 0x40, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x1E, 0x18, 0x06, 0x61, 0xFF, 0x8C, 0x0F, 0xC0, 0xC0, 0xFF,
  0x80, 0x01, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x20,
  0x60, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x81, 0x83, 0xF1, 0x8F, 0x1F, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x02,
  0xC0, 0x06, 0x60, 0x0C, 0x30, 0x18, 0x18, 0x10, 0x18, 0x10, 0x08, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x6D, 0xB6,
  0xD6, 0x80, 0xFF, 0x80, 0x5F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xF0,
  0x18, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x02,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x60, 0x06, 0x30, 0x06,
  0x30, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0x0F, 0x3D, 0xE1,
  0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06,
  0x40, 0x06, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x7F, 0xFF, 0x07, 0xE0, 0x0F, 0xF8, 0x38, 0x0C, 0x30, 0x04, 0x60, 0x06,
  0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x60, 0x02, 0x30, 0x06, 0x38, 0x0C, 0x0F, 0x78,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x06,
  0x80, 0x06, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00,
  0x82, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0x60, 0x40, 0x60, 0x20, 0x20, 0x10,
  0x30, 0x08, 0x10, 0x04, 0x18, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x87, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFE, 0x7F, 0xFC, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x3F, 0x07, 0xFF, 0x0E, 0x03, 0x08, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x70,
  0x00, 0xA0, 0x03, 0x40, 0x06, 0xC0, 0x0C, 0x80, 0x31, 0xC0, 0xC1, 0xFF,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x1F, 0x04,
  0xFF, 0x8B, 0x01, 0x94, 0x01, 0xB0, 0x03, 0x60, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x04, 0xC0, 0x19, 0x80, 0x31, 0x80, 0xC1, 0xEF, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x30, 0x06,
  0x18, 0x0C, 0x0F, 0xF8, 0x07, 0xF0, 0x1C, 0x18, 0x30, 0x0C, 0x60, 0x06,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x40, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x0C, 0x1F, 0x78, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x04, 0x60, 0x06,
  0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x07, 0x60, 0x07, 0x30, 0x0F, 0x38, 0x1B,
  0x1E, 0xF2, 0x07, 0xC2, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x0F, 0xC0, 0x0F, 0x00,
  0x5B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x4D, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x36, 0xDB, 0x6B, 0x40, 0x00, 0x04, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0x81, 0xEF, 0x18, 0x18, 0xC0,
  0x6C, 0x01, 0x60, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x31, 0x80, 0x1E, 0x00, 0x8C, 0x03, 0x9C, 0x04, 0x40,
  0x30, 0x20, 0x26, 0x03, 0x01, 0x01, 0xB0, 0x10, 0x08, 0x0D, 0x01, 0x80,
  0x40, 0x28, 0x0C, 0x02, 0x01, 0x40, 0x40, 0x10, 0x0A, 0x02, 0x01, 0x80,
  0x50, 0x30, 0x0C, 0x02, 0x81, 0x80, 0x60, 0x34, 0x0C, 0x03, 0x01, 0xA0,
  0x60, 0x18, 0x0D, 0x03, 0x00, 0xC0, 0x48, 0x18, 0x04, 0x02, 0x40, 0xC0,
  0x60, 0x32, 0x02, 0x07, 0x81, 0x18, 0x18, 0x24, 0x18, 0xC0, 0x7E, 0x31,
  0x82, 0x01, 0xE0, 0xF8, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x20, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x0C,
  0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x01, 0x00, 0x10, 0x0C, 0x00, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x0C,
  0x02, 0x00, 0x60, 0x30, 0x01, 0x01, 0xFF, 0xFC, 0x08, 0x00, 0x60, 0xC0,
  0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x08,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x08, 0xFF, 0xC0, 0x81, 0xF0,
  0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0xF0,
  0xFF, 0xF0, 0x80, 0x1C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x0C, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xEF,
  0x81, 0x80, 0x70, 0xC0, 0x04, 0x60, 0x01, 0x98, 0x00, 0x24, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x03, 0x60, 0x00, 0x98, 0x00, 0x63, 0x00, 0x10, 0x60, 0x1C, 0x0F,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x40, 0xF8, 0x20, 0x07, 0x10, 0x01,
  0xC8, 0x00, 0x64, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x40, 0x03, 0x20,
  0x03, 0x90, 0x03, 0x8F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xBF, 0xFF,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xF7, 0xC0, 0x70, 0x0C, 0x18, 0x00, 0xC3,
  0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x12, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x66, 0x00, 0x0C, 0x60, 0x03, 0x8E, 0x00, 0xE0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x02, 0xC0, 0x05, 0x80, 0x19, 0x80, 0x61, 0x81, 0xC1, 0xFF,
  0x01, 0xF8, 0x00, 0x80, 0x01, 0xA0, 0x00, 0xC8, 0x00, 0x62, 0x00, 0x30,
  0x80, 0x18, 0x20, 0x06, 0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0xC0, 0x20,
  0x60, 0x08, 0x38, 0x02, 0x0C, 0x00, 0x86, 0x00, 0x23, 0x00, 0x09, 0xE0,
  0x02, 0xCC, 0x00, 0xE3, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x02, 0x01, 0x80,
  0x80, 0x60, 0x20, 0x0C, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x0C, 0x20,
  0x01, 0x88, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x30, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xA0, 0x00, 0x0F, 0xA0, 0x00, 0x0B, 0xB0, 0x00, 0x1B, 0x90, 0x00,
  0x1B, 0x98, 0x00, 0x13, 0x98, 0x00, 0x33, 0x88, 0x00, 0x33, 0x8C, 0x00,
  0x23, 0x8C, 0x00, 0x63, 0x84, 0x00, 0x63, 0x86, 0x00, 0x43, 0x86, 0x00,
  0xC3, 0x82, 0x00, 0xC3, 0x83, 0x00, 0x83, 0x81, 0x01, 0x83, 0x81, 0x01,
  0x03, 0x81, 0x83, 0x03, 0x80, 0x83, 0x03, 0x80, 0xC2, 0x03, 0x80, 0xC6,
  0x03, 0x80, 0x46, 0x03, 0x80, 0x64, 0x03, 0x80, 0x6C, 0x03, 0x80, 0x2C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x10, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x64, 0x00, 0x19,
  0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x20, 0x06, 0x0C,
  0x01, 0x81, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x60, 0x08, 0x18, 0x03, 0x06, 0x00, 0x41, 0x80, 0x18, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x19, 0x80, 0x02, 0x60, 0x00, 0xD8, 0x00, 0x16, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x60,
  0x1C, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x02, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x16, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x03,
  0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x80, 0xF8, 0x80, 0x0C,
  0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06,
  0x80, 0x0C, 0xFF, 0xF8, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x60,
  0x1C, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x02, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x16, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x03,
  0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x40, 0x7C, 0x20, 0x03,
  0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x24, 0x00, 0x32,
  0x00, 0x31, 0xFF, 0xF0, 0xFF, 0xE0, 0x40, 0x30, 0x20, 0x0C, 0x10, 0x06,
  0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x31, 0x00, 0x18, 0x80, 0x06, 0x40,
  0x03, 0x20, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x0C, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0x80, 0x70, 0xC0, 0x04, 0x60, 0x01, 0x98, 0x00, 0x24,
  0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x23, 0x00, 0x18, 0xE0,
  0x1C, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0D, 0x00, 0x03, 0x60, 0x00, 0x98, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x1C,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00,
  0x36, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00,
  0x0C, 0x10, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0x80, 0x18, 0x0C,
  0x01, 0x80, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x40, 0x30, 0x06, 0x02, 0x00,
  0x60, 0x60, 0x02, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x10, 0xC0,
  0x01, 0x88, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x09, 0x00, 0x00, 0xD0,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x01, 0x00, 0x05,
  0x00, 0x0E, 0x00, 0x36, 0x00, 0x28, 0x00, 0xD8, 0x00, 0xA0, 0x03, 0x60,
  0x02, 0x80, 0x08, 0x80, 0x1B, 0x00, 0x23, 0x00, 0x6C, 0x01, 0x8C, 0x01,
  0x10, 0x06, 0x30, 0x04, 0x40, 0x18, 0x40, 0x31, 0x80, 0x41, 0x00, 0xC6,
  0x03, 0x06, 0x02, 0x08, 0x0C, 0x18, 0x08, 0x20, 0x30, 0x60, 0x60, 0xC0,
  0x80, 0x81, 0x83, 0x02, 0x02, 0x04, 0x04, 0x18, 0x0C, 0x10, 0x10, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0x43, 0x01, 0x84, 0x01, 0x08, 0x02, 0x10, 0x06,
  0x20, 0x08, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xC8, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x05, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18,
  0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x02, 0x06, 0x00,
  0x30, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x09, 0x80, 0x01, 0x88,
  0x00, 0x30, 0xC0, 0x03, 0x04, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x01, 0x81, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x60,
  0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x62,
  0x00, 0x04, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x80, 0x80, 0x10,
  0x0C, 0x03, 0x00, 0x40, 0x20, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C,
  0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x04, 0x01, 0xC0, 0x38, 0x05, 0x81, 0xB0,
  0x32, 0x04, 0x61, 0x8C, 0x30, 0x84, 0x19, 0x83, 0x30, 0x24, 0x07, 0x80,
  0xF0, 0x08, 0xFF, 0xFE, 0xC1, 0x86, 0x0C, 0x18, 0x20, 0x07, 0xE0, 0x3D,
  0xF0, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x48, 0x00, 0x90, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x1F, 0xF0, 0xF8, 0x27, 0x00, 0x4C, 0x00, 0xB0,
  0x01, 0x60, 0x02, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x73, 0x01, 0xA3, 0xFE,
  0x63, 0xF0, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x1F, 0x86,
  0xF7, 0x8F, 0x01, 0x9C, 0x01, 0xB0, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x6E, 0x00, 0xDE, 0x03, 0x37,
  0xFC, 0x63, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00,
  0x48, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x40, 0x06, 0xC0,
  0x0D, 0x80, 0x31, 0x80, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x1F, 0x08, 0xF7, 0x93, 0x01, 0xA4, 0x01, 0xD8,
  0x01, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x80, 0x0B,
  0x00, 0x32, 0x00, 0x66, 0x03, 0x47, 0xFC, 0x83, 0xE1, 0x07, 0xE0, 0x3F,
  0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0x48, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x11, 0xC0, 0x61, 0xFF,
  0x80, 0xFC, 0x00, 0x03, 0xC3, 0xF0, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x0F, 0xF8, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x07, 0xC2, 0x3D, 0xE4, 0xC0,
  0x69, 0x00, 0x76, 0x00, 0x68, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0xC0, 0x0C, 0x80, 0x39, 0x80, 0xD1, 0xFF, 0x20, 0xF8,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x19, 0x00, 0x23,
  0x00, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x3E, 0x33, 0xFC, 0xD8, 0x1B, 0xC0, 0x2E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xDF, 0xBC, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x01, 0xB0, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x30,
  0x60, 0xC3, 0x03, 0x18, 0x0C, 0xC0, 0x37, 0x00, 0xFC, 0x03, 0x98, 0x0C,
  0x30, 0x30, 0xC0, 0xC1, 0x83, 0x03, 0x0C, 0x04, 0x30, 0x18, 0xC0, 0x33,
  0x00, 0x6C, 0x01, 0xB0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xE0, 0x3E, 0x33, 0xBC, 0x3F, 0xCD, 0x81, 0x98, 0x1B, 0xC0,
  0x2C, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x07,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0,
  0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C,
  0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00,
  0x10, 0xC3, 0xE3, 0x3F, 0xCD, 0x81, 0xBC, 0x02, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x10, 0x07, 0xE0, 0x0F, 0xF8, 0x38, 0x0C, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x60, 0x02, 0x60, 0x06, 0x30, 0x06, 0x18, 0x0C, 0x0F, 0xF8, 0x07, 0xE0,
  0xC7, 0xE1, 0xBD, 0xE3, 0xC0, 0x67, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B, 0x80, 0x37,
  0x80, 0xCD, 0xFF, 0x18, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xC2, 0x3D, 0xE4, 0xC0, 0x69, 0x00, 0x76, 0x00, 0x6C, 0x00, 0x50, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xA0, 0x01, 0x60, 0x02, 0xC0, 0x0C, 0x80, 0x19, 0x80,
  0xD1, 0xFF, 0x20, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xC7, 0xE7,
  0xF4, 0x1E, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0x01, 0x98, 0x02, 0x40, 0x0D, 0x00, 0x34, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x34, 0x00, 0xDC, 0x06, 0x3E, 0xF0,
  0x3F, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0xFE, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0xE0, 0xF0, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x5C, 0x0D, 0x3F, 0xE4, 0x3E,
  0x10, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x20,
  0x0C, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08,
  0x30, 0x0C, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x06, 0x60, 0x06, 0x40, 0x02,
  0x40, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x18, 0x03,
  0xC0, 0x18, 0x02, 0xC0, 0x38, 0x02, 0x40, 0x28, 0x06, 0x40, 0x2C, 0x06,
  0x60, 0x2C, 0x04, 0x60, 0x64, 0x04, 0x20, 0x44, 0x0C, 0x20, 0x46, 0x0C,
  0x30, 0xC6, 0x08, 0x30, 0xC2, 0x08, 0x30, 0x83, 0x18, 0x10, 0x83, 0x18,
  0x19, 0x81, 0x10, 0x19, 0x81, 0x10, 0x19, 0x01, 0xB0, 0x09, 0x01, 0xB0,
  0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xA0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x60, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x10, 0x18, 0x18,
  0x18, 0x0C, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x08,
  0x10, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x20, 0x0C, 0x30,
  0x0C, 0x10, 0x08, 0x10, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C,
  0x30, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x1E, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x70, 0x08, 0x00, 0x1E, 0x00, 0x27, 0xF0, 0x05, 0x87, 0x01, 0xA0, 0x30,
  0x2C, 0x07, 0x0D, 0x80, 0x3F, 0x20, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 30, 8, 3, -30 },
  { 9, 6, 9, 11, 3, -32 },
  { 16, 19, 30, 21, 2, -30 },
  { 88, 16, 38, 20, 2, -34 },
  { 164, 23, 30, 27, 2, -30 },
  { 251, 19, 30, 23, 2, -30 },
  { 323, 1, 9, 7, 3, -32 },
  { 325, 8, 43, 12, 3, -33 },
  { 368, 8, 43, 12, 1, -33 },
  { 411, 16, 16, 18, 1, -30 },
  { 443, 17, 22, 21, 2, -25 },
  { 490, 3, 9, 8, 2, -3 },
  { 494, 9, 1, 11, 1, -14 },
  { 496, 3, 3, 9, 3, -3 },
  { 498, 12, 33, 15, 1, -30 },
  { 548, 16, 30, 20, 2, -30 },
  { 608, 8, 30, 20, 4, -30 },
  { 638, 16, 30, 20, 2, -30 },
  { 698, 16, 30, 20, 2, -30 },
  { 758, 17, 30, 20, 2, -30 },
  { 822, 15, 30, 20, 3, -30 },
  { 879, 15, 30, 20, 3, -30 },
  { 936, 16, 30, 20, 2, -30 },
  { 996, 16, 30, 20, 2, -30 },
  { 1056, 16, 30, 20, 2, -30 },
  { 1116, 3, 22, 8, 3, -22 },
  { 1125, 3, 28, 7, 2, -22 },
  { 1136, 14, 17, 19, 2, -22 },
  { 1166, 14, 11, 20, 3, -19 },
  { 1186, 15, 17, 19, 2, -22 },
  { 1218, 13, 30, 17, 2, -30 },
  { 1267, 29, 38, 33, 2, -29 },
  { 1405, 21, 30, 23, 1, -30 },
  { 1484, 16, 30, 22, 4, -30 },
  { 1544, 18, 30, 24, 3, -30 },
  { 1612, 17, 30, 24, 4, -30 },
  { 1676, 15, 30, 21, 4, -30 },
  { 1733, 15, 30, 21, 4, -30 },
  { 1790, 19, 30, 25, 3, -30 },
  { 1862, 18, 30, 26, 4, -30 },
  { 1930, 2, 30, 10, 4, -30 },
  { 1938, 15, 30, 20, 2, -30 },
  { 1995, 18, 30, 23, 4, -30 },
  { 2063, 14, 30, 19, 4, -30 },
  { 2116, 24, 30, 31, 4, -30 },
  { 2206, 18, 30, 26, 4, -30 },
  { 2274, 19, 30, 25, 3, -30 },
  { 2346, 16, 30, 22, 4, -30 },
  { 2406, 19, 35, 25, 3, -30 },
  { 2490, 17, 30, 24, 4, -30 },
  { 2554, 18, 30, 22, 2, -30 },
  { 2622, 20, 30, 22, 1, -30 },
  { 2697, 18, 30, 24, 3, -30 },
  { 2765, 20, 30, 22, 1, -30 },
  { 2840, 30, 30, 33, 1, -30 },
  { 2953, 20, 30, 22, 1, -30 },
  { 3028, 20, 30, 22, 1, -30 },
  { 3103, 18, 30, 22, 2, -30 },
  { 3171, 6, 40, 9, 3, -34 },
  { 3201, 12, 33, 15, 1, -30 },
  { 3251, 6, 40, 9, 0, -34 },
  { 3281, 11, 15, 16, 2, -30 },
  { 3302, 15, 1, 16, 0, 0 },
  { 3304, 6, 6, 11, 3, -32 },
  { 3309, 15, 22, 20, 2, -22 },
  { 3351, 15, 32, 20, 3, -32 },
  { 3411, 15, 22, 19, 2, -22 },
  { 3453, 15, 32, 20, 2, -32 },
  { 3513, 15, 22, 19, 2, -22 },
  { 3555, 10, 32, 12, 2, -32 },
  { 3595, 15, 31, 20, 2, -22 },
  { 3654, 14, 32, 20, 3, -32 },
  { 3710, 2, 30, 8, 3, -30 },
  { 3718, 7, 39, 9, -2, -30 },
  { 3753, 14, 32, 18, 3, -32 },
  { 3809, 2, 32, 8, 3, -32 },
  { 3817, 26, 22, 32, 3, -22 },
  { 3889, 14, 22, 20, 3, -22 },
  { 3928, 16, 22, 20, 2, -22 },
  { 3972, 15, 31, 20, 3, -22 },
  { 4031, 15, 31, 20, 2, -22 },
  { 4090, 9, 22, 13, 3, -22 },
  { 4115, 14, 22, 19, 2, -22 },
  { 4154, 9, 28, 12, 1, -28 },
  { 4186, 14, 22, 20, 3, -22 },
  { 4225, 16, 22, 18, 1, -22 },
  { 4269, 24, 22, 28, 2, -22 },
  { 4335, 16, 22, 18, 1, -22 },
  { 4379, 16, 31, 18, 1, -22 },
  { 4441, 15, 22, 18, 2, -22 },
  { 4483, 10, 42, 12, 2, -33 },
  { 4536, 1, 36, 9, 4, -30 },
  { 4541, 11, 42, 12, 0, -33 },
  { 4599, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT42PT7B_H_
