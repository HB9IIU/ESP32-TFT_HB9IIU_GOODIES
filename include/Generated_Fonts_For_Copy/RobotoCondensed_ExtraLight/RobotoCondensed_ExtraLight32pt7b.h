#ifndef _ROBOTOCONDENSED_EXTRALIGHT32PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x3C, 0xCE, 0x73, 0x18, 0xC6, 0x20,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x82, 0x01,
  0x04, 0x3F, 0xFF, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x61, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x18, 0x7F, 0xFE, 0x08, 0x40, 0x10, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x00, 0x02, 0x00, 0x20, 0x02,
  0x00, 0xF0, 0x30, 0xC6, 0x06, 0x40, 0x24, 0x02, 0x40, 0x24, 0x03, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x28, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x38, 0x00, 0x22, 0x00, 0x20, 0x80, 0x10, 0x41,
  0x08, 0x20, 0x84, 0x10, 0x82, 0x08, 0xC1, 0x04, 0x40, 0x82, 0x60, 0x22,
  0x20, 0x0E, 0x20, 0x00, 0x10, 0x00, 0x10, 0xE0, 0x08, 0x88, 0x08, 0x86,
  0x04, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x23, 0x04, 0x10, 0x02,
  0x18, 0x00, 0x88, 0x00, 0x38, 0x0F, 0x00, 0x46, 0x02, 0x08, 0x08, 0x30,
  0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x12, 0x00, 0x70, 0x00, 0x80,
  0x05, 0x00, 0x26, 0x01, 0x08, 0x2C, 0x10, 0xA0, 0x62, 0x80, 0xCA, 0x01,
  0x68, 0x03, 0x20, 0x0C, 0x40, 0x79, 0xC7, 0x21, 0xF0, 0x40, 0xFE, 0x04,
  0x30, 0x84, 0x10, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82,
  0x08, 0x30, 0xC1, 0x04, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0xC1, 0x83,
  0x04, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x82, 0x0C, 0x30, 0x41, 0x04,
  0x10, 0xC3, 0x08, 0x20, 0x82, 0x18, 0x41, 0x08, 0x21, 0x0C, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x04, 0x20, 0xB9, 0x38, 0x3F, 0x00, 0x60,
  0x05, 0x80, 0x64, 0x02, 0x10, 0x20, 0xC1, 0x02, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x24, 0x96, 0xA0, 0xFC, 0xF0, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x00, 0x0F,
  0x03, 0x18, 0x60, 0x44, 0x06, 0x40, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x28, 0x02, 0x40, 0x24, 0x06, 0x60, 0x43, 0x18, 0x1F, 0x00, 0x04, 0x7E,
  0x61, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x1F, 0x03, 0x18, 0x40, 0x4C, 0x06, 0x80, 0x28,
  0x02, 0x80, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xFF, 0xF0, 0x1F, 0x03, 0x0C, 0x40, 0x4C, 0x02, 0x80, 0x28, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0xF0, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x80, 0x38, 0x03, 0x80, 0x2C, 0x02, 0x40, 0x63, 0x0C,
  0x1F, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0x60, 0x09,
  0x80, 0x26, 0x01, 0x18, 0x04, 0x60, 0x21, 0x81, 0x86, 0x04, 0x18, 0x30,
  0x60, 0x81, 0x86, 0x06, 0x10, 0x18, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x7F, 0xE8, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xDF, 0x1E, 0x33, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x24, 0x0C,
  0xE3, 0x07, 0xC0, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x8F, 0x0B, 0x0C, 0xA0, 0x6C, 0x02, 0x80, 0x28, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x24, 0x02, 0x20, 0x43, 0x8C,
  0x0F, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x00, 0x1F, 0x03, 0x1C, 0x60, 0x44, 0x02, 0xC0, 0x28,
  0x02, 0x80, 0x2C, 0x02, 0x40, 0x26, 0x04, 0x30, 0xC1, 0xF0, 0x30, 0xC4,
  0x06, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x67,
  0x0C, 0x1F, 0x80, 0x1F, 0x03, 0x18, 0x60, 0x4C, 0x06, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x3C, 0x06, 0x40, 0x63, 0x1A,
  0x1E, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x70,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x09, 0x2D, 0xA8, 0x00, 0x20, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x08,
  0x00, 0x1F, 0x0C, 0x66, 0x09, 0x01, 0x40, 0x70, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x0E, 0x0E, 0x00,
  0x60, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00,
  0x00, 0x98, 0x0F, 0x02, 0x40, 0xC6, 0x09, 0x02, 0x08, 0x2C, 0x10, 0x20,
  0xA0, 0x40, 0x81, 0x82, 0x02, 0x06, 0x08, 0x08, 0x18, 0x20, 0x20, 0xE0,
  0x81, 0x82, 0x82, 0x04, 0x0A, 0x08, 0x10, 0x28, 0x20, 0x40, 0xA0, 0x83,
  0x84, 0xC1, 0x12, 0x31, 0x03, 0x87, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x01,
  0xF8, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x2C, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x30, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0xC0,
  0x81, 0x01, 0x02, 0x02, 0x0C, 0x02, 0x1F, 0xFC, 0x20, 0x08, 0xC0, 0x19,
  0x00, 0x12, 0x00, 0x2C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0xFF, 0x08,
  0x1C, 0x80, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x06, 0x80, 0xCF, 0xF8, 0x80, 0x68, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x0C, 0xFF, 0x80, 0x07, 0xC0, 0x60,
  0xC3, 0x01, 0x98, 0x02, 0x40, 0x05, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x58, 0x02, 0x30, 0x18, 0x60, 0xC0,
  0x7C, 0x00, 0xFF, 0x04, 0x0E, 0x20, 0x19, 0x00, 0x68, 0x01, 0x40, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00, 0x68, 0x06,
  0x40, 0xE3, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFC, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFC, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x07, 0xE0, 0x38, 0x60, 0xC0, 0x21, 0x00, 0x64, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xA0, 0x03, 0x40, 0x06, 0x80, 0x0D,
  0x80, 0x19, 0x00, 0x33, 0x00, 0xC3, 0x87, 0x01, 0xF8, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xC0, 0x3C, 0x03, 0x40, 0x24, 0x02,
  0x60, 0x63, 0x0C, 0x0F, 0x00, 0x80, 0x1A, 0x00, 0xC8, 0x06, 0x20, 0x10,
  0x80, 0x82, 0x06, 0x08, 0x30, 0x21, 0x80, 0x84, 0x02, 0x20, 0x09, 0x80,
  0x2F, 0x00, 0xE4, 0x03, 0x08, 0x08, 0x30, 0x20, 0x40, 0x80, 0x82, 0x03,
  0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x68, 0x00, 0x80, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x05, 0xA0, 0x01, 0x68, 0x00, 0xD9, 0x00, 0x26, 0x40, 0x09,
  0x90, 0x06, 0x62, 0x01, 0x18, 0x80, 0x46, 0x30, 0x31, 0x84, 0x08, 0x61,
  0x02, 0x18, 0x61, 0x06, 0x08, 0x41, 0x82, 0x10, 0x60, 0x48, 0x18, 0x12,
  0x06, 0x05, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x68, 0x01, 0xB0, 0x06, 0x40, 0x19, 0x80, 0x62, 0x01,
  0x84, 0x06, 0x10, 0x18, 0x20, 0x60, 0xC1, 0x81, 0x06, 0x06, 0x18, 0x08,
  0x60, 0x31, 0x80, 0x46, 0x00, 0x98, 0x03, 0x60, 0x05, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0xC0, 0x30, 0xE0, 0xC0, 0x63, 0x00, 0x44, 0x00,
  0x58, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x05, 0x80,
  0x09, 0x00, 0x13, 0x00, 0x63, 0x01, 0x83, 0x0E, 0x01, 0xF0, 0x00, 0xFF,
  0x88, 0x0E, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x0E, 0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xC0,
  0x30, 0xE0, 0xC0, 0x63, 0x00, 0x44, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x40,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x80, 0x09, 0x00, 0x13, 0x00, 0x43,
  0x01, 0x83, 0x0E, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0xFF, 0x84, 0x06, 0x20, 0x09, 0x00, 0x68, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x01, 0x8F, 0xF8, 0x40, 0xC2,
  0x02, 0x10, 0x18, 0x80, 0x44, 0x03, 0x20, 0x09, 0x00, 0x68, 0x01, 0x40,
  0x0E, 0x00, 0x20, 0x0F, 0x81, 0x83, 0x18, 0x0D, 0x80, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x36,
  0x01, 0x18, 0x30, 0x3F, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x80, 0x24, 0x03, 0x18,
  0x70, 0x7E, 0x00, 0x80, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00,
  0x4C, 0x01, 0x88, 0x02, 0x10, 0x04, 0x30, 0x18, 0x20, 0x20, 0x40, 0x40,
  0xC1, 0x80, 0x82, 0x01, 0x04, 0x02, 0x08, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x1B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x70, 0x00, 0x40, 0x00, 0x80,
  0x10, 0x03, 0x80, 0x20, 0x0D, 0x00, 0xA0, 0x12, 0x01, 0x40, 0x24, 0x02,
  0x80, 0x4C, 0x05, 0x01, 0x88, 0x11, 0x02, 0x10, 0x22, 0x04, 0x20, 0x44,
  0x08, 0x40, 0x88, 0x10, 0xC2, 0x08, 0x60, 0x84, 0x10, 0x81, 0x08, 0x21,
  0x02, 0x10, 0x42, 0x06, 0x40, 0x44, 0x04, 0x80, 0x98, 0x09, 0x01, 0x20,
  0x12, 0x02, 0x40, 0x28, 0x02, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x10, 0x00, 0x40, 0x04, 0xC0, 0x18, 0x80, 0x21,
  0x80, 0xC1, 0x01, 0x03, 0x06, 0x02, 0x08, 0x02, 0x20, 0x04, 0xC0, 0x05,
  0x00, 0x0E, 0x00, 0x08, 0x00, 0x28, 0x00, 0xD8, 0x01, 0x10, 0x06, 0x30,
  0x08, 0x20, 0x30, 0x60, 0x40, 0x41, 0x00, 0x46, 0x00, 0xC8, 0x00, 0xB0,
  0x01, 0x80, 0x80, 0x07, 0x80, 0x09, 0x00, 0x33, 0x00, 0x42, 0x01, 0x86,
  0x02, 0x04, 0x0C, 0x0C, 0x10, 0x08, 0x20, 0x18, 0x80, 0x11, 0x00, 0x34,
  0x00, 0x28, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x7F, 0xFC,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0F, 0xFF, 0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x60, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x0C, 0x06, 0x07, 0x02, 0xC1, 0x21, 0x10, 0x84,
  0x42, 0x41, 0x20, 0x50, 0x20, 0xFF, 0xF0, 0xC3, 0x08, 0x20, 0x1F, 0x0E,
  0x31, 0x01, 0x40, 0x28, 0x04, 0x00, 0x80, 0x10, 0xFE, 0x60, 0x58, 0x0A,
  0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x33, 0x1B, 0x3E, 0x60, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xD0, 0xCE,
  0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2E, 0x06, 0xF0, 0xCC, 0xF8, 0x1F, 0x0E,
  0x31, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0xD0, 0x13, 0x8C, 0x1F, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0xF9, 0x31, 0xA8, 0x0F,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1C, 0x02, 0x80, 0xCC, 0x68, 0xF9, 0x0F, 0x81, 0x8C, 0x20, 0x26,
  0x03, 0x40, 0x14, 0x01, 0xC0, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x86, 0x0F, 0x80, 0x07, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x2E, 0x35,
  0x01, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x50, 0x19, 0x8D, 0x1F, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x80, 0x8C, 0x30, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x7C, 0xD8, 0xDC, 0x0B, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xF0, 0x05, 0x55, 0x55, 0x55, 0x54, 0x18, 0xC0, 0x00,
  0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x46, 0x23, 0x70, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x02, 0xC0, 0x98, 0x33, 0x0C, 0x63, 0x0C, 0xC1, 0x90, 0x36,
  0x07, 0x40, 0xC4, 0x18, 0xC3, 0x08, 0x60, 0x8C, 0x19, 0x81, 0x30, 0x16,
  0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0x87, 0xCD, 0x0C, 0xC6, 0xE0, 0x58, 0x3C,
  0x07, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01,
  0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20,
  0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x10, 0xCF,
  0x9B, 0x1B, 0x81, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x20, 0x1F,
  0x03, 0x0C, 0x60, 0x6C, 0x02, 0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x2C, 0x02, 0x60, 0x63, 0x1C, 0x1F,
  0x00, 0xCF, 0x8F, 0x0C, 0xE0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x02, 0xE0, 0x6F,
  0x0C, 0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x1F, 0x2E, 0x35, 0x01, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x50, 0x19, 0x8D, 0x1F,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xCF, 0xA3,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x3F, 0x18, 0x6C, 0x0E, 0x01, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x0D, 0x86, 0x1F, 0x00, 0x30,
  0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x80, 0xE0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02,
  0x80, 0xD0, 0x19, 0x8D, 0x1F, 0x20, 0x80, 0x3C, 0x02, 0x40, 0x24, 0x06,
  0x40, 0x42, 0x04, 0x20, 0xC2, 0x08, 0x10, 0x81, 0x08, 0x11, 0x00, 0x90,
  0x09, 0x00, 0xA0, 0x0E, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x40, 0x68, 0x08,
  0x09, 0x02, 0x81, 0x20, 0x50, 0x26, 0x0A, 0x0C, 0x43, 0x41, 0x08, 0x44,
  0x21, 0x08, 0x84, 0x31, 0x11, 0x82, 0x63, 0x20, 0x48, 0x24, 0x09, 0x04,
  0x81, 0xA0, 0xB0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x00, 0xC0, 0x24, 0x06, 0x20, 0x43, 0x08, 0x11, 0x81, 0x90, 0x0B, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0B, 0x01, 0x90, 0x10, 0x82, 0x0C, 0x60, 0x44,
  0x06, 0xC0, 0x20, 0x80, 0x3C, 0x02, 0x40, 0x24, 0x06, 0x60, 0x42, 0x04,
  0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x11, 0x80, 0x90, 0x09, 0x00, 0xB0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x7F, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xFF, 0xF0, 0x01, 0x06, 0x04, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x60, 0xC0, 0x30, 0x10,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x06,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x06, 0x03, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x60,
  0x40, 0x3C, 0x02, 0xCC, 0x05, 0x04, 0x16, 0x06, 0x68, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 23, 6, 2, -23 },
  { 7, 5, 7, 9, 2, -24 },
  { 12, 15, 23, 16, 1, -23 },
  { 56, 12, 29, 16, 2, -26 },
  { 100, 17, 23, 21, 2, -23 },
  { 149, 14, 23, 17, 2, -23 },
  { 190, 1, 7, 5, 2, -24 },
  { 191, 6, 32, 9, 2, -25 },
  { 215, 6, 32, 9, 1, -25 },
  { 239, 13, 13, 13, 0, -23 },
  { 261, 13, 17, 16, 1, -19 },
  { 289, 3, 7, 6, 1, -3 },
  { 292, 6, 1, 8, 1, -11 },
  { 293, 2, 2, 7, 2, -2 },
  { 294, 9, 25, 11, 1, -23 },
  { 323, 12, 23, 16, 2, -23 },
  { 358, 6, 23, 16, 3, -23 },
  { 376, 12, 23, 16, 2, -23 },
  { 411, 12, 23, 16, 2, -23 },
  { 446, 14, 23, 16, 1, -23 },
  { 487, 11, 23, 16, 3, -23 },
  { 519, 12, 23, 16, 2, -23 },
  { 554, 13, 23, 16, 1, -23 },
  { 592, 12, 23, 16, 2, -23 },
  { 627, 12, 23, 16, 2, -23 },
  { 662, 2, 17, 6, 2, -17 },
  { 667, 3, 21, 6, 1, -17 },
  { 675, 11, 13, 14, 1, -17 },
  { 693, 11, 7, 16, 2, -14 },
  { 703, 11, 13, 15, 2, -17 },
  { 721, 10, 23, 13, 1, -23 },
  { 750, 22, 29, 25, 2, -22 },
  { 830, 15, 23, 17, 1, -23 },
  { 874, 12, 23, 17, 3, -23 },
  { 909, 14, 23, 18, 2, -23 },
  { 950, 13, 23, 18, 3, -23 },
  { 988, 12, 23, 16, 3, -23 },
  { 1023, 12, 23, 16, 3, -23 },
  { 1058, 15, 23, 19, 2, -23 },
  { 1102, 14, 23, 20, 3, -23 },
  { 1143, 1, 23, 8, 3, -23 },
  { 1146, 12, 23, 15, 1, -23 },
  { 1181, 14, 23, 18, 3, -23 },
  { 1222, 11, 23, 15, 3, -23 },
  { 1254, 18, 23, 24, 3, -23 },
  { 1306, 14, 23, 20, 3, -23 },
  { 1347, 15, 23, 19, 2, -23 },
  { 1391, 12, 23, 17, 3, -23 },
  { 1426, 15, 27, 19, 2, -23 },
  { 1477, 13, 23, 18, 3, -23 },
  { 1515, 13, 23, 17, 2, -23 },
  { 1553, 15, 23, 17, 1, -23 },
  { 1597, 13, 23, 19, 3, -23 },
  { 1635, 15, 23, 17, 1, -23 },
  { 1679, 23, 23, 25, 1, -23 },
  { 1746, 15, 23, 17, 1, -23 },
  { 1790, 15, 23, 17, 1, -23 },
  { 1834, 14, 23, 17, 1, -23 },
  { 1875, 4, 31, 7, 3, -26 },
  { 1891, 9, 25, 11, 1, -23 },
  { 1920, 4, 31, 7, 0, -26 },
  { 1936, 9, 11, 12, 1, -23 },
  { 1949, 12, 1, 12, 0, 0 },
  { 1951, 5, 4, 9, 2, -24 },
  { 1954, 11, 17, 15, 2, -17 },
  { 1978, 12, 24, 16, 2, -24 },
  { 2014, 11, 17, 14, 2, -17 },
  { 2038, 11, 24, 16, 2, -24 },
  { 2071, 12, 17, 15, 1, -17 },
  { 2097, 8, 24, 9, 1, -24 },
  { 2121, 11, 24, 16, 2, -17 },
  { 2154, 11, 24, 15, 2, -24 },
  { 2187, 2, 23, 6, 2, -23 },
  { 2193, 5, 30, 7, -1, -23 },
  { 2212, 11, 24, 14, 2, -24 },
  { 2245, 1, 24, 6, 3, -24 },
  { 2248, 20, 17, 25, 2, -17 },
  { 2291, 11, 17, 15, 2, -17 },
  { 2315, 12, 17, 16, 2, -17 },
  { 2341, 12, 24, 16, 2, -17 },
  { 2377, 11, 24, 16, 2, -17 },
  { 2410, 7, 17, 10, 2, -17 },
  { 2425, 10, 17, 14, 2, -17 },
  { 2447, 7, 21, 9, 1, -21 },
  { 2466, 11, 17, 15, 2, -17 },
  { 2490, 12, 17, 14, 1, -17 },
  { 2516, 19, 17, 21, 1, -17 },
  { 2557, 12, 17, 14, 1, -17 },
  { 2583, 12, 24, 13, 1, -17 },
  { 2619, 12, 17, 14, 1, -17 },
  { 2645, 8, 32, 9, 1, -25 },
  { 2677, 1, 27, 7, 3, -23 },
  { 2681, 8, 32, 9, 0, -25 },
  { 2713, 15, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT32PT7B_H_
