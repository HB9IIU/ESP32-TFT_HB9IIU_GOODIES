#ifndef _ROBOTOCONDENSED_EXTRALIGHT38PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x3C, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x06,
  0x00, 0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x3F, 0xFF, 0xC0, 0x81, 0x00,
  0x20, 0xC0, 0x08, 0x30, 0x02, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x06, 0x0F, 0xFF, 0xF8, 0x10, 0x40, 0x0C, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x02, 0x08, 0x01,
  0x82, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x07, 0xC0, 0x71,
  0xC3, 0x01, 0x88, 0x02, 0x60, 0x0D, 0x00, 0x34, 0x00, 0x50, 0x01, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x14,
  0x00, 0xD8, 0x03, 0x30, 0x18, 0x71, 0xC0, 0x7C, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x03, 0x10, 0x00, 0x10, 0x40, 0x01, 0x83, 0x02,
  0x08, 0x18, 0x10, 0x40, 0x41, 0x02, 0x02, 0x18, 0x10, 0x10, 0x80, 0x81,
  0x8C, 0x06, 0x0C, 0x40, 0x10, 0x46, 0x00, 0xC6, 0x20, 0x01, 0xC3, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x0F, 0x00, 0x08, 0xCC, 0x00, 0x8C, 0x30, 0x0C,
  0x40, 0x80, 0x42, 0x04, 0x06, 0x10, 0x20, 0x20, 0x81, 0x83, 0x04, 0x0C,
  0x10, 0x20, 0x41, 0x81, 0x02, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x06, 0x70, 0x06, 0x08, 0x02, 0x06, 0x03, 0x01, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x40, 0x10, 0x60, 0x0C, 0x60, 0x02, 0x60,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x44, 0x00, 0x43, 0x02, 0x60,
  0xC1, 0x20, 0x20, 0xB0, 0x18, 0x58, 0x06, 0x6C, 0x01, 0xA6, 0x00, 0x73,
  0x00, 0x30, 0x80, 0x1C, 0x60, 0x1B, 0x1E, 0x78, 0x83, 0xF0, 0x60, 0x55,
  0xFF, 0x02, 0x08, 0x20, 0x41, 0x06, 0x08, 0x10, 0x60, 0x81, 0x06, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03,
  0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x81, 0x81, 0x01, 0x03, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40,
  0xC1, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x18, 0x20, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x18, 0x61, 0x9E, 0xDE,
  0x07, 0xE0, 0x03, 0x00, 0x0F, 0x00, 0x33, 0x00, 0x42, 0x01, 0x86, 0x06,
  0x06, 0x08, 0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x33, 0x33, 0x22, 0x64, 0xFF, 0xF0, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x00, 0x07, 0xC0, 0x73, 0x83, 0x03, 0x08, 0x06, 0x60, 0x09, 0x00,
  0x24, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50,
  0x03, 0x40, 0x0D, 0x00, 0x26, 0x00, 0x88, 0x06, 0x30, 0x30, 0x7B, 0x80,
  0x7C, 0x00, 0x01, 0x0F, 0x39, 0xE1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x0F, 0xC0, 0x39, 0xC0, 0xC0, 0xC3, 0x00,
  0xC4, 0x00, 0x98, 0x01, 0x30, 0x02, 0x60, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x73, 0xC3,
  0x01, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x1F, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00,
  0xD8, 0x02, 0x30, 0x18, 0x71, 0xC0, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x02,
  0x30, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80,
  0x40, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x10, 0x06,
  0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F, 0xF8, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0xF8, 0x16, 0x38, 0x60, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x0B, 0x00, 0x24, 0x00, 0x98, 0x06,
  0x20, 0x30, 0x73, 0x80, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x1F, 0x04,
  0xC7, 0x14, 0x06, 0xE0, 0x0B, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x36, 0x00, 0xCC, 0x06,
  0x10, 0x18, 0x31, 0xC0, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x39, 0xE0, 0xC0, 0xE3,
  0x00, 0xC4, 0x00, 0xC8, 0x01, 0x90, 0x03, 0x20, 0x02, 0x40, 0x0C, 0x80,
  0x19, 0x80, 0x21, 0x80, 0x81, 0xC6, 0x01, 0xF8, 0x0E, 0x0C, 0x30, 0x0C,
  0x40, 0x0D, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x38, 0x00, 0x78, 0x00, 0xB0,
  0x01, 0x20, 0x06, 0x60, 0x18, 0x78, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x73,
  0x83, 0x03, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x2C, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x4C,
  0x0D, 0x18, 0xEC, 0x3E, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xB0, 0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x33, 0x32, 0x66, 0x40, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x10, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x00,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F,
  0x07, 0x39, 0x81, 0x60, 0x3C, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x02, 0x30, 0x0F, 0x00, 0x88, 0x06, 0x70, 0x26, 0x02, 0x04,
  0x0D, 0x01, 0x81, 0x01, 0x40, 0x40, 0x40, 0x50, 0x20, 0x10, 0x1C, 0x08,
  0x04, 0x07, 0x02, 0x01, 0x01, 0xC1, 0x80, 0xC0, 0x70, 0x60, 0x30, 0x1C,
  0x18, 0x0C, 0x07, 0x06, 0x03, 0x03, 0xC1, 0x80, 0x80, 0xB0, 0x60, 0x60,
  0x24, 0x08, 0x1C, 0x19, 0x02, 0x09, 0x04, 0x40, 0xE6, 0x66, 0x18, 0x1E,
  0x0F, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0xD0, 0x00, 0x12, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02,
  0x18, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x02, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x02, 0x02, 0x00, 0x40, 0x7F,
  0xFC, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x00, 0xFF, 0xC1, 0x80,
  0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x60, 0x02,
  0xC0, 0x05, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x07, 0x1F, 0xFC, 0x30,
  0x06, 0x60, 0x06, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80, 0xF3, 0xFF, 0x80,
  0x07, 0xE0, 0x1E, 0x38, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06,
  0x30, 0x0C, 0x1E, 0x38, 0x07, 0xE0, 0xFF, 0xC0, 0xC0, 0xF0, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF,
  0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0x1E, 0x0C, 0x01, 0x84, 0x00, 0x46,
  0x00, 0x32, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x03, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A,
  0x00, 0x0D, 0x80, 0x06, 0x60, 0x03, 0x18, 0x07, 0x07, 0x1F, 0x00, 0xFC,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0F, 0x00, 0x78, 0x06, 0x60, 0x61, 0xCF, 0x03, 0xE0, 0xC0,
  0x03, 0x60, 0x03, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x83,
  0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x30, 0x80, 0x18, 0xC0,
  0x0C, 0xE0, 0x06, 0xF0, 0x03, 0xCC, 0x01, 0xC3, 0x00, 0xC0, 0x80, 0x60,
  0x60, 0x30, 0x18, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x08, 0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x60, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFE, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x05, 0xF0, 0x00, 0x37, 0x40, 0x00, 0xDD, 0x80, 0x02,
  0x72, 0x00, 0x19, 0xC8, 0x00, 0x47, 0x30, 0x01, 0x1C, 0x40, 0x0C, 0x71,
  0x00, 0x21, 0xC6, 0x00, 0x87, 0x08, 0x06, 0x1C, 0x30, 0x10, 0x70, 0xC0,
  0xC1, 0xC1, 0x03, 0x07, 0x06, 0x08, 0x1C, 0x08, 0x60, 0x70, 0x21, 0x01,
  0xC0, 0xC4, 0x07, 0x01, 0x30, 0x1C, 0x04, 0x80, 0x70, 0x1A, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x40, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1D, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x03, 0x88,
  0x01, 0xC6, 0x00, 0xE1, 0x00, 0x70, 0xC0, 0x38, 0x20, 0x1C, 0x18, 0x0E,
  0x06, 0x07, 0x01, 0x03, 0x80, 0xC1, 0xC0, 0x20, 0xE0, 0x18, 0x70, 0x04,
  0x38, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x27, 0x00, 0x1B, 0x80, 0x05, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0x07, 0xE0, 0x0F, 0x3C, 0x0C, 0x03,
  0x0C, 0x00, 0xC4, 0x00, 0x36, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x16, 0x00, 0x19, 0x00, 0x0C, 0xC0, 0x0C, 0x30, 0x0C, 0x0F,
  0x3C, 0x01, 0xF8, 0x00, 0xFF, 0xE1, 0x80, 0xF3, 0x00, 0x36, 0x00, 0x2C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x58, 0x01, 0xB0, 0x1E, 0x7F, 0xF0, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xCF, 0x01,
  0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x98, 0x00, 0x64, 0x00, 0x09, 0x00,
  0x02, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x0D, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x62, 0x00, 0x18, 0xC0,
  0x0C, 0x18, 0x06, 0x03, 0xCF, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0xFF, 0xE0, 0xC0, 0x78, 0xC0,
  0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x78, 0xFF, 0xE0, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x10, 0xC0,
  0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0x07, 0xE0, 0x1C, 0x78, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0x40,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x06, 0x30, 0x0E, 0x1E, 0x3C, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x1E, 0x78,
  0x07, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x02, 0x60,
  0x01, 0x88, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x03, 0x04, 0x00,
  0x81, 0x80, 0x20, 0x60, 0x18, 0x08, 0x04, 0x03, 0x01, 0x00, 0xC0, 0xC0,
  0x10, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x21, 0x80, 0x08, 0x40, 0x03,
  0x30, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x06, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x00, 0xC0, 0x05, 0x00, 0x18,
  0x01, 0xB0, 0x07, 0x00, 0x36, 0x00, 0xB0, 0x04, 0x40, 0x12, 0x00, 0x88,
  0x02, 0x40, 0x31, 0x00, 0xC8, 0x06, 0x30, 0x11, 0x80, 0xC6, 0x02, 0x10,
  0x10, 0x40, 0x42, 0x02, 0x08, 0x18, 0x40, 0xC1, 0x82, 0x0C, 0x18, 0x30,
  0x40, 0x82, 0x02, 0x08, 0x10, 0x40, 0x43, 0x02, 0x08, 0x08, 0x40, 0x63,
  0x01, 0x88, 0x04, 0x60, 0x31, 0x00, 0x88, 0x02, 0x60, 0x11, 0x00, 0x48,
  0x03, 0x60, 0x09, 0x00, 0x2C, 0x01, 0xA0, 0x05, 0x00, 0x1C, 0x00, 0xA0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x98, 0x00, 0x63, 0x00, 0x30, 0x40, 0x0C, 0x18, 0x06, 0x02, 0x01,
  0x00, 0xC0, 0xC0, 0x10, 0x20, 0x06, 0x18, 0x00, 0xC4, 0x00, 0x13, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x80, 0x03,
  0x30, 0x00, 0x84, 0x00, 0x61, 0x80, 0x10, 0x30, 0x0C, 0x04, 0x06, 0x01,
  0x81, 0x00, 0x20, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x0C,
  0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00, 0x18, 0x80, 0x04, 0x30, 0x03, 0x04,
  0x00, 0x81, 0x80, 0x60, 0x20, 0x10, 0x0C, 0x0C, 0x01, 0x02, 0x00, 0x61,
  0x80, 0x08, 0x40, 0x03, 0x30, 0x00, 0x48, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x0C,
  0x03, 0x01, 0xC0, 0x58, 0x12, 0x0C, 0x82, 0x10, 0x84, 0x61, 0x90, 0x24,
  0x0B, 0x03, 0x80, 0x40, 0xFF, 0xFC, 0x60, 0x83, 0x06, 0x08, 0x0F, 0xC1,
  0xC7, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x7F, 0xCF, 0x06, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x3E, 0x03, 0xDE, 0x72, 0x3E, 0x10, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x7E, 0x26,
  0x79, 0x40, 0x6C, 0x01, 0x60, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1E,
  0x00, 0xA8, 0x0D, 0x73, 0xC8, 0xF8, 0x00, 0x0F, 0xC1, 0xE7, 0x18, 0x0C,
  0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1B, 0x01,
  0x8F, 0x38, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3E, 0x33, 0xCE, 0xC8,
  0x0F, 0x60, 0x1D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D,
  0x80, 0x73, 0x03, 0xC7, 0x3B, 0x0F, 0x8C, 0x0F, 0xC0, 0x73, 0x83, 0x03,
  0x18, 0x06, 0xC0, 0x0B, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x61, 0xEF, 0x03, 0xF0, 0x03, 0xC1, 0x90, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x3F, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0F, 0x8C, 0xF3, 0xB2, 0x03,
  0xD8, 0x07, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x60,
  0x1C, 0xC0, 0xF3, 0xCE, 0xC3, 0xE3, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x80, 0x41, 0x87, 0x03, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x7C, 0x9C,
  0xEB, 0x03, 0xA0, 0x3C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x02, 0x0D, 0x33, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x01, 0xA0, 0x19,
  0x01, 0x88, 0x18, 0x41, 0x82, 0x18, 0x10, 0x80, 0x88, 0x04, 0xC0, 0x2E,
  0x01, 0xD8, 0x0C, 0x60, 0x41, 0x02, 0x0C, 0x10, 0x30, 0x80, 0xC4, 0x02,
  0x20, 0x19, 0x00, 0x68, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x87, 0x80, 0xF8, 0x98, 0xE3, 0x9C, 0xB0, 0x36, 0x06, 0xA0,
  0x3C, 0x02, 0xC0, 0x18, 0x02, 0xC0, 0x18, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x87, 0xC9, 0xCE, 0xB0, 0x3A, 0x03, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x07, 0xC0, 0x71, 0xC3,
  0x01, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x03,
  0x60, 0x08, 0xC0, 0x61, 0xC7, 0x01, 0xF0, 0x8F, 0xC4, 0xCF, 0x28, 0x0D,
  0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x17, 0x01,
  0xAE, 0x79, 0x1F, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x0F, 0x8C, 0xF3, 0xB3, 0x03, 0xD8, 0x07,
  0x40, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x60, 0x1C, 0xC0,
  0xF3, 0xCE, 0xC3, 0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x8F, 0x9D, 0xB0, 0xA0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x1F, 0x81, 0xC7, 0x18, 0x0C, 0x80, 0x6C, 0x01, 0x60, 0x09,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x78, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0A, 0x00, 0x70, 0x03, 0xC0, 0x13, 0x01, 0x8E, 0x78, 0x3F, 0x00, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0C, 0x07,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x36, 0x07, 0x39, 0xD1, 0xF1, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0x98,
  0x02, 0x60, 0x18, 0x80, 0x43, 0x01, 0x0C, 0x0C, 0x10, 0x20, 0x40, 0x81,
  0x86, 0x02, 0x10, 0x08, 0x40, 0x33, 0x00, 0x48, 0x01, 0x20, 0x07, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x40, 0x10, 0x05, 0x00, 0xC0, 0x36, 0x03,
  0x80, 0xD8, 0x0A, 0x02, 0x20, 0x28, 0x08, 0x81, 0xB0, 0x23, 0x04, 0xC1,
  0x8C, 0x11, 0x06, 0x10, 0xC4, 0x10, 0x43, 0x18, 0x41, 0x88, 0x23, 0x06,
  0x20, 0x8C, 0x09, 0x82, 0x20, 0x24, 0x0C, 0x80, 0x90, 0x16, 0x03, 0x40,
  0x58, 0x07, 0x01, 0x40, 0x18, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x40, 0x09, 0x80, 0x63, 0x01, 0x04, 0x0C, 0x18, 0x60, 0x21, 0x00, 0xCC,
  0x01, 0x20, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xE0, 0x04, 0xC0, 0x31,
  0x01, 0x86, 0x04, 0x08, 0x30, 0x30, 0x80, 0x66, 0x01, 0xB0, 0x03, 0xC0,
  0x0F, 0x00, 0x34, 0x00, 0x98, 0x02, 0x60, 0x18, 0x80, 0x43, 0x01, 0x0C,
  0x0C, 0x10, 0x20, 0x60, 0x81, 0x86, 0x02, 0x18, 0x08, 0x40, 0x33, 0x00,
  0x4C, 0x01, 0x20, 0x06, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0xF0, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x07, 0x03, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x18, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x3C, 0x07, 0x03, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x60, 0x10, 0x00, 0x3C, 0x00, 0xB3, 0x80, 0x70, 0x60, 0x70,
  0x18, 0x28, 0x07, 0x74, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 5, 8, 10, 3, -29 },
  { 13, 18, 27, 19, 1, -27 },
  { 74, 14, 34, 18, 2, -31 },
  { 134, 21, 27, 25, 2, -27 },
  { 205, 17, 27, 20, 2, -27 },
  { 263, 2, 8, 6, 2, -29 },
  { 265, 7, 39, 11, 3, -30 },
  { 300, 7, 39, 11, 1, -30 },
  { 335, 15, 15, 16, 1, -27 },
  { 364, 15, 19, 19, 2, -22 },
  { 400, 4, 8, 7, 1, -3 },
  { 404, 8, 1, 10, 1, -13 },
  { 405, 2, 2, 9, 3, -2 },
  { 406, 11, 29, 13, 1, -27 },
  { 446, 14, 27, 18, 2, -27 },
  { 494, 8, 27, 18, 3, -27 },
  { 521, 15, 27, 18, 2, -27 },
  { 572, 14, 27, 18, 2, -27 },
  { 620, 17, 27, 18, 1, -27 },
  { 678, 14, 27, 18, 3, -27 },
  { 726, 14, 27, 18, 2, -27 },
  { 774, 14, 27, 18, 2, -27 },
  { 822, 15, 27, 18, 2, -27 },
  { 873, 14, 27, 18, 2, -27 },
  { 921, 3, 20, 7, 2, -20 },
  { 929, 4, 25, 7, 1, -20 },
  { 942, 13, 15, 17, 2, -20 },
  { 967, 13, 9, 19, 3, -17 },
  { 982, 13, 15, 17, 2, -20 },
  { 1007, 11, 27, 15, 2, -27 },
  { 1045, 26, 34, 30, 2, -26 },
  { 1156, 19, 27, 20, 1, -27 },
  { 1221, 15, 27, 20, 3, -27 },
  { 1272, 16, 27, 22, 3, -27 },
  { 1326, 16, 27, 22, 3, -27 },
  { 1380, 14, 27, 19, 3, -27 },
  { 1428, 15, 27, 19, 3, -27 },
  { 1479, 17, 27, 23, 3, -27 },
  { 1537, 17, 27, 23, 3, -27 },
  { 1595, 1, 27, 9, 4, -27 },
  { 1599, 13, 27, 18, 2, -27 },
  { 1643, 17, 27, 21, 3, -27 },
  { 1701, 13, 27, 17, 3, -27 },
  { 1745, 22, 27, 28, 3, -27 },
  { 1820, 17, 27, 23, 3, -27 },
  { 1878, 17, 27, 22, 3, -27 },
  { 1936, 15, 27, 20, 3, -27 },
  { 1987, 18, 32, 22, 2, -27 },
  { 2059, 16, 27, 21, 3, -27 },
  { 2113, 16, 27, 20, 2, -27 },
  { 2167, 18, 27, 20, 1, -27 },
  { 2228, 16, 27, 22, 3, -27 },
  { 2282, 18, 27, 20, 1, -27 },
  { 2343, 27, 27, 30, 1, -27 },
  { 2435, 18, 27, 20, 1, -27 },
  { 2496, 18, 27, 20, 1, -27 },
  { 2557, 16, 27, 20, 2, -27 },
  { 2611, 5, 37, 8, 3, -31 },
  { 2635, 11, 29, 13, 1, -27 },
  { 2675, 5, 37, 8, 0, -31 },
  { 2699, 10, 13, 14, 2, -27 },
  { 2716, 14, 1, 14, 0, 0 },
  { 2718, 6, 5, 10, 2, -28 },
  { 2722, 13, 20, 18, 2, -20 },
  { 2755, 13, 29, 18, 3, -29 },
  { 2803, 13, 20, 17, 2, -20 },
  { 2836, 14, 29, 18, 2, -29 },
  { 2887, 14, 20, 17, 2, -20 },
  { 2922, 10, 29, 11, 1, -29 },
  { 2959, 14, 28, 18, 2, -20 },
  { 3008, 12, 29, 18, 3, -29 },
  { 3052, 2, 27, 8, 3, -27 },
  { 3059, 7, 35, 8, -2, -27 },
  { 3090, 13, 29, 16, 3, -29 },
  { 3138, 2, 29, 8, 3, -29 },
  { 3146, 24, 20, 29, 3, -20 },
  { 3206, 12, 20, 18, 3, -20 },
  { 3236, 14, 20, 19, 2, -20 },
  { 3271, 13, 28, 18, 3, -20 },
  { 3317, 14, 28, 18, 2, -20 },
  { 3366, 8, 20, 12, 3, -20 },
  { 3386, 13, 20, 17, 2, -20 },
  { 3419, 8, 25, 11, 1, -25 },
  { 3444, 12, 20, 18, 3, -20 },
  { 3474, 14, 20, 16, 1, -20 },
  { 3509, 22, 20, 25, 1, -20 },
  { 3564, 14, 20, 16, 1, -20 },
  { 3599, 14, 28, 16, 1, -20 },
  { 3648, 13, 20, 16, 2, -20 },
  { 3681, 10, 38, 11, 1, -30 },
  { 3729, 2, 32, 8, 3, -27 },
  { 3737, 10, 38, 11, 0, -30 },
  { 3785, 17, 6, 23, 3, -14 },
};

const GFXfont RobotoCondensed_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT38PT7B_H_
