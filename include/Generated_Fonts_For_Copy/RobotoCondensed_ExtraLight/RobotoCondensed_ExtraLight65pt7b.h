#ifndef _ROBOTOCONDENSED_EXTRALIGHT65PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x00, 0x00, 0x00, 0x7F, 0xD8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x60, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1F, 0x00,
  0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x38, 0x06, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x30,
  0x01, 0x80, 0x18, 0x0E, 0x00, 0x30, 0x03, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x70, 0x00, 0xE0, 0x1C, 0x0C, 0x00, 0x0C, 0x03, 0x03, 0x80, 0x00, 0xE0,
  0xE0, 0x60, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x03, 0xF0, 0x00, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x30, 0x38, 0x70, 0x00,
  0x0C, 0x0C, 0x03, 0x00, 0x03, 0x81, 0x80, 0x70, 0x00, 0x60, 0x60, 0x06,
  0x00, 0x1C, 0x0C, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x30,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x18, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x04, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0xC3, 0x80, 0x70, 0x06, 0x38, 0x03, 0x80, 0x31, 0x80,
  0x0E, 0x01, 0x9C, 0x00, 0x38, 0x0C, 0xC0, 0x00, 0xE0, 0x66, 0x00, 0x07,
  0x07, 0x30, 0x00, 0x1C, 0x31, 0x80, 0x00, 0x71, 0x8C, 0x00, 0x01, 0x9C,
  0x60, 0x00, 0x0E, 0xC3, 0x00, 0x00, 0x3E, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x07, 0x70, 0x70, 0x00,
  0x71, 0xC1, 0xE0, 0x0F, 0x0E, 0x07, 0xFF, 0xF0, 0x38, 0x0F, 0xFE, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0x80, 0x00, 0x10,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x04, 0x40,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x0C, 0x01, 0xBE, 0x03, 0x03, 0xE7, 0xF0, 0xC3, 0xF0,
  0x3F, 0xB7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0C,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x00, 0x70, 0x04, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x9C, 0x61, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF6, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x7E, 0x1F, 0xF3, 0xE3, 0xFC, 0x1F, 0x80, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1E,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x38, 0x70, 0x00, 0x18, 0x60,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0xC0, 0x03, 0x80, 0xF8, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xFC, 0x00, 0xCF, 0xFF, 0x01,
  0xBE, 0x3F, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x30, 0x70, 0x00, 0xE0, 0x78, 0x07, 0x80,
  0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x7F, 0x00,
  0x61, 0xFF, 0xC0, 0x63, 0xE3, 0xF0, 0xE7, 0x00, 0x78, 0xEC, 0x00, 0x38,
  0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x19, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x80, 0x01, 0x80, 0xE0, 0x01, 0xC0,
  0x38, 0x03, 0xC0, 0x0F, 0x87, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x03, 0xE0, 0x7C, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC0,
  0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0xF0,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x30, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x1B, 0x1E, 0x00, 0x3B,
  0x0F, 0x00, 0xF3, 0x07, 0xC3, 0xE3, 0x03, 0xFF, 0x83, 0x00, 0x7E, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF7, 0xBC, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xDE, 0xF3, 0x00, 0x3C, 0xF3, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3,
  0x1C, 0x61, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0C,
  0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0xFF, 0x00,
  0x06, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x63, 0x00, 0x07, 0x00, 0xE0, 0x06,
  0x30, 0x00, 0xE0, 0x0E, 0x00, 0x67, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x36, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x36, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xE0, 0x06, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x6C, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x6C, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x6C, 0x00, 0xC0, 0x03,
  0x80, 0x0C, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0xC6, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x60, 0x06, 0x00, 0x5C, 0x01, 0x86, 0x00, 0x70, 0x0C, 0xC0, 0x30,
  0x70, 0x03, 0x01, 0x8E, 0x07, 0x07, 0x00, 0x3F, 0xF0, 0x79, 0xE0, 0x30,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x01, 0xFC, 0x18,
  0x00, 0x0F, 0x0C, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x3E, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0x80, 0x01, 0xF0, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x0F, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x7F, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x07, 0x80, 0x1E, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0x00, 0x1F, 0xC0,
  0x60, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x83,
  0x00, 0x01, 0xE0, 0x60, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xDC,
  0x00, 0x01, 0xB8, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xF0, 0x01, 0xC0, 0xF0, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF0,
  0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C,
  0x1E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC7, 0xE0,
  0x00, 0x0C, 0xE7, 0x00, 0x00, 0xDC, 0x38, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0,
  0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xEC, 0x00, 0x00, 0x00, 0xFF, 0x60, 0x00, 0x00,
  0x07, 0xFB, 0x80, 0x00, 0x00, 0x37, 0xCC, 0x00, 0x00, 0x03, 0xBE, 0x60,
  0x00, 0x00, 0x19, 0xF3, 0x80, 0x00, 0x00, 0xCF, 0x8C, 0x00, 0x00, 0x0E,
  0x7C, 0x70, 0x00, 0x00, 0x63, 0xE3, 0x80, 0x00, 0x03, 0x1F, 0x0C, 0x00,
  0x00, 0x38, 0xF8, 0x70, 0x00, 0x01, 0x87, 0xC1, 0x80, 0x00, 0x1C, 0x3E,
  0x0C, 0x00, 0x00, 0xE1, 0xF0, 0x70, 0x00, 0x06, 0x0F, 0x81, 0x80, 0x00,
  0x70, 0x7C, 0x0C, 0x00, 0x03, 0x03, 0xE0, 0x70, 0x00, 0x18, 0x1F, 0x01,
  0x80, 0x01, 0xC0, 0xF8, 0x0E, 0x00, 0x0C, 0x07, 0xC0, 0x70, 0x00, 0x60,
  0x3E, 0x01, 0x80, 0x07, 0x01, 0xF0, 0x0E, 0x00, 0x30, 0x0F, 0x80, 0x30,
  0x01, 0x80, 0x7C, 0x01, 0x80, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0xC0, 0x1F,
  0x00, 0x30, 0x0E, 0x00, 0xF8, 0x01, 0x80, 0x60, 0x07, 0xC0, 0x0E, 0x03,
  0x00, 0x3E, 0x00, 0x30, 0x38, 0x01, 0xF0, 0x01, 0xC1, 0x80, 0x0F, 0x80,
  0x0E, 0x0C, 0x00, 0x7C, 0x00, 0x30, 0xE0, 0x03, 0xE0, 0x01, 0xC6, 0x00,
  0x1F, 0x00, 0x06, 0x30, 0x00, 0xF8, 0x00, 0x33, 0x80, 0x07, 0xC0, 0x01,
  0xD8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x03, 0xC3, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x03, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x01, 0x80, 0x03,
  0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0x80,
  0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x06, 0x3C,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x30, 0x00, 0xFE, 0x18, 0x00, 0x07, 0x8C, 0x00, 0x01, 0xE6, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x79, 0x80, 0x00, 0x78, 0xC0, 0x03,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x0F, 0xE0, 0x60, 0x00, 0x1E, 0x0C,
  0x00, 0x01, 0xE1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x3C,
  0x30, 0x00, 0x0F, 0x06, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x78, 0x01, 0xF0,
  0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x70, 0x78, 0x00, 0x1C, 0x07, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0x18, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x81, 0xC0, 0x01, 0x83,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0xE0, 0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x18, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x70, 0x60, 0x00, 0xC1, 0xC0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x60, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x81, 0x80, 0x60, 0xE0, 0x18,
  0x30, 0x07, 0x0C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0E, 0x60, 0x01, 0xB8,
  0x00, 0x6C, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87,
  0x00, 0x03, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x00, 0x30, 0xF0, 0x00, 0x63, 0x80, 0x00, 0xCE, 0x00, 0x01,
  0x9C, 0x00, 0x03, 0x30, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x9C,
  0x00, 0x1B, 0x38, 0x00, 0x76, 0x3C, 0x03, 0xCE, 0x3F, 0xFF, 0x1C, 0x3F,
  0xF8, 0x38, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x1F, 0x00,
  0x60, 0xFF, 0xC0, 0xC7, 0xFF, 0xE1, 0x9C, 0x01, 0xC3, 0x70, 0x01, 0xC6,
  0xC0, 0x01, 0xCF, 0x00, 0x01, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x80, 0x01, 0xCF,
  0x00, 0x03, 0x9B, 0x00, 0x0E, 0x33, 0x80, 0x38, 0x63, 0xFF, 0xE0, 0xC3,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x78, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x37, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x0E, 0x00,
  0x1C, 0x0F, 0x00, 0x70, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3E, 0x03, 0x83, 0xFF, 0x87, 0x0F,
  0xFF, 0x8E, 0x3C, 0x03, 0x9C, 0xF0, 0x01, 0xB9, 0xC0, 0x01, 0xF7, 0x00,
  0x01, 0xEC, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF3, 0x80, 0x03, 0xE7, 0x80,
  0x0F, 0xC7, 0x80, 0x3B, 0x87, 0xFF, 0xE7, 0x03, 0xFF, 0x0E, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x00,
  0xF0, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x1E, 0x00,
  0x0E, 0x0F, 0x80, 0x3C, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xFF,
  0xFE, 0x7F, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x1C, 0x3F, 0xFE, 0x38, 0xF0, 0x0E, 0x73,
  0xC0, 0x06, 0xE7, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xB0, 0x00, 0x0F, 0x60,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0xCE, 0x00, 0x0F, 0x9E, 0x00, 0x3F, 0x1E, 0x00, 0xEE, 0x1F,
  0xFF, 0x9C, 0x0F, 0xFC, 0x38, 0x07, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xF0, 0x7C,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0xF8, 0x18, 0x1F, 0xF0,
  0xC3, 0xFF, 0xC6, 0x38, 0x07, 0x33, 0x80, 0x1D, 0xB8, 0x00, 0x6D, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0x1C, 0xCF, 0x9F, 0xE1, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x8C, 0x00, 0x1C, 0x30,
  0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0x0E,
  0x00, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x70, 0x00,
  0xC3, 0x80, 0x03, 0x1C, 0x00, 0x0C, 0xF8, 0x00, 0x37, 0x60, 0x00, 0xF9,
  0xC0, 0x03, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x07, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x60, 0xFF,
  0xC0, 0x1F, 0xF8, 0x30, 0xFF, 0xF0, 0x3F, 0xFE, 0x18, 0xE0, 0x3C, 0x3C,
  0x03, 0x8C, 0xC0, 0x07, 0x18, 0x00, 0xE6, 0xC0, 0x03, 0x98, 0x00, 0x33,
  0x60, 0x00, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00,
  0x30, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x06, 0x07, 0xFC, 0x30, 0xFF,
  0xF1, 0x8E, 0x01, 0xCC, 0xE0, 0x07, 0x6E, 0x00, 0x1B, 0x60, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x30, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0x83, 0xFF, 0x03, 0x1F, 0xFF, 0x86, 0x70, 0x07,
  0x0D, 0x80, 0x07, 0x1A, 0x00, 0x07, 0x3C, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0x3C, 0x00, 0x0E, 0x6C, 0x00, 0x38, 0xCE, 0x00, 0xE1,
  0x8F, 0xFF, 0x83, 0x0F, 0xFE, 0x06, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE,
  0x1C, 0x3F, 0xFF, 0x38, 0xF0, 0x0F, 0x73, 0x80, 0x06, 0xE7, 0x00, 0x07,
  0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xCE, 0x00, 0x0F,
  0x9E, 0x00, 0x3F, 0x1E, 0x00, 0xEE, 0x1F, 0xFF, 0x9C, 0x0F, 0xFC, 0x38,
  0x07, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x7E, 0x0F, 0xF1, 0xFF, 0x9E, 0x0C, 0xC0, 0x6C, 0x03, 0x40,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x3C, 0x38, 0x00, 0x70,
  0xC0, 0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x03, 0x8E,
  0x00, 0x0E, 0x1E, 0x00, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xE0,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x76, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0xE0, 0x03, 0x67, 0x80, 0x73,
  0x1F, 0xFF, 0x18, 0x7F, 0xF0, 0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x07,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x3C, 0x00, 0x0D, 0xC0, 0x01, 0xE0, 0x00, 0x66, 0x00, 0x0F, 0x80,
  0x07, 0x30, 0x00, 0x6C, 0x00, 0x39, 0xC0, 0x07, 0x60, 0x01, 0x8E, 0x00,
  0x33, 0x00, 0x0C, 0x30, 0x01, 0x9C, 0x00, 0xE1, 0x80, 0x0C, 0xE0, 0x07,
  0x0E, 0x00, 0xE3, 0x00, 0x30, 0x70, 0x06, 0x18, 0x01, 0x81, 0x80, 0x30,
  0xE0, 0x1C, 0x0C, 0x03, 0x83, 0x00, 0xE0, 0x70, 0x18, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0xE0, 0x30, 0x0C, 0x06, 0x07, 0x03, 0x80, 0x60, 0x70, 0x18,
  0x1C, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x07, 0x06, 0x00, 0x60,
  0xC0, 0x18, 0x70, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x1C, 0x60, 0x06, 0x18,
  0x00, 0xE3, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x19, 0x80,
  0x06, 0x70, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x07, 0x60, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x83,
  0x80, 0x01, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00, 0x01, 0xC3,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xCF, 0x3E, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x36, 0x00, 0xE0,
  0x03, 0xF0, 0x03, 0x80, 0x1B, 0x00, 0x0E, 0x00, 0xD8, 0x00, 0x38, 0x0C,
  0xC0, 0x00, 0xF1, 0xE6, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 47, 13, 5, -46 },
  { 19, 9, 14, 18, 5, -49 },
  { 35, 30, 46, 32, 2, -46 },
  { 208, 24, 60, 31, 4, -53 },
  { 388, 35, 48, 42, 4, -47 },
  { 598, 29, 48, 35, 4, -47 },
  { 772, 3, 14, 11, 4, -49 },
  { 778, 13, 67, 18, 4, -52 },
  { 887, 13, 67, 19, 1, -52 },
  { 996, 26, 25, 27, 1, -46 },
  { 1078, 26, 34, 32, 3, -38 },
  { 1189, 6, 14, 12, 2, -5 },
  { 1200, 13, 2, 17, 2, -22 },
  { 1204, 4, 4, 15, 5, -3 },
  { 1206, 18, 50, 23, 2, -46 },
  { 1319, 24, 48, 31, 4, -47 },
  { 1463, 13, 46, 31, 6, -46 },
  { 1538, 24, 47, 31, 4, -47 },
  { 1679, 25, 48, 31, 3, -47 },
  { 1829, 27, 46, 31, 3, -46 },
  { 1985, 23, 47, 31, 5, -46 },
  { 2121, 24, 47, 31, 4, -46 },
  { 2262, 25, 46, 31, 3, -46 },
  { 2406, 25, 48, 31, 3, -47 },
  { 2556, 24, 47, 31, 3, -47 },
  { 2697, 5, 34, 12, 4, -33 },
  { 2719, 6, 42, 11, 2, -33 },
  { 2751, 22, 26, 29, 3, -34 },
  { 2823, 22, 15, 32, 5, -29 },
  { 2865, 22, 26, 30, 4, -34 },
  { 2937, 20, 48, 26, 3, -47 },
  { 3057, 44, 59, 52, 4, -45 },
  { 3382, 32, 46, 35, 1, -46 },
  { 3566, 25, 46, 35, 6, -46 },
  { 3710, 28, 48, 37, 5, -47 },
  { 3878, 27, 46, 37, 6, -46 },
  { 4034, 24, 46, 33, 6, -46 },
  { 4172, 24, 46, 32, 6, -46 },
  { 4310, 29, 48, 39, 5, -47 },
  { 4484, 28, 46, 40, 6, -46 },
  { 4645, 2, 46, 16, 7, -46 },
  { 4657, 23, 47, 31, 3, -46 },
  { 4793, 28, 46, 36, 6, -46 },
  { 4954, 22, 46, 30, 6, -46 },
  { 5081, 37, 46, 49, 6, -46 },
  { 5294, 28, 46, 40, 6, -46 },
  { 5455, 30, 48, 38, 4, -47 },
  { 5635, 25, 46, 35, 6, -46 },
  { 5779, 30, 55, 38, 4, -47 },
  { 5986, 27, 46, 37, 6, -46 },
  { 6142, 28, 48, 34, 3, -47 },
  { 6310, 30, 46, 34, 2, -46 },
  { 6483, 27, 47, 38, 5, -46 },
  { 6642, 32, 46, 35, 1, -46 },
  { 6826, 47, 46, 51, 2, -46 },
  { 7097, 30, 46, 34, 2, -46 },
  { 7270, 32, 46, 34, 1, -46 },
  { 7454, 28, 46, 34, 3, -46 },
  { 7615, 8, 63, 14, 5, -53 },
  { 7678, 19, 50, 22, 2, -46 },
  { 7797, 8, 63, 14, 1, -53 },
  { 7860, 18, 23, 24, 3, -46 },
  { 7912, 23, 2, 24, 1, 0 },
  { 7918, 9, 9, 18, 4, -49 },
  { 7929, 23, 36, 31, 3, -35 },
  { 8033, 23, 50, 32, 5, -49 },
  { 8177, 23, 36, 29, 3, -35 },
  { 8281, 23, 50, 32, 4, -49 },
  { 8425, 24, 36, 30, 3, -35 },
  { 8533, 17, 50, 19, 2, -50 },
  { 8640, 23, 48, 32, 4, -35 },
  { 8778, 21, 49, 31, 5, -49 },
  { 8907, 3, 46, 13, 5, -46 },
  { 8925, 11, 59, 13, -3, -46 },
  { 9007, 22, 49, 28, 5, -49 },
  { 9142, 3, 49, 13, 5, -49 },
  { 9161, 41, 35, 50, 5, -35 },
  { 9341, 21, 35, 31, 5, -35 },
  { 9433, 24, 36, 32, 4, -35 },
  { 9541, 23, 48, 32, 5, -35 },
  { 9679, 23, 48, 32, 4, -35 },
  { 9817, 13, 35, 20, 5, -35 },
  { 9874, 22, 36, 29, 3, -35 },
  { 9973, 15, 44, 19, 1, -43 },
  { 10056, 21, 35, 31, 5, -34 },
  { 10148, 24, 34, 28, 2, -34 },
  { 10250, 37, 34, 43, 3, -34 },
  { 10408, 24, 34, 28, 2, -34 },
  { 10510, 24, 47, 27, 2, -34 },
  { 10651, 23, 34, 28, 3, -34 },
  { 10749, 16, 65, 19, 2, -51 },
  { 10879, 2, 55, 14, 6, -46 },
  { 10893, 16, 65, 19, 1, -51 },
  { 11023, 29, 11, 39, 5, -25 },
};

const GFXfont RobotoCondensed_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT65PT7B_H_
