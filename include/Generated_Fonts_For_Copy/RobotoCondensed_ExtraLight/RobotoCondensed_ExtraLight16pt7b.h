#ifndef _ROBOTOCONDENSED_EXTRALIGHT16PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xFC, 0x24, 0x48, 0x97, 0xF2, 0x85, 0x12, 0x24, 0xFC,
  0x91, 0x22, 0x80, 0x10, 0x47, 0xA1, 0x86, 0x08, 0x18, 0x18, 0x10, 0x61,
  0x85, 0xE1, 0x00, 0x60, 0x90, 0x94, 0x94, 0x68, 0x08, 0x10, 0x17, 0x25,
  0x25, 0x05, 0x07, 0x30, 0x91, 0x22, 0x45, 0x04, 0x18, 0x49, 0x8B, 0x0A,
  0x13, 0xD0, 0xE0, 0x25, 0x29, 0x24, 0x92, 0x48, 0x91, 0x20, 0x89, 0x12,
  0x49, 0x24, 0x92, 0x52, 0x80, 0x10, 0x23, 0xF0, 0x82, 0x88, 0x80, 0x20,
  0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0xE0, 0xE0, 0x80, 0x08, 0x44, 0x21,
  0x10, 0x84, 0x22, 0x10, 0x88, 0x00, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x9C, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x72, 0x28, 0x41,
  0x08, 0x21, 0x04, 0x21, 0x04, 0x3F, 0x7A, 0x28, 0x41, 0x08, 0xC0, 0x81,
  0x06, 0x18, 0x5E, 0x08, 0x61, 0x8A, 0x29, 0x24, 0xA2, 0xFC, 0x20, 0x82,
  0x7D, 0x04, 0x10, 0xF8, 0x10, 0x41, 0x06, 0x14, 0x4E, 0x39, 0x04, 0x20,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x5E, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x84, 0x10, 0x7A, 0x18, 0x61, 0x85, 0xE4, 0xA1, 0x86, 0x18, 0x5E,
  0x72, 0x28, 0x61, 0x86, 0x18, 0xDD, 0x04, 0x20, 0x9C, 0x81, 0x81, 0xC0,
  0x09, 0xB1, 0x83, 0x04, 0xFC, 0x00, 0x00, 0xFC, 0x83, 0x06, 0x36, 0x40,
  0x74, 0x62, 0x10, 0x88, 0x84, 0x20, 0x00, 0x00, 0x1F, 0x04, 0x19, 0x01,
  0x27, 0x19, 0x13, 0x22, 0x64, 0x4C, 0x91, 0x92, 0x32, 0x4A, 0x37, 0x40,
  0x04, 0x00, 0x40, 0x07, 0x80, 0x08, 0x18, 0x14, 0x14, 0x24, 0x24, 0x22,
  0x3E, 0x42, 0x41, 0x41, 0x81, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41,
  0x83, 0x06, 0x17, 0xC0, 0x3C, 0x86, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x83,
  0x05, 0x09, 0xE0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x17, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x3F, 0xFE,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x3C, 0x86, 0x0C, 0x08,
  0x10, 0x23, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xFF, 0xF0, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x0C, 0x62, 0xE0, 0x83, 0x0A, 0x24, 0x89, 0x14, 0x34, 0x48, 0x89,
  0x0A, 0x14, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0x80, 0x70, 0x3C, 0x0E, 0x85, 0xA1, 0x68, 0x59, 0x26, 0x49, 0x92, 0x63,
  0x18, 0xC6, 0x21, 0x83, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5, 0x87, 0x0E,
  0x0C, 0x10, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09,
  0xE0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00,
  0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x40,
  0x40, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x85, 0x0A, 0x0C, 0x10,
  0x79, 0x0A, 0x0C, 0x08, 0x0E, 0x02, 0x02, 0x03, 0x06, 0x13, 0xC0, 0xFF,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x81, 0x41,
  0x41, 0x42, 0x22, 0x22, 0x24, 0x24, 0x14, 0x14, 0x08, 0x08, 0x84, 0x30,
  0x86, 0x30, 0xC5, 0x28, 0xA4, 0xA4, 0x94, 0x92, 0x8A, 0x51, 0x8C, 0x30,
  0x86, 0x10, 0x40, 0x83, 0x09, 0x12, 0x42, 0x82, 0x04, 0x14, 0x48, 0x8A,
  0x14, 0x10, 0x81, 0x42, 0x42, 0x22, 0x24, 0x14, 0x18, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFC, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x07,
  0xF0, 0xEA, 0xAA, 0xAA, 0xAC, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82,
  0x10, 0x80, 0xD5, 0x55, 0x55, 0x5C, 0x46, 0x69, 0x99, 0xFC, 0x90, 0x74,
  0x42, 0x17, 0xC6, 0x31, 0x78, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x7E, 0x74, 0x63, 0x08, 0x42, 0x31, 0x70, 0x04, 0x10, 0x5D, 0x8E,
  0x18, 0x61, 0x86, 0x18, 0xDD, 0x72, 0x28, 0x7F, 0x82, 0x08, 0x20, 0x78,
  0x74, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x76, 0x38, 0x61, 0x86, 0x18, 0x63,
  0x74, 0x10, 0x9E, 0x82, 0x08, 0x2E, 0xCA, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x70, 0x82, 0x08, 0x22, 0x92,
  0x8A, 0x38, 0xA2, 0x48, 0xA2, 0xFF, 0xF0, 0xBB, 0xB1, 0x18, 0x46, 0x11,
  0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x40, 0xBB, 0x28, 0x61, 0x86, 0x18,
  0x61, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x76, 0x38, 0x61, 0x86, 0x18, 0x63,
  0x74, 0x10, 0x41, 0xE8, 0x88, 0x88, 0x88, 0x80, 0x74, 0x60, 0x83, 0x04,
  0x31, 0x70, 0x44, 0xF4, 0x44, 0x44, 0x42, 0x30, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x63, 0x74, 0x85, 0x14, 0x51, 0x28, 0xA2, 0x8C, 0x10, 0x88, 0xC4,
  0x66, 0x52, 0xA9, 0x53, 0x29, 0x94, 0xC4, 0x02, 0x00, 0x45, 0x12, 0x8C,
  0x10, 0xA2, 0x91, 0x44, 0x85, 0x14, 0x52, 0x28, 0xA2, 0x84, 0x10, 0x42,
  0x18, 0xF8, 0x44, 0x42, 0x21, 0x10, 0xF8, 0x24, 0x44, 0x44, 0x48, 0x44,
  0x44, 0x44, 0x20, 0xFF, 0xFC, 0x84, 0x22, 0x22, 0x21, 0x22, 0x22, 0x24,
  0x80, 0x63, 0x26, 0x38,
};

const GFXglyph RobotoCondensed_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 2, 3, 4, 1, -12 },
  { 4, 7, 12, 8, 1, -12 },
  { 15, 6, 15, 8, 1, -14 },
  { 27, 8, 12, 10, 1, -12 },
  { 39, 7, 12, 9, 1, -12 },
  { 50, 1, 3, 3, 1, -12 },
  { 51, 3, 17, 4, 1, -13 },
  { 58, 3, 17, 5, 0, -13 },
  { 65, 7, 6, 7, 0, -12 },
  { 71, 6, 9, 8, 1, -10 },
  { 78, 1, 3, 3, 1, -1 },
  { 79, 3, 1, 4, 1, -6 },
  { 80, 1, 1, 4, 1, -1 },
  { 81, 5, 13, 6, 0, -12 },
  { 90, 6, 12, 8, 1, -12 },
  { 99, 4, 12, 8, 1, -12 },
  { 105, 6, 12, 8, 1, -12 },
  { 114, 6, 12, 8, 1, -12 },
  { 123, 6, 12, 8, 1, -12 },
  { 132, 6, 12, 8, 1, -12 },
  { 141, 6, 12, 8, 1, -12 },
  { 150, 6, 12, 8, 1, -12 },
  { 159, 6, 12, 8, 1, -12 },
  { 168, 6, 12, 8, 1, -12 },
  { 177, 1, 8, 3, 1, -8 },
  { 178, 1, 10, 3, 1, -8 },
  { 180, 5, 6, 7, 1, -8 },
  { 184, 6, 5, 8, 1, -8 },
  { 188, 5, 6, 7, 1, -8 },
  { 192, 5, 12, 6, 1, -12 },
  { 200, 11, 15, 13, 1, -11 },
  { 221, 8, 12, 9, 0, -12 },
  { 233, 7, 12, 9, 1, -12 },
  { 244, 7, 12, 9, 1, -12 },
  { 255, 7, 12, 9, 1, -12 },
  { 266, 6, 12, 8, 1, -12 },
  { 275, 6, 12, 8, 1, -12 },
  { 284, 7, 12, 10, 1, -12 },
  { 295, 7, 12, 10, 1, -12 },
  { 306, 1, 12, 4, 1, -12 },
  { 308, 5, 12, 8, 1, -12 },
  { 316, 7, 12, 9, 1, -12 },
  { 327, 6, 12, 7, 1, -12 },
  { 336, 10, 12, 12, 1, -12 },
  { 351, 7, 12, 10, 1, -12 },
  { 362, 7, 12, 9, 1, -12 },
  { 373, 7, 12, 9, 1, -12 },
  { 384, 7, 14, 9, 1, -12 },
  { 397, 7, 12, 9, 1, -12 },
  { 408, 7, 12, 8, 1, -12 },
  { 419, 8, 12, 8, 0, -12 },
  { 431, 7, 12, 9, 1, -12 },
  { 442, 8, 12, 9, 0, -12 },
  { 454, 11, 12, 12, 1, -12 },
  { 471, 7, 12, 8, 1, -12 },
  { 482, 8, 12, 8, 0, -12 },
  { 494, 7, 12, 8, 1, -12 },
  { 505, 2, 15, 3, 1, -13 },
  { 509, 5, 13, 6, 0, -12 },
  { 518, 2, 15, 3, 0, -13 },
  { 522, 4, 6, 6, 1, -12 },
  { 525, 6, 1, 6, 0, 0 },
  { 526, 2, 2, 4, 1, -12 },
  { 527, 5, 9, 8, 1, -9 },
  { 533, 6, 12, 8, 1, -12 },
  { 542, 5, 9, 7, 1, -9 },
  { 548, 6, 12, 8, 1, -12 },
  { 557, 6, 9, 7, 1, -9 },
  { 564, 4, 12, 5, 1, -12 },
  { 570, 6, 12, 8, 1, -9 },
  { 579, 6, 12, 8, 1, -12 },
  { 588, 1, 12, 3, 1, -12 },
  { 590, 3, 15, 3, -1, -12 },
  { 596, 6, 12, 7, 1, -12 },
  { 605, 1, 12, 3, 1, -12 },
  { 607, 10, 9, 12, 1, -9 },
  { 619, 6, 9, 8, 1, -9 },
  { 626, 6, 9, 8, 1, -9 },
  { 633, 6, 12, 8, 1, -9 },
  { 642, 6, 12, 8, 1, -9 },
  { 651, 4, 9, 5, 1, -9 },
  { 656, 5, 9, 7, 1, -9 },
  { 662, 4, 11, 5, 0, -11 },
  { 668, 6, 9, 8, 1, -9 },
  { 675, 6, 9, 7, 0, -9 },
  { 682, 9, 9, 11, 1, -9 },
  { 693, 6, 9, 7, 0, -9 },
  { 700, 6, 12, 7, 0, -9 },
  { 709, 5, 9, 7, 1, -9 },
  { 715, 4, 15, 5, 1, -12 },
  { 723, 1, 14, 3, 1, -12 },
  { 725, 4, 15, 5, 0, -12 },
  { 733, 7, 3, 10, 1, -6 },
};

const GFXfont RobotoCondensed_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT16PT7B_H_
