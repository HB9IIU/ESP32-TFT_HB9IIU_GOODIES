#ifndef _ROBOTOCONDENSED_EXTRALIGHT6PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0xC0, 0x09, 0x00, 0x53, 0x1A, 0x80, 0xE2, 0x53, 0xEB, 0x70,
  0xC0, 0x2A, 0x80, 0x78, 0x20, 0x49, 0x20, 0xC0, 0x00, 0x00, 0x5A, 0xF6,
  0xF0, 0xE0, 0xE5, 0x20, 0xE4, 0xF0, 0x0B, 0x80, 0x48, 0xB0, 0x1E, 0xF0,
  0x49, 0x00, 0xFE, 0xF0, 0xF5, 0x20, 0x00, 0x30, 0x60, 0xC0, 0x50, 0xD0,
  0x7D, 0xDF, 0x40, 0x4A, 0xC0, 0xF9, 0xD2, 0x60, 0x7D, 0x28, 0x28, 0xD2,
  0x70, 0x3C, 0x60, 0x17, 0x29, 0x28, 0x37, 0xA0, 0xBD, 0xF6, 0xF0, 0xF8,
  0xF6, 0xF0, 0xF9, 0xD8, 0xF0, 0x49, 0x20, 0x96, 0xF0, 0x95, 0x20, 0xAF,
  0xD5, 0xA9, 0x50, 0xA9, 0x20, 0x69, 0x60, 0xFC, 0xA5, 0x78, 0xA0, 0x00,
  0x80, 0xD8, 0x9A, 0xDE, 0xA8, 0x1F, 0xC0, 0xF8, 0x6A, 0x00, 0xFC, 0xAF,
  0x80, 0x70, 0x78, 0xAA, 0x80, 0xF8, 0xBB, 0x80, 0xF8, 0xF7, 0x80, 0xF7,
  0xC0, 0xFC, 0xA8, 0x9C, 0x60, 0xB8, 0xB4, 0x96, 0x00, 0x98, 0xB4, 0x58,
  0x60, 0x80, 0x70, 0x20, 0x80, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 1, 6, 2, 0, -5 },
  { 16, 2, 2, 3, 0, -4 },
  { 17, 3, 4, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 1, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 2, 2, 3, 0, -3 },
  { 45, 2, 2, 3, 0, -3 },
  { 46, 2, 2, 3, 0, -3 },
  { 47, 2, 4, 2, 0, -4 },
  { 48, 4, 5, 5, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 2, 4, 3, 1, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 2, 4, 3, 1, -4 },
  { 57, 2, 4, 3, 1, -4 },
  { 58, 2, 4, 3, 1, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 1, 4, 1, 0, -4 },
  { 63, 2, 4, 3, 0, -4 },
  { 64, 2, 4, 3, 1, -4 },
  { 65, 2, 4, 3, 1, -4 },
  { 66, 3, 4, 4, 1, -4 },
  { 68, 2, 4, 4, 1, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 2, 4, 3, 1, -4 },
  { 72, 3, 5, 4, 0, -4 },
  { 74, 2, 4, 3, 1, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 4, 4, 5, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 1, 6, 1, 0, -5 },
  { 92, 2, 4, 2, 0, -4 },
  { 93, 1, 6, 1, 0, -5 },
  { 94, 2, 2, 2, 0, -4 },
  { 95, 2, 1, 2, 0, 0 },
  { 96, 1, 1, 2, 0, -5 },
  { 97, 2, 3, 3, 0, -3 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 2, 3, 3, 0, -3 },
  { 101, 2, 5, 3, 0, -5 },
  { 103, 2, 3, 3, 0, -3 },
  { 104, 2, 5, 2, 0, -5 },
  { 106, 2, 4, 3, 0, -3 },
  { 107, 2, 5, 3, 0, -5 },
  { 109, 1, 4, 1, 0, -4 },
  { 110, 1, 5, 1, 0, -4 },
  { 111, 2, 5, 3, 0, -5 },
  { 113, 1, 5, 1, 0, -5 },
  { 114, 4, 3, 5, 0, -3 },
  { 116, 2, 3, 3, 0, -3 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 4, 3, 0, -3 },
  { 121, 2, 4, 3, 0, -3 },
  { 122, 2, 3, 2, 0, -3 },
  { 123, 2, 3, 3, 0, -3 },
  { 124, 1, 4, 2, 0, -4 },
  { 125, 2, 3, 3, 0, -3 },
  { 126, 2, 3, 3, 0, -3 },
  { 127, 4, 3, 4, 0, -3 },
  { 129, 2, 3, 3, 0, -3 },
  { 130, 2, 4, 3, 0, -3 },
  { 131, 2, 3, 3, 0, -3 },
  { 132, 2, 6, 2, 0, -5 },
  { 134, 1, 5, 1, 0, -4 },
  { 135, 2, 6, 2, 0, -5 },
  { 137, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoCondensed_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT6PT7B_H_
