#ifndef _ROBOTOCONDENSED_EXTRALIGHT34PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x05, 0xCE, 0x73, 0x9C, 0xE7, 0x20,
  0x01, 0x0C, 0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x02, 0x08, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x60, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x03, 0x8E, 0x10, 0x11, 0x00, 0xC8,
  0x02, 0x40, 0x12, 0x00, 0x90, 0x00, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x28, 0x01, 0xC0, 0x0F,
  0x00, 0x48, 0x02, 0x60, 0x31, 0xC7, 0x03, 0xE0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x3C, 0x00, 0x19, 0x80, 0x0C, 0x20, 0x02, 0x0C, 0x10, 0x81, 0x04,
  0x20, 0x42, 0x08, 0x11, 0x82, 0x0C, 0x40, 0xC2, 0x30, 0x11, 0x88, 0x03,
  0xC4, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x23, 0xC0, 0x11, 0x88, 0x0C,
  0x43, 0x02, 0x30, 0x41, 0x88, 0x10, 0x42, 0x04, 0x20, 0x81, 0x08, 0x30,
  0x40, 0x04, 0x30, 0x01, 0x88, 0x00, 0x3C, 0x0F, 0x00, 0x31, 0x00, 0xC1,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x18, 0x40, 0x11, 0x00,
  0x34, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x60, 0x04, 0x60, 0x90, 0x41, 0x60,
  0x42, 0x80, 0xC5, 0x00, 0xDA, 0x00, 0xA4, 0x00, 0xCC, 0x01, 0x8C, 0x05,
  0x8C, 0x31, 0x0F, 0xC3, 0xFE, 0xA8, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x83, 0x04, 0x08, 0x20, 0x41, 0x06, 0x08, 0x20, 0x83, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x08, 0x20, 0x86, 0x10, 0x42,
  0x08, 0x43, 0x08, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x41,
  0x0D, 0xE4, 0xE0, 0xFC, 0x00, 0xC0, 0x06, 0x80, 0x13, 0x00, 0x86, 0x06,
  0x08, 0x10, 0x10, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x24, 0x96, 0xB0,
  0xFE, 0xEC, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x0F,
  0x81, 0x8C, 0x20, 0x66, 0x02, 0x40, 0x3C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x22, 0x06, 0x18, 0xC0, 0xF8, 0x06,
  0x3D, 0xCC, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x0F, 0x81, 0x86, 0x18,
  0x18, 0x80, 0x4C, 0x03, 0x40, 0x1A, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x1F, 0xFF, 0x0F,
  0x83, 0x8C, 0x60, 0x24, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0xE0, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x16, 0x02, 0x30, 0xC0, 0xF8, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8,
  0x01, 0x10, 0x06, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x01, 0x02, 0x06,
  0x04, 0x08, 0x08, 0x30, 0x10, 0x40, 0x21, 0xFF, 0xFC, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x7F, 0xF6, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x05, 0xF0, 0x71,
  0xCC, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x38, 0x02, 0x40, 0x26, 0x06, 0x31, 0xC1, 0xF8, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x4F, 0x86, 0xC7,
  0x28, 0x09, 0x80, 0x6C, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x04, 0x80, 0x26, 0x03, 0x10, 0x10, 0x63, 0x01, 0xF0, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x0F, 0x81, 0xC6, 0x18, 0x08, 0x80, 0x6C,
  0x01, 0x60, 0x0B, 0x00, 0x58, 0x02, 0x40, 0x33, 0x01, 0x0E, 0x30, 0x1F,
  0x03, 0x06, 0x30, 0x1B, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0x30, 0x18, 0xC3, 0x83, 0xF0, 0x0F, 0x03, 0x1C, 0x60,
  0x64, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x03, 0x40, 0x36, 0x05, 0x31, 0xD1, 0xF1, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x24, 0xB5, 0x80, 0x00, 0x10,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0xE0, 0x08, 0x00, 0x1E, 0x18, 0xCC, 0x0A, 0x03, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x7F,
  0x00, 0x03, 0x83, 0x80, 0x18, 0x00, 0x80, 0x60, 0x00, 0x81, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x1E, 0x02, 0x60, 0x63, 0x06,
  0x81, 0x82, 0x05, 0x02, 0x04, 0x0E, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0xC0, 0x40, 0xC1, 0x81, 0x81, 0x82, 0x03, 0x03, 0x04,
  0x04, 0x06, 0x08, 0x08, 0x14, 0x18, 0x30, 0x28, 0x10, 0x70, 0xC8, 0x33,
  0x23, 0x10, 0x3C, 0x3C, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40,
  0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x18, 0x08, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C,
  0x3F, 0xFC, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0xFF, 0x84, 0x07, 0x20, 0x0D, 0x00, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x39, 0xFF, 0x88,
  0x06, 0x40, 0x0A, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x1A, 0x01, 0x9F, 0xF8, 0x07, 0xE0, 0x38, 0x70, 0xC0,
  0x31, 0x00, 0x26, 0x00, 0x68, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x0B, 0x00, 0x32, 0x00, 0x46, 0x01,
  0x87, 0x0E, 0x03, 0xF0, 0xFF, 0x82, 0x03, 0x88, 0x03, 0x20, 0x06, 0x80,
  0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x02, 0x80, 0x1A, 0x00, 0xC8, 0x0E, 0x3F, 0xE0, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0xFF, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xC8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x30, 0x60, 0x80, 0x62, 0x00, 0x6C,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x3F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x66, 0x01, 0x87, 0x1E, 0x03,
  0xF0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0xB0, 0x04, 0x80,
  0x24, 0x03, 0x30, 0x10, 0xE3, 0x01, 0xF0, 0x80, 0x0D, 0x00, 0x32, 0x00,
  0xC4, 0x01, 0x08, 0x04, 0x10, 0x18, 0x20, 0x60, 0x41, 0x80, 0x86, 0x01,
  0x08, 0x02, 0x20, 0x04, 0xE0, 0x0B, 0x60, 0x1C, 0x40, 0x30, 0xC0, 0x40,
  0xC0, 0x80, 0x81, 0x00, 0x82, 0x01, 0x84, 0x01, 0x88, 0x01, 0x10, 0x03,
  0x20, 0x03, 0x40, 0x02, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD0,
  0x00, 0x7A, 0x00, 0x0B, 0x60, 0x01, 0x64, 0x00, 0x6C, 0x80, 0x09, 0x88,
  0x01, 0x31, 0x00, 0x46, 0x30, 0x08, 0xC2, 0x03, 0x18, 0x40, 0x43, 0x0C,
  0x08, 0x60, 0x83, 0x0C, 0x10, 0x41, 0x83, 0x08, 0x30, 0x23, 0x06, 0x04,
  0x40, 0xC0, 0x48, 0x18, 0x0A, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x02,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x32, 0x00,
  0x62, 0x00, 0xC6, 0x01, 0x84, 0x03, 0x0C, 0x06, 0x08, 0x0C, 0x08, 0x18,
  0x18, 0x30, 0x10, 0x60, 0x30, 0xC0, 0x21, 0x80, 0x63, 0x00, 0x46, 0x00,
  0x4C, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x07, 0xE0,
  0x1C, 0x38, 0x30, 0x0C, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02,
  0x40, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x1C, 0x38, 0x07, 0xE0, 0xFF, 0xC4,
  0x03, 0x20, 0x0D, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x68, 0x06, 0x7F, 0xE2, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x1C, 0x38, 0x07,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0xFF, 0x82, 0x01,
  0x88, 0x03, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x01, 0xA0, 0x0C, 0x80, 0x63, 0xFE, 0x08, 0x08, 0x20,
  0x30, 0x80, 0x42, 0x01, 0x88, 0x02, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x28,
  0x00, 0xE0, 0x01, 0x0F, 0xC0, 0xE1, 0xC6, 0x01, 0x90, 0x02, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xC0, 0x0D, 0x80, 0x63, 0x87, 0x03, 0xF0, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x09, 0x80, 0x63,
  0x87, 0x03, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60,
  0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10,
  0x08, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x04,
  0x20, 0x06, 0x20, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x08, 0x01, 0x40, 0x18, 0x01, 0x40, 0x1C, 0x01,
  0x40, 0x14, 0x03, 0x60, 0x14, 0x02, 0x60, 0x24, 0x02, 0x20, 0x26, 0x02,
  0x20, 0x22, 0x06, 0x20, 0x22, 0x06, 0x30, 0x42, 0x04, 0x10, 0x43, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x10, 0x81, 0x08, 0x18, 0x81, 0x88,
  0x08, 0x80, 0x88, 0x09, 0x80, 0x98, 0x09, 0x00, 0x98, 0x0D, 0x00, 0xD0,
  0x05, 0x00, 0x50, 0x05, 0x00, 0x50, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10,
  0x08, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x20, 0x0C,
  0x30, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x40,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20,
  0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x60, 0x02, 0x40, 0x02, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0xF8,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xF8, 0x0C, 0x03, 0x00, 0xE0,
  0x68, 0x12, 0x04, 0xC3, 0x10, 0x84, 0x21, 0x98, 0x24, 0x09, 0x03, 0xFF,
  0xF0, 0xC3, 0x08, 0x21, 0x80, 0x1F, 0x83, 0x1C, 0x40, 0x6C, 0x02, 0x80,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x1F, 0xE7, 0x02, 0xC0, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x6C, 0x0E, 0x63, 0xA3, 0xE3, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0x0B, 0x1C, 0xC0,
  0x48, 0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x02, 0x80, 0x28, 0x02, 0x80, 0x6C, 0x04, 0xB1, 0xC9, 0xF0, 0x1F,
  0x83, 0x1C, 0x60, 0x6C, 0x02, 0x80, 0x38, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x38, 0x03, 0xC0, 0x24, 0x06, 0x30,
  0xC1, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x1F, 0x13, 0x1D, 0x60, 0x54, 0x03, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40,
  0x36, 0x07, 0x30, 0xD1, 0xF1, 0x0F, 0x83, 0x8C, 0x60, 0x6C, 0x02, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x02, 0x38, 0xE0, 0xF8, 0x07, 0x86, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x1F, 0x13, 0x1D, 0x60, 0x54, 0x03, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40,
  0x36, 0x07, 0x30, 0xD1, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x60,
  0x23, 0x0C, 0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x8F, 0x16, 0x3A, 0x81, 0x60, 0x38, 0x07, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0xD0, 0x05, 0x55, 0x55, 0x55, 0x55, 0x08, 0x40,
  0x00, 0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x11, 0x9B, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xD0, 0x12, 0x04, 0x41, 0x08, 0x61,
  0x18, 0x26, 0x05, 0x80, 0xF0, 0x19, 0x02, 0x30, 0x42, 0x08, 0x21, 0x06,
  0x20, 0x64, 0x04, 0x80, 0xD0, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x81,
  0xE3, 0x63, 0x18, 0xEF, 0x02, 0xC0, 0xB8, 0x0A, 0x02, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x1C, 0x01, 0x00, 0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00,
  0x40, 0x1C, 0x01, 0x00, 0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40,
  0x1C, 0x01, 0x00, 0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x10,
  0x8F, 0x16, 0x3A, 0x81, 0x60, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x0F, 0x81, 0xC6, 0x18, 0x08, 0x80, 0x6C, 0x01, 0x40, 0x0A, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x60, 0x09,
  0x00, 0xCC, 0x04, 0x38, 0xC0, 0x7C, 0x00, 0x9F, 0x0B, 0x1C, 0xC0, 0x48,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x6C, 0x04, 0xB1, 0xC9, 0xF0, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x1F, 0x13, 0x1D,
  0x60, 0x54, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x36, 0x07, 0x30, 0xD1, 0xF1,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x9F,
  0x63, 0x86, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x00, 0x1F, 0x0E, 0x39, 0x01, 0x40, 0x38, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x1E,
  0x03, 0x71, 0xC3, 0xE0, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC4, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x03,
  0x80, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1E, 0x05, 0x61,
  0xA7, 0xC4, 0x80, 0x16, 0x00, 0x90, 0x0C, 0x80, 0x46, 0x02, 0x10, 0x30,
  0x81, 0x06, 0x08, 0x10, 0x40, 0x84, 0x06, 0x20, 0x11, 0x00, 0x98, 0x04,
  0x80, 0x14, 0x00, 0xE0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x60, 0x34, 0x06,
  0x03, 0x40, 0x60, 0x26, 0x07, 0x02, 0x60, 0xD0, 0x62, 0x09, 0x06, 0x20,
  0x90, 0x42, 0x09, 0x84, 0x31, 0x08, 0x41, 0x10, 0x8C, 0x11, 0x08, 0x81,
  0x30, 0x48, 0x1A, 0x04, 0x80, 0xA0, 0x58, 0x0A, 0x05, 0x00, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x30, 0x40, 0x36, 0x02, 0x20, 0x63, 0x04, 0x10,
  0xC0, 0x88, 0x0D, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0D, 0x00, 0x98, 0x18,
  0x81, 0x0C, 0x30, 0x42, 0x06, 0x40, 0x3C, 0x01, 0x80, 0x16, 0x00, 0x90,
  0x0C, 0x80, 0x46, 0x02, 0x10, 0x30, 0x81, 0x86, 0x08, 0x10, 0x40, 0x86,
  0x06, 0x20, 0x11, 0x00, 0x98, 0x06, 0x80, 0x14, 0x00, 0xE0, 0x06, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x70,
  0x00, 0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x1F, 0xFC, 0x01, 0x01, 0x81, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x60, 0x70, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x03, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x30, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x30, 0x08, 0x03, 0x00, 0xC1, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x60, 0x20, 0x00,
  0x1C, 0x01, 0x23, 0x01, 0x41, 0x03, 0x40, 0x82, 0x40, 0x66, 0xC0, 0x3C,
};

const GFXglyph RobotoCondensed_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 24, 7, 2, -24 },
  { 7, 5, 7, 9, 2, -26 },
  { 12, 16, 24, 17, 1, -24 },
  { 60, 13, 30, 16, 2, -27 },
  { 109, 18, 24, 22, 2, -24 },
  { 163, 15, 24, 18, 2, -24 },
  { 208, 2, 7, 6, 2, -26 },
  { 210, 7, 35, 10, 2, -27 },
  { 241, 6, 35, 10, 1, -27 },
  { 268, 14, 13, 14, 0, -24 },
  { 291, 14, 17, 17, 1, -20 },
  { 321, 3, 7, 6, 1, -3 },
  { 324, 7, 1, 9, 1, -11 },
  { 325, 3, 2, 8, 2, -2 },
  { 326, 10, 26, 12, 1, -24 },
  { 359, 12, 24, 16, 2, -24 },
  { 395, 7, 24, 16, 3, -24 },
  { 416, 13, 24, 16, 2, -24 },
  { 455, 12, 24, 16, 2, -24 },
  { 491, 15, 24, 16, 1, -24 },
  { 536, 12, 24, 16, 3, -24 },
  { 572, 13, 24, 16, 2, -24 },
  { 611, 14, 24, 16, 1, -24 },
  { 653, 13, 24, 16, 2, -24 },
  { 692, 12, 24, 16, 2, -24 },
  { 728, 2, 18, 6, 2, -18 },
  { 733, 3, 22, 6, 1, -18 },
  { 742, 12, 14, 15, 1, -18 },
  { 763, 12, 8, 17, 2, -15 },
  { 775, 12, 14, 15, 2, -18 },
  { 796, 10, 24, 13, 2, -24 },
  { 826, 23, 31, 27, 2, -23 },
  { 916, 16, 24, 18, 1, -24 },
  { 964, 13, 24, 18, 3, -24 },
  { 1003, 15, 24, 19, 2, -24 },
  { 1048, 14, 24, 19, 3, -24 },
  { 1090, 13, 24, 17, 3, -24 },
  { 1129, 13, 24, 17, 3, -24 },
  { 1168, 15, 24, 20, 3, -24 },
  { 1213, 15, 24, 21, 3, -24 },
  { 1258, 2, 24, 8, 3, -24 },
  { 1264, 13, 24, 16, 1, -24 },
  { 1303, 15, 24, 19, 3, -24 },
  { 1348, 12, 24, 16, 3, -24 },
  { 1384, 19, 24, 25, 3, -24 },
  { 1441, 15, 24, 21, 3, -24 },
  { 1486, 16, 24, 20, 2, -24 },
  { 1534, 13, 24, 18, 3, -24 },
  { 1573, 16, 28, 20, 2, -24 },
  { 1629, 14, 24, 19, 3, -24 },
  { 1671, 14, 24, 18, 2, -24 },
  { 1713, 16, 24, 18, 1, -24 },
  { 1761, 14, 24, 20, 3, -24 },
  { 1803, 16, 24, 18, 1, -24 },
  { 1851, 24, 24, 27, 1, -24 },
  { 1923, 16, 24, 18, 1, -24 },
  { 1971, 16, 24, 18, 1, -24 },
  { 2019, 14, 24, 18, 2, -24 },
  { 2061, 4, 33, 7, 3, -28 },
  { 2078, 10, 26, 12, 1, -24 },
  { 2111, 5, 33, 7, 0, -28 },
  { 2132, 10, 12, 13, 1, -24 },
  { 2147, 12, 1, 13, 0, 0 },
  { 2149, 5, 5, 9, 2, -26 },
  { 2153, 12, 18, 16, 2, -18 },
  { 2180, 12, 26, 16, 3, -26 },
  { 2219, 12, 18, 15, 2, -18 },
  { 2246, 12, 26, 17, 2, -26 },
  { 2285, 12, 18, 15, 2, -18 },
  { 2312, 9, 26, 10, 1, -26 },
  { 2342, 12, 25, 17, 2, -18 },
  { 2380, 11, 26, 16, 3, -26 },
  { 2416, 2, 24, 7, 2, -24 },
  { 2422, 5, 31, 7, -1, -24 },
  { 2442, 11, 26, 15, 3, -26 },
  { 2478, 1, 26, 7, 3, -26 },
  { 2482, 22, 18, 26, 2, -18 },
  { 2532, 11, 18, 16, 3, -18 },
  { 2557, 13, 18, 17, 2, -18 },
  { 2587, 12, 25, 16, 3, -18 },
  { 2625, 12, 25, 17, 2, -18 },
  { 2663, 7, 18, 10, 3, -18 },
  { 2679, 11, 18, 15, 2, -18 },
  { 2704, 7, 23, 10, 1, -23 },
  { 2725, 11, 18, 16, 3, -18 },
  { 2750, 13, 18, 14, 1, -18 },
  { 2780, 20, 18, 22, 1, -18 },
  { 2825, 12, 18, 15, 1, -18 },
  { 2852, 13, 25, 14, 1, -18 },
  { 2893, 11, 18, 15, 2, -18 },
  { 2918, 9, 34, 10, 1, -27 },
  { 2957, 1, 28, 7, 3, -24 },
  { 2961, 9, 34, 10, 0, -27 },
  { 3000, 16, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT34PT7B_H_
