#ifndef _ROBOTOCONDENSED_EXTRALIGHT54PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x00, 0x2F, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2,
  0xC2, 0xC2, 0xC2, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18, 0x00, 0x10,
  0x0C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x20, 0x18, 0x00, 0x10, 0x0C,
  0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x03, 0xFE, 0x00, 0xFD, 0xF0, 0x1C, 0x03,
  0x81, 0x80, 0x1C, 0x30, 0x00, 0xE3, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00,
  0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x77, 0x00, 0x06, 0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x0F,
  0xDF, 0x80, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x02, 0x01, 0x80,
  0xC0, 0x10, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x04, 0x06, 0x01, 0x80,
  0x20, 0x60, 0x0C, 0x03, 0x02, 0x00, 0x60, 0x18, 0x30, 0x01, 0x80, 0xC3,
  0x00, 0x0C, 0x0C, 0x18, 0x00, 0x38, 0xC1, 0x80, 0x00, 0xFC, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x01, 0x83, 0x1C, 0x00, 0x18,
  0x30, 0x30, 0x00, 0x83, 0x01, 0x80, 0x0C, 0x18, 0x06, 0x00, 0x40, 0x80,
  0x30, 0x06, 0x04, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x03, 0x01, 0x00, 0x60,
  0x30, 0x08, 0x03, 0x01, 0x80, 0x40, 0x18, 0x18, 0x02, 0x00, 0xC0, 0xC0,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x30, 0x0C, 0x70,
  0x1C, 0x06, 0x30, 0x07, 0x03, 0x38, 0x01, 0x81, 0x98, 0x00, 0x60, 0xCC,
  0x00, 0x38, 0xC6, 0x00, 0x0E, 0x63, 0x00, 0x03, 0x71, 0x80, 0x00, 0xF0,
  0xC0, 0x00, 0x78, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1E, 0x06, 0x00, 0x19,
  0x83, 0xC0, 0x38, 0xE0, 0xFC, 0xF8, 0x30, 0x1F, 0xF0, 0x0C, 0x00, 0x80,
  0x00, 0x6D, 0xB6, 0xD6, 0xDB, 0x00, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x04, 0x07, 0xF8, 0x21, 0xF8,
  0xF9, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x6C,
  0x00, 0x06, 0x30, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x18, 0x03,
  0x00, 0x60, 0x38, 0x03, 0x80, 0x80, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x39, 0xCE, 0x73, 0x98, 0xC6, 0x67, 0x10, 0xFF, 0xFF, 0xF0, 0xFF,
  0xA0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xC0, 0x07, 0x9F, 0x00, 0xC0, 0x38, 0x18, 0x01, 0x83,
  0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C,
  0x38, 0x00, 0xC1, 0x80, 0x18, 0x0E, 0x03, 0x80, 0x79, 0xF0, 0x03, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0x3F, 0x07, 0x80, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xEF, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x18, 0x18, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x1C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0x9F, 0x01, 0xC0,
  0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x80, 0x0C, 0x1C, 0x01, 0x80,
  0xF9, 0xF0, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x31, 0xF8, 0x03, 0x7F,
  0xE0, 0x3C, 0x07, 0x03, 0x80, 0x38, 0x20, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x38, 0x01,
  0xC1, 0xC0, 0x38, 0x0F, 0x9F, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0F, 0xC0, 0x63, 0xFF,
  0x06, 0x70, 0x78, 0x6C, 0x01, 0xC5, 0x80, 0x0C, 0xF0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x06, 0x30, 0x00, 0x63, 0x80, 0x0E,
  0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0xCF, 0x00, 0x1F, 0xE0, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xE7,
  0xC0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x18, 0x00, 0x71, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x18,
  0x01, 0x80, 0x70, 0x38, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xE0, 0x78,
  0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x76, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00,
  0x18, 0x60, 0x01, 0xC1, 0xC0, 0x1C, 0x07, 0xCF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x0F, 0xBE, 0x01, 0xC0, 0x70,
  0x38, 0x01, 0x83, 0x00, 0x1C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0xF3, 0x00, 0x1B, 0x38, 0x03, 0x31,
  0xE0, 0xE3, 0x0F, 0xFC, 0x20, 0x3F, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x6F, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x00, 0x33, 0xDE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE,
  0x73, 0x18, 0xCE, 0x67, 0x10, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xCF, 0x03, 0x01, 0xC3,
  0x00, 0x73, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0xFC, 0x00, 0x41,
  0x80, 0x0F, 0xF0, 0x03, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0xC0, 0x0C, 0x03,
  0x00, 0xC6, 0x00, 0xC0, 0x18, 0x02, 0x60, 0x06, 0x00, 0xC0, 0x13, 0x00,
  0x60, 0x04, 0x00, 0xD8, 0x03, 0x00, 0x20, 0x06, 0xC0, 0x30, 0x01, 0x00,
  0x34, 0x01, 0x80, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xC0, 0x0F, 0x00, 0x40,
  0x06, 0x00, 0x78, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x1E,
  0x01, 0x80, 0x0C, 0x00, 0xF0, 0x0C, 0x00, 0x60, 0x05, 0x80, 0x60, 0x03,
  0x00, 0x2C, 0x03, 0x00, 0x18, 0x03, 0x60, 0x18, 0x01, 0xC0, 0x1B, 0x00,
  0xC0, 0x0E, 0x00, 0xC8, 0x06, 0x00, 0x70, 0x0C, 0x60, 0x18, 0x07, 0x80,
  0x63, 0x00, 0xC0, 0x6C, 0x06, 0x18, 0x07, 0x06, 0x30, 0x30, 0xC0, 0x1C,
  0xF1, 0xC7, 0x03, 0x00, 0x7E, 0x07, 0xF0, 0x18, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x40,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x01, 0xE1, 0x80, 0x03, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x07, 0x87, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80, 0x07, 0x8F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x9F,
  0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0C, 0x00, 0x78, 0x30, 0x00, 0x70, 0xC0, 0x00,
  0xE3, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x30,
  0x01, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xE7, 0xF0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x3C, 0x03, 0xF3, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0xCE, 0x00, 0x18, 0xE0, 0x06, 0x0E, 0x01, 0xC0, 0xFB, 0xF0, 0x0F, 0xF8,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x60,
  0x03, 0x80, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x01,
  0xC0, 0x0C, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x3E, 0x00, 0x06, 0xEE, 0x00,
  0x0F, 0x8E, 0x00, 0x1E, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x38, 0x06, 0x00, 0x38, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x70, 0x60, 0x00, 0x70, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0x7F, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x19, 0xEC, 0x00,
  0x00, 0x33, 0xCC, 0x00, 0x00, 0x67, 0x98, 0x00, 0x01, 0x8F, 0x30, 0x00,
  0x03, 0x1E, 0x30, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x18, 0x78, 0xC0, 0x00,
  0x30, 0xF0, 0xC0, 0x00, 0xE1, 0xE1, 0x80, 0x01, 0x83, 0xC3, 0x80, 0x03,
  0x07, 0x83, 0x00, 0x0C, 0x0F, 0x06, 0x00, 0x18, 0x1E, 0x06, 0x00, 0x30,
  0x3C, 0x0C, 0x00, 0xC0, 0x78, 0x18, 0x01, 0x80, 0xF0, 0x18, 0x03, 0x01,
  0xE0, 0x30, 0x0C, 0x03, 0xC0, 0x60, 0x18, 0x07, 0x80, 0x60, 0x30, 0x0F,
  0x00, 0xC0, 0xC0, 0x1E, 0x00, 0x81, 0x80, 0x3C, 0x01, 0x86, 0x00, 0x78,
  0x03, 0x0C, 0x00, 0xF0, 0x03, 0x18, 0x01, 0xE0, 0x06, 0x60, 0x03, 0xC0,
  0x0C, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xC6,
  0x00, 0x03, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1,
  0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0,
  0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x1C, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x06, 0x03, 0xC0,
  0x03, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xEF, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x30, 0x00,
  0xF1, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x39, 0x80, 0x07, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFE, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x03, 0x80, 0x70, 0x07, 0x80, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x10, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0x63, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00,
  0x0E, 0x30, 0x00, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0x3F, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x03, 0x06, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x71, 0xC0,
  0x01, 0xC1, 0xE0, 0x0F, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x30, 0xE0, 0x00, 0xE0, 0xF0, 0x07, 0x80, 0xFE, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0x80, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x07, 0x60, 0x00, 0x68,
  0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0xC3, 0x00, 0x08, 0x60, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x18,
  0x01, 0x82, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0E, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0E, 0x60, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x01,
  0x87, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xE0,
  0x30, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0xFF,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x6C, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30,
  0x0C, 0x30, 0x18, 0x60, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0x86, 0x03, 0x0C,
  0x03, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x0D, 0x80, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x00, 0x40, 0x00,
  0xFF, 0x80, 0x7C, 0xFC, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x98,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3C,
  0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x7B, 0x80,
  0x1B, 0x38, 0x07, 0x63, 0xEF, 0x8C, 0x3F, 0xE1, 0xC0, 0xC0, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x3F, 0xC1, 0x9F, 0x3E, 0x37, 0x00, 0xE6, 0x80,
  0x0C, 0xF0, 0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x70, 0x00,
  0x6E, 0x00, 0x1D, 0xE0, 0x03, 0x36, 0x00, 0xC6, 0x7C, 0xF8, 0xC3, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7E, 0x7C, 0x1C, 0x01,
  0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0xC0, 0xF9, 0xF0,
  0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x30, 0x7F, 0x86,
  0x1F, 0x7C, 0xC7, 0x00, 0xD9, 0xC0, 0x0F, 0x70, 0x00, 0xEC, 0x00, 0x1D,
  0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x03, 0xC7,
  0x00, 0xD8, 0x7D, 0xF3, 0x07, 0xFC, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xDF, 0x80, 0xE0, 0x1C, 0x18, 0x00, 0xC3, 0x80, 0x0E,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x60, 0xE0, 0x0E, 0x07, 0xCF, 0xC0, 0x3F, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3C, 0x81, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x03, 0xFF, 0xCF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x0C, 0x3E, 0xF9,
  0x8E, 0x01, 0xB3, 0x00, 0x1E, 0xE0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03,
  0x60, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x07, 0x8E, 0x01, 0xB0,
  0xFB, 0xE6, 0x0F, 0xF8, 0xC0, 0x30, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x63, 0x00, 0x0C, 0x70, 0x03, 0x07,
  0x81, 0xE0, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x80, 0xC3, 0xFC,
  0x31, 0xE7, 0xCC, 0xC0, 0x33, 0x60, 0x06, 0xD0, 0x01, 0xBC, 0x00, 0x6E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x03, 0x81, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x1C, 0xFC, 0x7C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0xB0, 0x00, 0xCC,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x0E, 0x0C, 0x07, 0x03, 0x03,
  0x80, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCE, 0x00,
  0x37, 0xC0, 0x0F, 0xB0, 0x03, 0xC6, 0x00, 0xE1, 0xC0, 0x30, 0x30, 0x0C,
  0x06, 0x03, 0x01, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x30, 0xFF, 0x00, 0xFF, 0x0C, 0x7B, 0xE0, 0xF9,
  0xE3, 0x30, 0x1C, 0x70, 0x1C, 0xD8, 0x03, 0x98, 0x03, 0xBC, 0x00, 0x6C,
  0x00, 0x6E, 0x00, 0x1E, 0x00, 0x1B, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x30, 0xFF,
  0x0C, 0x79, 0xF3, 0x30, 0x0C, 0xD8, 0x01, 0xB4, 0x00, 0x6F, 0x00, 0x1B,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x9F, 0x01,
  0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x0C, 0x38, 0x01, 0xC1,
  0xC0, 0x38, 0x0F, 0x9F, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x7F, 0x83, 0x3E, 0xFC, 0x6E, 0x01, 0xCF, 0x00, 0x19, 0xC0, 0x03,
  0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x3B,
  0xC0, 0x06, 0x6C, 0x01, 0x8C, 0xFB, 0xF1, 0x8F, 0xF8, 0x30, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x8C, 0x3E, 0xF9, 0x8E, 0x01, 0xB3, 0x80, 0x1E,
  0xE0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x66,
  0x00, 0x1C, 0xC0, 0x07, 0x8E, 0x01, 0xB0, 0xFB, 0xE6, 0x0F, 0xF8, 0xC0,
  0x30, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x58, 0x7F, 0x3F, 0xE6, 0x0D, 0x81, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x01, 0xF3, 0xE0, 0xE0, 0x1C, 0x60, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x1C, 0x3F,
  0x3E, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0xD0, 0x1F,
  0x00, 0x40, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00,
  0xF3, 0x80, 0x6C, 0x7D, 0xF3, 0x0F, 0xF8, 0xC0, 0x60, 0x00, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x0C,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xD8,
  0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x0D, 0x80, 0x0E, 0x00, 0x3B, 0x00,
  0x1C, 0x00, 0x66, 0x00, 0x2C, 0x00, 0xCE, 0x00, 0xD8, 0x01, 0x8C, 0x01,
  0xB0, 0x03, 0x18, 0x03, 0x20, 0x0C, 0x30, 0x0C, 0x60, 0x18, 0x60, 0x18,
  0xC0, 0x30, 0x60, 0x31, 0x80, 0x60, 0xC0, 0x61, 0x81, 0x81, 0x81, 0x83,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x03, 0x06, 0x0C, 0x0C, 0x06, 0x0C, 0x0C,
  0x30, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x30, 0xC0, 0x18, 0xC0, 0x21,
  0x80, 0x31, 0x00, 0x66, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xCC, 0x01, 0x98,
  0x00, 0xD8, 0x01, 0x30, 0x01, 0xA0, 0x03, 0x40, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x06, 0x18,
  0x00, 0xC1, 0x80, 0x30, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x70, 0x70, 0x06,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x00, 0x77, 0x00, 0x0C,
  0x60, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x0C, 0x07, 0x01, 0xC0, 0xC0,
  0x18, 0x38, 0x03, 0x86, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xE0, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xE0, 0x03, 0x83, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xE0, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x01,
  0xC0, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x08, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0x70, 0xE0, 0x03, 0x60, 0x30,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x0E, 0x06, 0xC0, 0x07, 0x0E, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 39, 11, 4, -38 },
  { 16, 8, 11, 15, 4, -41 },
  { 27, 25, 38, 27, 2, -38 },
  { 146, 20, 50, 26, 3, -44 },
  { 271, 29, 40, 35, 3, -39 },
  { 416, 25, 40, 29, 3, -39 },
  { 541, 3, 11, 9, 3, -41 },
  { 546, 10, 55, 15, 4, -43 },
  { 615, 10, 55, 15, 1, -43 },
  { 684, 21, 21, 23, 1, -38 },
  { 740, 22, 28, 27, 2, -32 },
  { 817, 5, 11, 10, 2, -4 },
  { 824, 10, 2, 14, 2, -18 },
  { 827, 3, 4, 12, 4, -3 },
  { 829, 16, 41, 19, 1, -38 },
  { 911, 20, 40, 26, 3, -39 },
  { 1011, 11, 38, 26, 5, -38 },
  { 1064, 21, 39, 26, 3, -39 },
  { 1167, 20, 40, 26, 3, -39 },
  { 1267, 23, 38, 26, 2, -38 },
  { 1377, 20, 39, 26, 4, -38 },
  { 1475, 20, 39, 26, 3, -38 },
  { 1573, 21, 38, 26, 2, -38 },
  { 1673, 21, 40, 26, 3, -39 },
  { 1778, 20, 39, 26, 3, -39 },
  { 1876, 4, 29, 10, 3, -28 },
  { 1891, 5, 35, 10, 2, -28 },
  { 1913, 19, 21, 24, 2, -28 },
  { 1963, 18, 13, 26, 4, -24 },
  { 1993, 19, 21, 25, 3, -28 },
  { 2043, 17, 40, 21, 2, -39 },
  { 2128, 37, 49, 43, 3, -37 },
  { 2355, 27, 38, 29, 1, -38 },
  { 2484, 21, 38, 29, 5, -38 },
  { 2584, 23, 40, 31, 4, -39 },
  { 2699, 22, 38, 31, 5, -38 },
  { 2804, 20, 38, 27, 5, -38 },
  { 2899, 20, 38, 27, 5, -38 },
  { 2994, 24, 40, 32, 4, -39 },
  { 3114, 23, 38, 33, 5, -38 },
  { 3224, 2, 38, 13, 6, -38 },
  { 3234, 19, 39, 26, 2, -38 },
  { 3327, 23, 38, 30, 5, -38 },
  { 3437, 18, 38, 25, 5, -38 },
  { 3523, 31, 38, 40, 5, -38 },
  { 3671, 24, 38, 33, 5, -38 },
  { 3785, 24, 40, 32, 4, -39 },
  { 3905, 21, 38, 29, 5, -38 },
  { 4005, 25, 46, 32, 3, -39 },
  { 4149, 22, 38, 30, 5, -38 },
  { 4254, 23, 40, 28, 3, -39 },
  { 4369, 25, 38, 28, 2, -38 },
  { 4488, 23, 39, 31, 4, -38 },
  { 4601, 27, 38, 29, 1, -38 },
  { 4730, 38, 38, 42, 2, -38 },
  { 4911, 25, 38, 29, 2, -38 },
  { 5030, 26, 38, 28, 1, -38 },
  { 5154, 23, 38, 28, 3, -38 },
  { 5264, 7, 52, 11, 4, -44 },
  { 5310, 15, 41, 19, 2, -38 },
  { 5387, 7, 52, 11, 0, -44 },
  { 5433, 15, 19, 20, 2, -38 },
  { 5469, 19, 2, 20, 1, 0 },
  { 5474, 8, 7, 15, 3, -40 },
  { 5481, 19, 31, 25, 3, -30 },
  { 5555, 19, 42, 26, 4, -41 },
  { 5655, 19, 31, 24, 3, -30 },
  { 5729, 19, 42, 26, 3, -41 },
  { 5829, 20, 31, 25, 2, -30 },
  { 5907, 14, 42, 16, 2, -42 },
  { 5981, 19, 41, 26, 3, -30 },
  { 6079, 18, 41, 26, 4, -41 },
  { 6172, 3, 39, 11, 4, -39 },
  { 6187, 9, 50, 11, -2, -39 },
  { 6244, 18, 41, 23, 4, -41 },
  { 6337, 2, 41, 11, 4, -41 },
  { 6348, 34, 30, 42, 4, -30 },
  { 6476, 18, 30, 26, 4, -30 },
  { 6544, 20, 31, 26, 3, -30 },
  { 6622, 19, 41, 26, 4, -30 },
  { 6720, 19, 41, 26, 3, -30 },
  { 6818, 11, 30, 16, 4, -30 },
  { 6860, 18, 31, 24, 3, -30 },
  { 6930, 12, 37, 16, 1, -36 },
  { 6986, 18, 30, 26, 4, -29 },
  { 7054, 20, 29, 23, 1, -29 },
  { 7127, 31, 29, 36, 2, -29 },
  { 7240, 19, 29, 23, 2, -29 },
  { 7309, 21, 40, 23, 1, -29 },
  { 7414, 19, 29, 23, 2, -29 },
  { 7483, 13, 53, 16, 2, -42 },
  { 7570, 2, 45, 11, 5, -38 },
  { 7582, 13, 53, 16, 1, -42 },
  { 7669, 24, 9, 32, 4, -20 },
};

const GFXfont RobotoCondensed_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT54PT7B_H_
