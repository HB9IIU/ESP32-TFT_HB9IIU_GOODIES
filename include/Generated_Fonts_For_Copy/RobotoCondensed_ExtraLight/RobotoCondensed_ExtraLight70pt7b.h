#ifndef _ROBOTOCONDENSED_EXTRALIGHT70PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x60, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x1C, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x03, 0xC3,
  0xC0, 0xE0, 0x00, 0x0F, 0xFC, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xC0, 0x00, 0x07, 0x01,
  0xFF, 0x00, 0x00, 0x30, 0x1C, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x00,
  0x18, 0x0C, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x0E, 0x00, 0x1C, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x1C, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x07, 0x00, 0x18,
  0x03, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0x80, 0xE0, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x70,
  0x01, 0xC0, 0x1C, 0x70, 0x00, 0xE0, 0x1C, 0xE0, 0x00, 0x70, 0x18, 0xE0,
  0x00, 0x70, 0x18, 0xE0, 0x00, 0x38, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0xC0,
  0x00, 0x1E, 0x30, 0xC0, 0x00, 0x0E, 0x70, 0xE0, 0x00, 0x07, 0x70, 0xE0,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x0F, 0x70, 0x1E,
  0x00, 0x1E, 0x38, 0x0F, 0x00, 0x78, 0x1C, 0x07, 0xFF, 0xF0, 0x0E, 0x03,
  0xFF, 0xC0, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xFF,
  0xF8, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x27, 0x00, 0x60, 0x0E, 0xFC, 0x06, 0x07, 0xF3, 0xF8, 0x61,
  0xFC, 0x07, 0xF6, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x06, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x9C, 0xE3, 0x84, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x67, 0xBF, 0xE6, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x04, 0x00,
  0xF0, 0x0F, 0xC0, 0xFB, 0x1F, 0x8D, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xC0, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x03, 0x80,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x07,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x0E, 0x7F, 0xF8, 0x07,
  0x7F, 0xFE, 0x03, 0xF0, 0x07, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0xE0,
  0x1E, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x01, 0xFC, 0x01, 0x83, 0xFF, 0xC0, 0x61, 0xFF, 0xF8, 0x18, 0xE0, 0x0F,
  0x06, 0x70, 0x01, 0xE1, 0xB0, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0x3E, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x0F, 0x01,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x03, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x78,
  0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3E,
  0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x60, 0x00, 0x03, 0xDC, 0x00,
  0x01, 0xF7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x36, 0x3C, 0x00, 0x1D, 0x87,
  0x80, 0x0E, 0x60, 0xF0, 0x0F, 0x18, 0x1F, 0xFF, 0x86, 0x03, 0xFF, 0xC1,
  0x80, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x33,
  0xFE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xFE, 0xF3, 0x00, 0x18,
  0xF7, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18,
  0x61, 0x86, 0x18, 0xE3, 0x8E, 0x71, 0xCE, 0x38, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1E,
  0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0xFE,
  0x00, 0x0C, 0x18, 0x00, 0x0F, 0x1F, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x38, 0x00, 0x38, 0x01, 0x80, 0x06, 0x30, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x60, 0x01, 0x80, 0x03,
  0x80, 0x06, 0x60, 0x01, 0x80, 0x03, 0x80, 0x06, 0x60, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x60, 0x03, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x00, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x03,
  0x00, 0x07, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x06, 0xE0, 0x07, 0x00, 0x03,
  0x00, 0x06, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x06, 0xE0, 0x06, 0x00, 0x03,
  0x00, 0x06, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x06, 0xE0, 0x06, 0x00, 0x03,
  0x00, 0x06, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x0E, 0xE0, 0x06, 0x00, 0x07,
  0x00, 0x0C, 0x60, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x60, 0x07, 0x00, 0x0F,
  0x00, 0x1C, 0x60, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x60, 0x03, 0x00, 0x1B,
  0x00, 0x18, 0x70, 0x03, 0x80, 0x3B, 0x00, 0x30, 0x70, 0x03, 0x80, 0x33,
  0x80, 0x70, 0x30, 0x01, 0xC0, 0xE1, 0xC0, 0xE0, 0x30, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x38, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x18, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x70, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x1F, 0xE0, 0x70, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x38, 0x03,
  0xFE, 0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0xE0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x70,
  0xF8, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x01, 0xCE, 0x70, 0x00, 0x03, 0xB8,
  0x70, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1B, 0xFC, 0x00, 0x00, 0x00,
  0x3B, 0xEC, 0x00, 0x00, 0x00, 0x33, 0xEE, 0x00, 0x00, 0x00, 0x73, 0xEE,
  0x00, 0x00, 0x00, 0x73, 0xE6, 0x00, 0x00, 0x00, 0x63, 0xE7, 0x00, 0x00,
  0x00, 0xE3, 0xE3, 0x00, 0x00, 0x00, 0xE3, 0xE3, 0x80, 0x00, 0x00, 0xC3,
  0xE3, 0x80, 0x00, 0x01, 0xC3, 0xE1, 0x80, 0x00, 0x01, 0xC3, 0xE1, 0xC0,
  0x00, 0x01, 0x83, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0xC0, 0x00, 0x03,
  0x03, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0xE0,
  0x60, 0x00, 0x06, 0x07, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0xE0, 0x30, 0x00, 0x0C, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0xE0, 0x18, 0x00, 0x1C, 0x07, 0xE0, 0x1C, 0x00, 0x18, 0x07, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0xE0, 0x0C, 0x00, 0x38, 0x07, 0xE0, 0x0E, 0x00, 0x30,
  0x07, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x07, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x00,
  0xC0, 0x07, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0xE0, 0x01, 0x81, 0xC0, 0x07,
  0xE0, 0x01, 0xC1, 0x80, 0x07, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0xE0, 0x00,
  0xC3, 0x80, 0x07, 0xE0, 0x00, 0xE3, 0x00, 0x07, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0xE0, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFB,
  0x80, 0x00, 0x03, 0xF7, 0x00, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x0F, 0xCE,
  0x00, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x3F, 0x0C, 0x00, 0x00, 0x7E, 0x1C,
  0x00, 0x00, 0xFC, 0x1C, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x03, 0xF0, 0x38,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x1F, 0x80, 0x60,
  0x00, 0x3F, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xC0,
  0x01, 0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x1C, 0x03,
  0xF0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x38, 0x1F,
  0x80, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x70, 0xFC,
  0x00, 0x00, 0xE1, 0xF8, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x01, 0xC7, 0xE0,
  0x00, 0x01, 0xCF, 0xC0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x03, 0xBF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xFE, 0x0E, 0x00,
  0x01, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xFF, 0x01, 0xC0,
  0x00, 0x3E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x7F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x78, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x31, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x18, 0x07,
  0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x30,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x18, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x3F, 0xFF, 0xF0, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1B, 0x00, 0x03, 0x70, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03,
  0x1C, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x07, 0x00, 0xE0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0xC0, 0xE0, 0x18, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0,
  0x06, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x01, 0x9C, 0x00, 0x3B, 0x00,
  0x07, 0xE0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x80,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFE,
  0x00, 0x60, 0xF0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C,
  0xC0, 0x00, 0x1E, 0x70, 0x00, 0x1F, 0x38, 0x00, 0x1D, 0x8E, 0x00, 0x1C,
  0xC3, 0xC0, 0x3C, 0x71, 0xFF, 0xFC, 0x38, 0x3F, 0xF8, 0x1C, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x3E, 0x00, 0xE0, 0xFF, 0xE0, 0x71, 0xFF, 0xF8, 0x39, 0xE0, 0x1E,
  0x1D, 0xC0, 0x07, 0x8F, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0x73, 0xC0, 0x00,
  0x19, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x19, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0x77, 0x00,
  0x1E, 0x39, 0xE0, 0x1E, 0x1C, 0x7F, 0xFE, 0x0E, 0x1F, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x60, 0x00, 0x1C,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x03, 0x80, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0x03, 0xFF, 0x83, 0x83, 0xFF, 0xF1,
  0xC3, 0xC0, 0x3C, 0xE3, 0xC0, 0x07, 0x73, 0xC0, 0x01, 0xB9, 0xC0, 0x00,
  0x7D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x1F, 0x1C, 0x00,
  0x0F, 0x8F, 0x00, 0x1D, 0xC3, 0xC0, 0x3C, 0xE0, 0xFF, 0xFC, 0x70, 0x1F,
  0xF8, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xF0, 0x00, 0x70, 0x1F,
  0x00, 0x78, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xC1, 0xC1, 0xFF, 0xF8, 0xE1, 0xE0, 0x1E, 0x71, 0xE0, 0x03, 0xB9, 0xE0,
  0x00, 0xDC, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xC7, 0x80, 0x0E, 0xE1, 0xE0, 0x1E, 0x70,
  0x7F, 0xFE, 0x38, 0x1F, 0xFC, 0x1C, 0x01, 0xF8, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x0F, 0x00, 0x3C, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x1F, 0x00, 0xE0, 0x7F, 0xE0, 0xE1, 0xFF, 0xF0, 0xE3, 0xC0, 0x78, 0xE7,
  0x00, 0x3C, 0xEE, 0x00, 0x1C, 0xEC, 0x00, 0x0C, 0xF8, 0x00, 0x0E, 0xF8,
  0x00, 0x0E, 0xF0, 0x00, 0x06, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0xCF, 0xF8, 0xFF, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00,
  0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0xC0, 0x00, 0xEF, 0xC0, 0x00,
  0xFC, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x0E, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xE1, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0E, 0x38, 0x07, 0x83, 0xC0, 0x78, 0xE7, 0x00, 0x38,
  0x70, 0x01, 0xCE, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xFC, 0x00, 0x0C, 0xC0,
  0x00, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x06, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x1F, 0x00, 0xE0, 0x7F, 0xE0, 0xE1, 0xFF,
  0xF0, 0xE3, 0xC0, 0x78, 0xE7, 0x00, 0x3C, 0xEE, 0x00, 0x1C, 0xEC, 0x00,
  0x0C, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xF0, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x7F, 0xF0, 0x38,
  0xFF, 0xFC, 0x1C, 0xF0, 0x0F, 0x0E, 0xE0, 0x03, 0xC7, 0xE0, 0x00, 0xF3,
  0xE0, 0x00, 0x39, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0E,
  0x7C, 0x00, 0x0E, 0x3B, 0x80, 0x0F, 0x1C, 0xE0, 0x0F, 0x0E, 0x3F, 0xFF,
  0x07, 0x0F, 0xFE, 0x03, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC1, 0xC1, 0xFF, 0xF8, 0xE1, 0xE0, 0x1E,
  0x71, 0xE0, 0x03, 0xB9, 0xE0, 0x00, 0xFC, 0xE0, 0x00, 0x3E, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0x60, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xC7, 0x80,
  0x0E, 0xE1, 0xE0, 0x0E, 0x70, 0x7F, 0xFE, 0x38, 0x1F, 0xFE, 0x1C, 0x01,
  0xF8, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x3D, 0xC1, 0xFF, 0x8F,
  0xFF, 0x3C, 0x0E, 0x60, 0x1D, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0x80, 0x07, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xE1,
  0xF0, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1E, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8,
  0x00, 0x0F, 0x38, 0x00, 0x36, 0x78, 0x00, 0xEC, 0x78, 0x07, 0x98, 0x7F,
  0xFE, 0x30, 0x7F, 0xF0, 0x60, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x7C, 0x00, 0x0E, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x70, 0x00, 0x6E, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00,
  0x1C, 0x38, 0x00, 0xE6, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x38,
  0x00, 0xC7, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x18, 0x01, 0xC3,
  0x00, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0x83, 0x80, 0x30,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x81, 0x80, 0x70, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x06, 0x07, 0x00, 0xC0,
  0x60, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0xE0, 0xE0, 0x07,
  0x06, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00,
  0x71, 0xC0, 0x03, 0x8C, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x31, 0xC0,
  0x01, 0x9C, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x39, 0x80, 0x01, 0x98,
  0x00, 0x1B, 0x80, 0x01, 0xD8, 0x00, 0x1B, 0x80, 0x01, 0xF8, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x0C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x6F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0x1F, 0xFC, 0x00, 0x07, 0x38, 0x1E, 0x00, 0x07, 0x70, 0x07,
  0x00, 0x06, 0x70, 0x03, 0x80, 0x06, 0x60, 0x01, 0xC0, 0x0E, 0xE0, 0x00,
  0xE0, 0x0C, 0xE0, 0x00, 0x70, 0x1C, 0xE0, 0x00, 0x3F, 0xF8, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 51, 14, 5, -50 },
  { 27, 10, 15, 19, 5, -53 },
  { 46, 32, 50, 35, 3, -50 },
  { 246, 26, 65, 34, 4, -58 },
  { 458, 37, 52, 45, 4, -51 },
  { 699, 32, 52, 38, 4, -51 },
  { 907, 3, 15, 12, 4, -53 },
  { 913, 13, 72, 20, 5, -56 },
  { 1030, 13, 72, 20, 2, -56 },
  { 1147, 28, 27, 29, 1, -50 },
  { 1242, 29, 37, 35, 3, -42 },
  { 1377, 6, 15, 13, 3, -6 },
  { 1389, 14, 2, 19, 2, -23 },
  { 1393, 5, 5, 16, 5, -4 },
  { 1397, 20, 54, 24, 2, -50 },
  { 1532, 26, 52, 34, 4, -51 },
  { 1701, 14, 50, 34, 6, -50 },
  { 1789, 27, 51, 34, 4, -51 },
  { 1962, 26, 52, 34, 4, -51 },
  { 2131, 29, 50, 34, 3, -50 },
  { 2313, 25, 51, 34, 6, -50 },
  { 2473, 26, 51, 34, 4, -50 },
  { 2639, 27, 50, 34, 3, -50 },
  { 2808, 26, 52, 34, 4, -51 },
  { 2977, 26, 51, 34, 4, -51 },
  { 3143, 5, 37, 13, 4, -36 },
  { 3167, 6, 45, 12, 3, -36 },
  { 3201, 24, 28, 32, 3, -37 },
  { 3285, 24, 18, 34, 5, -32 },
  { 3339, 24, 28, 32, 4, -37 },
  { 3423, 21, 52, 28, 3, -51 },
  { 3560, 48, 63, 56, 4, -48 },
  { 3938, 34, 50, 38, 2, -50 },
  { 4151, 27, 50, 37, 6, -50 },
  { 4320, 30, 52, 40, 5, -51 },
  { 4515, 29, 50, 40, 6, -50 },
  { 4697, 26, 50, 35, 6, -50 },
  { 4860, 26, 50, 35, 6, -50 },
  { 5023, 31, 52, 42, 5, -51 },
  { 5225, 31, 50, 43, 6, -50 },
  { 5419, 3, 50, 17, 7, -50 },
  { 5438, 25, 51, 34, 3, -50 },
  { 5598, 31, 50, 39, 6, -50 },
  { 5792, 24, 50, 32, 6, -50 },
  { 5942, 40, 50, 52, 6, -50 },
  { 6192, 31, 50, 43, 6, -50 },
  { 6386, 31, 52, 41, 5, -51 },
  { 6588, 28, 50, 37, 6, -50 },
  { 6763, 31, 60, 41, 5, -51 },
  { 6996, 29, 50, 39, 6, -50 },
  { 7178, 30, 52, 36, 3, -51 },
  { 7373, 32, 50, 37, 2, -50 },
  { 7573, 29, 51, 40, 6, -50 },
  { 7758, 34, 50, 37, 2, -50 },
  { 7971, 50, 50, 55, 2, -50 },
  { 8284, 33, 50, 37, 2, -50 },
  { 8491, 34, 50, 37, 1, -50 },
  { 8704, 30, 50, 37, 3, -50 },
  { 8892, 9, 68, 15, 6, -57 },
  { 8969, 20, 54, 24, 2, -50 },
  { 9104, 8, 68, 15, 1, -57 },
  { 9172, 19, 25, 26, 3, -50 },
  { 9232, 25, 2, 26, 1, 0 },
  { 9239, 10, 9, 19, 4, -52 },
  { 9251, 25, 39, 33, 3, -38 },
  { 9373, 25, 54, 34, 5, -53 },
  { 9542, 25, 39, 32, 3, -38 },
  { 9664, 25, 54, 34, 4, -53 },
  { 9833, 26, 39, 32, 3, -38 },
  { 9960, 17, 54, 20, 3, -54 },
  { 10075, 25, 52, 34, 4, -38 },
  { 10238, 24, 53, 34, 5, -53 },
  { 10397, 4, 50, 14, 5, -50 },
  { 10422, 12, 64, 15, -3, -50 },
  { 10518, 24, 53, 30, 5, -53 },
  { 10677, 2, 53, 14, 6, -53 },
  { 10691, 44, 38, 54, 5, -38 },
  { 10900, 24, 38, 34, 5, -38 },
  { 11014, 26, 39, 34, 4, -38 },
  { 11141, 25, 52, 34, 5, -38 },
  { 11304, 25, 52, 34, 4, -38 },
  { 11467, 15, 38, 21, 5, -38 },
  { 11539, 23, 39, 31, 4, -38 },
  { 11652, 15, 48, 20, 2, -47 },
  { 11742, 23, 38, 34, 5, -37 },
  { 11852, 26, 37, 30, 2, -37 },
  { 11973, 40, 37, 46, 3, -37 },
  { 12158, 26, 37, 30, 2, -37 },
  { 12279, 26, 51, 29, 2, -37 },
  { 12445, 25, 37, 30, 3, -37 },
  { 12561, 17, 70, 21, 3, -55 },
  { 12710, 3, 59, 15, 6, -50 },
  { 12733, 17, 70, 21, 1, -55 },
  { 12882, 32, 12, 42, 5, -27 },
};

const GFXfont RobotoCondensed_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT70PT7B_H_
