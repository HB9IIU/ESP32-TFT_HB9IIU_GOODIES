#ifndef _ROBOTOCONDENSED_EXTRALIGHT22PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xB6, 0xDA, 0x08, 0x82, 0x41, 0x10, 0x44, 0x7F, 0xC4,
  0x41, 0x10, 0x48, 0x12, 0x08, 0x82, 0x23, 0xFE, 0x22, 0x08, 0x82, 0x41,
  0x10, 0x08, 0x08, 0x3C, 0x42, 0x41, 0x41, 0x41, 0x40, 0x60, 0x18, 0x06,
  0x03, 0x01, 0x81, 0x81, 0x41, 0x41, 0x3E, 0x08, 0x08, 0x70, 0x08, 0x80,
  0x88, 0x48, 0x88, 0x89, 0x08, 0x90, 0x72, 0x00, 0x20, 0x04, 0x00, 0x4E,
  0x09, 0x10, 0x91, 0x11, 0x11, 0x11, 0x01, 0x10, 0x0E, 0x1C, 0x08, 0x84,
  0x21, 0x08, 0x42, 0x09, 0x02, 0x80, 0x40, 0x28, 0x11, 0x18, 0x46, 0x0A,
  0x81, 0xA0, 0x44, 0x38, 0xF1, 0xF8, 0x08, 0x88, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x21, 0x08, 0x42, 0x08, 0x41, 0x04, 0x82, 0x08, 0x41, 0x08,
  0x42, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x44, 0x40, 0x08, 0x04,
  0x02, 0x19, 0x33, 0xE0, 0x60, 0x50, 0x44, 0x21, 0x00, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x56, 0x80,
  0xF0, 0x80, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x20, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x41, 0x22, 0x1C, 0x17, 0x91, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x10, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0xFF, 0x3C, 0x42, 0x41,
  0x81, 0x01, 0x01, 0x02, 0x1C, 0x02, 0x01, 0x01, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0x02, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x21,
  0x20, 0x9F, 0xF0, 0x20, 0x10, 0x08, 0x04, 0x7E, 0x40, 0x40, 0x80, 0x80,
  0x80, 0xBC, 0xC2, 0x02, 0x01, 0x01, 0x01, 0x81, 0x82, 0x42, 0x3C, 0x0E,
  0x08, 0x08, 0x08, 0x04, 0x02, 0x02, 0x79, 0x46, 0xC1, 0x40, 0xA0, 0x30,
  0x14, 0x12, 0x08, 0x88, 0x38, 0xFF, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x3C, 0x21, 0x10,
  0x50, 0x28, 0x12, 0x09, 0x08, 0x78, 0x62, 0x20, 0xA0, 0x30, 0x18, 0x0C,
  0x09, 0x04, 0x7C, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x43, 0x3D, 0x01, 0x01, 0x02, 0x04, 0x38, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x15, 0xA0, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x18, 0x04, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x18,
  0x60, 0x80, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x40,
  0x80, 0x00, 0x00, 0x08, 0x07, 0xE0, 0x10, 0x30, 0x40, 0x11, 0x00, 0x24,
  0x00, 0x28, 0x38, 0x50, 0x88, 0xC2, 0x11, 0x84, 0x23, 0x10, 0x46, 0x21,
  0x0C, 0x42, 0x18, 0x84, 0x30, 0x94, 0x91, 0xCE, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x04, 0x00, 0xC0, 0x18, 0x04, 0x80,
  0x90, 0x12, 0x04, 0x40, 0x84, 0x10, 0x84, 0x10, 0xFF, 0x10, 0x22, 0x04,
  0x80, 0x50, 0x0A, 0x01, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x09,
  0xF8, 0x82, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x0A, 0x05, 0xFC, 0x3E, 0x20,
  0xA0, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x05, 0x04, 0x7C, 0xFC, 0x41, 0x20, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0A, 0x09, 0xF8, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C,
  0x02, 0x01, 0x00, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x06, 0x7C,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xFF, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x82,
  0x42, 0x3C, 0x80, 0xA0, 0x48, 0x22, 0x10, 0x88, 0x22, 0x09, 0x02, 0xC0,
  0xD0, 0x22, 0x08, 0x42, 0x10, 0x82, 0x20, 0x48, 0x12, 0x02, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F,
  0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xA0, 0x3A, 0x05, 0xA0, 0x59, 0x05,
  0x90, 0x99, 0x09, 0x88, 0x98, 0x91, 0x85, 0x18, 0x51, 0x86, 0x18, 0x21,
  0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x19, 0x06, 0x21, 0x84, 0x61,
  0x18, 0x26, 0x09, 0x81, 0x60, 0x58, 0x0E, 0x01, 0x1F, 0x08, 0x24, 0x05,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40,
  0x50, 0x12, 0x08, 0x7C, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x05,
  0x02, 0xFE, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x1F, 0x08,
  0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x40, 0x50, 0x12, 0x08, 0x7C, 0x00, 0x80, 0x30, 0x04, 0xFC, 0x41,
  0xA0, 0x50, 0x18, 0x0C, 0x06, 0x05, 0x02, 0xFE, 0x42, 0x20, 0x90, 0x48,
  0x14, 0x0A, 0x03, 0x01, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x02, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x0A, 0x05, 0x86, 0x3C, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C,
  0x40, 0x28, 0x05, 0x01, 0x10, 0x22, 0x04, 0x40, 0x88, 0x20, 0x84, 0x10,
  0x82, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0x80, 0x20, 0x81, 0x03,
  0x02, 0x06, 0x0A, 0x0C, 0x14, 0x14, 0x28, 0x28, 0x50, 0x91, 0x11, 0x22,
  0x22, 0x24, 0x44, 0x48, 0x90, 0x90, 0xA1, 0x41, 0x42, 0x82, 0x83, 0x05,
  0x04, 0x04, 0x08, 0x08, 0x80, 0x50, 0x24, 0x10, 0x84, 0x22, 0x04, 0x80,
  0xC0, 0x30, 0x0C, 0x05, 0x01, 0x20, 0x88, 0x21, 0x10, 0x24, 0x0A, 0x01,
  0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x02, 0x40, 0x50, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x03, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x4E, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08,
  0x20, 0x81, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9E, 0x10,
  0xC3, 0x12, 0x49, 0x28, 0x61, 0xFF, 0x44, 0x20, 0x3C, 0x42, 0x81, 0x01,
  0x01, 0x3F, 0x41, 0x81, 0x81, 0x83, 0x85, 0x79, 0x81, 0x02, 0x04, 0x08,
  0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xBC, 0x3C,
  0x42, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x42, 0x3C, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x43, 0x3D, 0x3C, 0x42, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x41, 0x3E, 0x19, 0x10, 0x84, 0x7D, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x40, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x43, 0x3D, 0x01, 0x01, 0x42, 0x3C, 0x81, 0x02, 0x04, 0x08, 0x17,
  0xB1, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x8F, 0xFF,
  0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x81, 0x02,
  0x04, 0x08, 0x10, 0xA2, 0x44, 0x91, 0x43, 0x85, 0x09, 0x11, 0x22, 0x42,
  0x82, 0xFF, 0xFF, 0x80, 0xBC, 0xF6, 0x28, 0x60, 0x83, 0x04, 0x18, 0x20,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10,
  0xBD, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x3C,
  0x21, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x20, 0x90, 0x87,
  0x80, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0D, 0xE8,
  0x10, 0x20, 0x40, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xBC, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x3C, 0x86, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x03, 0x05, 0x09, 0xE0,
  0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x60, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1B, 0xD0, 0x81, 0x82, 0x82,
  0x42, 0x44, 0x44, 0x44, 0x24, 0x28, 0x28, 0x10, 0x10, 0x82, 0x14, 0x30,
  0xA1, 0x84, 0x8A, 0x24, 0x51, 0x24, 0x91, 0x24, 0x85, 0x14, 0x30, 0xA1,
  0x86, 0x0C, 0x10, 0x20, 0x80, 0x82, 0x42, 0x44, 0x24, 0x28, 0x10, 0x18,
  0x28, 0x24, 0x44, 0x82, 0x82, 0x81, 0x82, 0x82, 0x42, 0x44, 0x44, 0x24,
  0x28, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFE, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0x08, 0x88, 0x42,
  0x10, 0x84, 0x22, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x41, 0x04, 0xFF,
  0xFF, 0xE0, 0xC0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0xC4, 0x10,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x23, 0x00, 0x70, 0x62, 0x18, 0x4A, 0x0C,
};

const GFXglyph RobotoCondensed_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 4, 2, -16 },
  { 3, 3, 5, 6, 2, -17 },
  { 5, 10, 16, 11, 1, -16 },
  { 25, 8, 20, 11, 1, -18 },
  { 45, 12, 16, 14, 1, -16 },
  { 69, 10, 16, 12, 1, -16 },
  { 89, 1, 5, 4, 1, -17 },
  { 90, 5, 22, 6, 1, -17 },
  { 104, 5, 22, 6, 0, -17 },
  { 118, 9, 9, 9, 0, -16 },
  { 129, 9, 11, 11, 1, -13 },
  { 142, 2, 5, 4, 1, -2 },
  { 144, 4, 1, 6, 1, -8 },
  { 145, 1, 1, 5, 2, -1 },
  { 146, 6, 17, 8, 1, -16 },
  { 159, 8, 16, 11, 1, -16 },
  { 175, 4, 16, 11, 2, -16 },
  { 183, 9, 16, 11, 1, -16 },
  { 201, 8, 16, 11, 1, -16 },
  { 217, 9, 16, 11, 1, -16 },
  { 235, 8, 16, 11, 2, -16 },
  { 251, 9, 16, 11, 1, -16 },
  { 269, 8, 16, 11, 1, -16 },
  { 285, 9, 16, 11, 1, -16 },
  { 303, 8, 16, 11, 1, -16 },
  { 319, 2, 11, 4, 1, -11 },
  { 322, 2, 14, 4, 1, -11 },
  { 326, 8, 9, 10, 1, -12 },
  { 335, 7, 6, 11, 2, -10 },
  { 341, 8, 9, 10, 1, -12 },
  { 350, 7, 16, 9, 1, -16 },
  { 364, 15, 20, 18, 1, -15 },
  { 402, 11, 16, 12, 0, -16 },
  { 424, 9, 16, 12, 2, -16 },
  { 442, 9, 16, 12, 2, -16 },
  { 460, 9, 16, 13, 2, -16 },
  { 478, 8, 16, 11, 2, -16 },
  { 494, 8, 16, 11, 2, -16 },
  { 510, 9, 16, 13, 2, -16 },
  { 528, 10, 16, 14, 2, -16 },
  { 548, 1, 16, 5, 2, -16 },
  { 550, 8, 16, 11, 1, -16 },
  { 566, 10, 16, 12, 2, -16 },
  { 586, 7, 16, 10, 2, -16 },
  { 600, 12, 16, 16, 2, -16 },
  { 624, 10, 16, 14, 2, -16 },
  { 644, 10, 16, 13, 1, -16 },
  { 664, 9, 16, 12, 2, -16 },
  { 682, 10, 19, 13, 1, -16 },
  { 706, 9, 16, 12, 2, -16 },
  { 724, 9, 16, 11, 1, -16 },
  { 742, 10, 16, 12, 1, -16 },
  { 762, 9, 16, 13, 2, -16 },
  { 780, 11, 16, 12, 0, -16 },
  { 802, 15, 16, 17, 1, -16 },
  { 832, 10, 16, 12, 1, -16 },
  { 852, 11, 16, 12, 0, -16 },
  { 874, 10, 16, 12, 1, -16 },
  { 894, 3, 21, 5, 2, -18 },
  { 902, 6, 17, 8, 1, -16 },
  { 915, 3, 21, 5, 0, -18 },
  { 923, 6, 8, 8, 1, -16 },
  { 929, 8, 1, 8, 0, 0 },
  { 930, 4, 3, 6, 1, -17 },
  { 932, 8, 12, 10, 1, -12 },
  { 944, 7, 17, 11, 2, -17 },
  { 959, 8, 12, 10, 1, -12 },
  { 971, 8, 17, 11, 1, -17 },
  { 988, 8, 12, 10, 1, -12 },
  { 1000, 5, 17, 6, 1, -17 },
  { 1011, 8, 16, 11, 1, -12 },
  { 1027, 7, 17, 11, 2, -17 },
  { 1042, 1, 16, 4, 2, -16 },
  { 1044, 4, 20, 5, -1, -16 },
  { 1054, 7, 17, 9, 2, -17 },
  { 1069, 1, 17, 4, 2, -17 },
  { 1072, 13, 12, 17, 2, -12 },
  { 1092, 7, 12, 11, 2, -12 },
  { 1103, 9, 12, 11, 1, -12 },
  { 1117, 7, 16, 11, 2, -12 },
  { 1131, 8, 16, 11, 1, -12 },
  { 1147, 4, 12, 7, 2, -12 },
  { 1153, 7, 12, 10, 1, -12 },
  { 1164, 5, 15, 6, 0, -15 },
  { 1174, 7, 12, 11, 2, -12 },
  { 1185, 8, 12, 9, 1, -12 },
  { 1197, 13, 12, 14, 1, -12 },
  { 1217, 8, 12, 9, 1, -12 },
  { 1229, 8, 16, 9, 1, -12 },
  { 1245, 8, 12, 9, 1, -12 },
  { 1257, 5, 22, 6, 1, -17 },
  { 1271, 1, 19, 5, 2, -16 },
  { 1274, 6, 22, 6, 0, -17 },
  { 1291, 10, 4, 13, 2, -9 },
};

const GFXfont RobotoCondensed_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT22PT7B_H_
