#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x04, 0xEF, 0x60, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x04,
  0x00, 0xC0, 0x80, 0x18, 0x10, 0x03, 0x02, 0x00, 0x40, 0xC1, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x20,
  0x06, 0x04, 0x00, 0x80, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40, 0xC0,
  0x18, 0x18, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x0C, 0x08, 0x01, 0x81, 0x00,
  0x20, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x10, 0x03, 0x02, 0x00, 0x60, 0x40, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x0F, 0xF8, 0x3D, 0x7E, 0x71, 0x04, 0x61, 0x00,
  0xC1, 0x00, 0xC1, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0xC1, 0x00,
  0xC1, 0x00, 0xC1, 0x00, 0x61, 0x00, 0x31, 0x00, 0x1D, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0x38, 0x01, 0x0C, 0x01, 0x06, 0x01, 0x03,
  0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03,
  0x01, 0x06, 0x81, 0x0C, 0xE1, 0x38, 0x7F, 0xF0, 0x07, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x60, 0x19, 0x80, 0x30,
  0x18, 0x60, 0x10, 0x0C, 0x10, 0x18, 0x04, 0x0C, 0x0C, 0x02, 0x06, 0x04,
  0x03, 0x03, 0x06, 0x01, 0x81, 0x83, 0x00, 0xC0, 0xC1, 0x00, 0x60, 0x61,
  0x80, 0x30, 0x30, 0xC0, 0x18, 0x18, 0x40, 0x0C, 0x0C, 0x60, 0x06, 0x06,
  0x30, 0x83, 0x03, 0x11, 0xF0, 0x81, 0x98, 0x8C, 0x40, 0x8C, 0xC3, 0x30,
  0x44, 0x41, 0x98, 0x66, 0x60, 0x46, 0x63, 0x30, 0x21, 0xE1, 0x18, 0x18,
  0x01, 0x8C, 0x0C, 0x00, 0xC6, 0x06, 0x00, 0x43, 0x03, 0x00, 0x61, 0x81,
  0x80, 0x30, 0xC0, 0xC0, 0x10, 0x60, 0x60, 0x18, 0x30, 0x30, 0x0C, 0x18,
  0x18, 0x04, 0x0C, 0x08, 0x06, 0x06, 0x04, 0x03, 0x01, 0x06, 0x01, 0x00,
  0xC3, 0x01, 0x80, 0x33, 0x00, 0xC0, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0x38,
  0x01, 0x86, 0x00, 0x40, 0x80, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x04, 0x08, 0x01, 0x06, 0x00, 0x61, 0x80, 0x18,
  0x40, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x03, 0xB0, 0x00, 0xC6, 0x00, 0x60, 0xC1, 0xB0, 0x30, 0x6C, 0x06, 0x1B,
  0x01, 0x84, 0x80, 0x33, 0x20, 0x0C, 0xC8, 0x01, 0xB2, 0x00, 0x38, 0x80,
  0x0E, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x6C, 0x60, 0x33, 0x0E, 0x38,
  0x61, 0xFC, 0x0C, 0xFF, 0xFF, 0xFD, 0x40, 0x01, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x0C, 0x21, 0xFD, 0x7C, 0x3E, 0x00, 0xE0, 0x05, 0x80,
  0x46, 0x06, 0x10, 0x60, 0xC2, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x33, 0x33, 0x36, 0x66,
  0x4C, 0xC0, 0xFF, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x1C, 0xE0, 0x60, 0x61, 0x80, 0xC3, 0x00, 0xC6, 0x01,
  0x98, 0x03, 0x30, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x1C,
  0x0C, 0x18, 0x18, 0x1C, 0xE0, 0x1F, 0x80, 0x03, 0x07, 0x0F, 0x1B, 0x33,
  0x63, 0xC3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xE0, 0xF1, 0xE1, 0x80, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE0, 0xF1, 0xE3, 0x00, 0x64, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x80, 0x19, 0xE1, 0xE1, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30,
  0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x6F, 0xC0, 0x7F, 0xF0, 0x40, 0x38, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x80, 0x38, 0xF8, 0xF0, 0x7F, 0xE0, 0x01,
  0xFC, 0x07, 0xDC, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x80, 0x47, 0xF0, 0xCC, 0x38, 0xD8, 0x0C, 0xD0, 0x0C, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x06, 0x30, 0x0C, 0x18, 0x1C, 0x1C, 0x38, 0x0F, 0xF0, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x1C, 0x78, 0x30, 0x1C, 0x60,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0x40, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x70, 0x07,
  0xE0, 0x03, 0x80, 0x07, 0xE0, 0x1C, 0x70, 0x38, 0x18, 0x30, 0x0C, 0x60,
  0x0E, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x3C,
  0x38, 0x0F, 0xF0, 0x0F, 0xE0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0xC6, 0x00,
  0xC8, 0x01, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x0E, 0xC0,
  0x1C, 0xC0, 0x59, 0xC3, 0xB1, 0xFE, 0x60, 0x70, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0xC3, 0x81, 0xFE, 0x00, 0xFF, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x37, 0x73, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x33, 0x66, 0x64, 0xCC, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x1C, 0x7A, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x98, 0x0F, 0xE0, 0xC8, 0x0E, 0x30, 0x6C, 0x06, 0x18,
  0x36, 0x06, 0x0C, 0x0B, 0x02, 0x06, 0x05, 0x83, 0x03, 0x03, 0xC1, 0x81,
  0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0x40, 0x60, 0x70, 0x20, 0x20, 0x38, 0x10,
  0x10, 0x1C, 0x08, 0x08, 0x0A, 0x04, 0x0C, 0x05, 0x03, 0x06, 0x06, 0x81,
  0x83, 0x03, 0x60, 0xC1, 0xC1, 0xB0, 0x61, 0xA1, 0x98, 0x19, 0x99, 0xCC,
  0x07, 0x87, 0xC2, 0x00, 0x80, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x04, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x64, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x20,
  0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x00, 0x20, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x10, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x00, 0x42, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0xFF, 0xC0,
  0xFF, 0xF0, 0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0xF0, 0xFF, 0xC0, 0xC1, 0xF0, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x07, 0x87,
  0x0E, 0x01, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x01, 0x07, 0x87, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x30, 0x1E,
  0x18, 0x03, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31,
  0x80, 0x30, 0xC0, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xF7, 0xFF, 0xB0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xBF,
  0xFD, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x3C, 0x3F, 0x0E, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x0E,
  0x00, 0x30, 0x7C, 0x1F, 0x01, 0xFF, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xFF, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0x8E, 0xFC, 0x78, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x66, 0x00,
  0xCC, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x83, 0x03,
  0x06, 0x06, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xDC,
  0x01, 0xEC, 0x03, 0xD8, 0x07, 0x18, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03, 0x18,
  0x03, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x18, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF4, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x6F, 0x40,
  0x00, 0x37, 0xB0, 0x00, 0x1B, 0xD8, 0x00, 0x09, 0xE4, 0x00, 0x0C, 0xF3,
  0x00, 0x06, 0x79, 0x80, 0x02, 0x3C, 0xC0, 0x03, 0x1E, 0x20, 0x01, 0x8F,
  0x18, 0x00, 0xC7, 0x8C, 0x00, 0xC3, 0xC2, 0x00, 0x61, 0xE1, 0x80, 0x30,
  0xF0, 0xC0, 0x10, 0x78, 0x20, 0x18, 0x3C, 0x18, 0x0C, 0x1E, 0x0C, 0x04,
  0x0F, 0x06, 0x06, 0x07, 0x81, 0x83, 0x03, 0xC0, 0xC1, 0x81, 0xE0, 0x61,
  0x80, 0xF0, 0x10, 0xC0, 0x78, 0x0C, 0x60, 0x3C, 0x06, 0x20, 0x1E, 0x03,
  0x30, 0x0F, 0x00, 0xD8, 0x07, 0x80, 0x68, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x60, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0E, 0xC0, 0x03, 0xF0, 0x00, 0xF4, 0x00, 0x3D, 0x80, 0x0F, 0x60, 0x03,
  0xCC, 0x00, 0xF3, 0x00, 0x3C, 0x60, 0x0F, 0x18, 0x03, 0xC2, 0x00, 0xF0,
  0xC0, 0x3C, 0x30, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x30, 0x3C, 0x0C,
  0x0F, 0x01, 0x83, 0xC0, 0x60, 0xF0, 0x08, 0x3C, 0x03, 0x0F, 0x00, 0xC3,
  0xC0, 0x18, 0xF0, 0x06, 0x3C, 0x00, 0xCF, 0x00, 0x33, 0xC0, 0x06, 0xF0,
  0x01, 0xBC, 0x00, 0x6F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1C, 0x03, 0xFC, 0x00, 0xF0, 0xE0, 0x1C, 0x03, 0x01, 0x80, 0x18, 0x30,
  0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x00,
  0xF9, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0E,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x01,
  0xCC, 0x3E, 0x3F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0xE0,
  0x1C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0x40, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01,
  0xC1, 0x80, 0x18, 0x1C, 0x03, 0x00, 0xF9, 0xE0, 0x03, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xFF, 0x81, 0xFF, 0xC3, 0x01,
  0xC6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x60,
  0x0C, 0xC0, 0x31, 0x83, 0xC3, 0xFE, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0x61, 0x80, 0xC3, 0x00, 0xC6, 0x01, 0x8C,
  0x03, 0x18, 0x03, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0F, 0x00,
  0x18, 0x0F, 0xFC, 0x3C, 0x3C, 0xE0, 0x0B, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x80, 0x19, 0xF1, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80,
  0x02, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x0C, 0x38, 0x07,
  0x07, 0x87, 0x80, 0x7F, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x00, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x30, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00,
  0x30, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00,
  0x13, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x40, 0x01, 0x80,
  0x03, 0x60, 0x01, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0x06, 0x60, 0x03, 0xC0,
  0x06, 0x60, 0x03, 0xC0, 0x06, 0x30, 0x03, 0x40, 0x06, 0x30, 0x03, 0x60,
  0x06, 0x30, 0x02, 0x60, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x60,
  0x0C, 0x18, 0x06, 0x20, 0x0C, 0x18, 0x06, 0x30, 0x08, 0x18, 0x04, 0x30,
  0x18, 0x18, 0x0C, 0x30, 0x18, 0x08, 0x0C, 0x30, 0x18, 0x0C, 0x0C, 0x10,
  0x18, 0x0C, 0x0C, 0x18, 0x30, 0x0C, 0x08, 0x18, 0x30, 0x0C, 0x18, 0x18,
  0x30, 0x04, 0x18, 0x18, 0x30, 0x06, 0x18, 0x08, 0x30, 0x06, 0x18, 0x08,
  0x60, 0x06, 0x10, 0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60, 0x03, 0x30, 0x0C,
  0x60, 0x03, 0x30, 0x04, 0x40, 0x03, 0x30, 0x04, 0xC0, 0x03, 0x20, 0x06,
  0xC0, 0x03, 0x60, 0x06, 0xC0, 0x01, 0x60, 0x06, 0xC0, 0x01, 0xE0, 0x02,
  0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03,
  0x80, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x18, 0x06, 0x18, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x01, 0x60, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0x60, 0x03, 0x60, 0x03, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x18,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x20, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x10, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x10, 0x0C,
  0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x03, 0x40, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFD, 0xFF,
  0xF0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xE0,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18,
  0x20, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x30, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0, 0xC0, 0xC1, 0x81, 0x80, 0x1F, 0xC1,
  0xC7, 0x88, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x03, 0xF0, 0xFD, 0x9C, 0x0D, 0xC0, 0x6C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xAC,
  0x0D, 0x70, 0xC9, 0xFC, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCE, 0x38, 0xD8, 0x0C, 0xD0, 0x0C, 0xF0,
  0x06, 0xE0, 0x06, 0xE0, 0x02, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xD0,
  0x0C, 0xD8, 0x1C, 0xCE, 0x38, 0xC7, 0xF0, 0x07, 0xF8, 0x79, 0x86, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x18,
  0x3F, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x0F, 0xE3, 0x1E, 0x73, 0x38, 0x1B, 0x30, 0x0F, 0x70, 0x07, 0x60, 0x07,
  0x60, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x38, 0x1B,
  0x1C, 0x33, 0x0F, 0xE3, 0x07, 0xE0, 0x38, 0xE0, 0x60, 0x61, 0x80, 0xC2,
  0x00, 0xCC, 0x01, 0x98, 0x01, 0x30, 0x03, 0x40, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x02, 0x0E, 0x1C, 0x0F, 0xF0, 0x03, 0xF0, 0x71, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFC, 0xFF,
  0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x0F, 0xE3, 0x1E, 0x73, 0x38, 0x1B, 0x30, 0x0F, 0x60, 0x07, 0x60,
  0x07, 0x60, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x38,
  0x1B, 0x1C, 0x33, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x40, 0x0C, 0x60,
  0x38, 0x7F, 0xF0, 0x0F, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x31, 0xF8, 0xCE, 0x73, 0x60, 0x6D, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0x5F, 0xF0,
  0x00, 0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20,
  0x08, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0x86, 0x18, 0x6F, 0x38,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x7C, 0x03, 0x60, 0x33, 0x01,
  0x98, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x60, 0x67, 0x03,
  0x38, 0x1B, 0x60, 0xD3, 0x07, 0x8C, 0x38, 0x61, 0x81, 0x0C, 0x0C, 0x60,
  0x63, 0x01, 0x98, 0x0C, 0xC0, 0x26, 0x01, 0xB0, 0x0D, 0x80, 0x3C, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7,
  0xE0, 0xFC, 0xCC, 0x71, 0x9E, 0xD8, 0x32, 0x06, 0xD0, 0x1E, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC7, 0xF3, 0x39, 0xED, 0x81, 0xB4, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x30, 0x0F, 0xF0, 0x1C, 0x78, 0x38, 0x1C, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x38, 0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0xC7, 0xF0, 0xCE, 0x38, 0xD8,
  0x0C, 0xD0, 0x0C, 0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x02, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x06, 0xE0,
  0x06, 0xF0, 0x06, 0xD0, 0x0C, 0xD8, 0x1C, 0xCE, 0x38, 0xC7, 0xF0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE3, 0x1E,
  0x73, 0x18, 0x1B, 0x30, 0x0F, 0x30, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60,
  0x07, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x38, 0x1B, 0x1C, 0x33, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7,
  0xF3, 0xFD, 0x83, 0x40, 0xD0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xE7, 0x8F, 0x60,
  0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x78, 0x06, 0xF1, 0xC7, 0xF8, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x83, 0xFF, 0xFF, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x62, 0x1F, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1D,
  0x80, 0x76, 0x03, 0x5C, 0x09, 0x38, 0xE4, 0x7E, 0x10, 0xC0, 0x06, 0x80,
  0x0D, 0x80, 0x33, 0x00, 0x66, 0x00, 0xC4, 0x01, 0x8C, 0x06, 0x18, 0x0C,
  0x30, 0x18, 0x20, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x02,
  0x08, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x11, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0xD8, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x0C,
  0x00, 0xD8, 0x03, 0x00, 0x66, 0x00, 0xE0, 0x19, 0x80, 0x78, 0x06, 0x60,
  0x1E, 0x01, 0x88, 0x06, 0x80, 0x43, 0x01, 0x30, 0x30, 0xC0, 0x4C, 0x0C,
  0x30, 0x33, 0x03, 0x04, 0x0C, 0xC0, 0x81, 0x83, 0x10, 0x60, 0x60, 0x86,
  0x18, 0x18, 0x61, 0x86, 0x06, 0x18, 0x61, 0x80, 0x86, 0x08, 0x40, 0x31,
  0x82, 0x30, 0x0C, 0x40, 0xCC, 0x03, 0x30, 0x33, 0x00, 0x4C, 0x0C, 0xC0,
  0x1B, 0x01, 0x20, 0x06, 0x80, 0x58, 0x01, 0xA0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0D, 0x80, 0x66, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0x60, 0xC1, 0x86, 0x03,
  0x18, 0x0C, 0xC0, 0x13, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0xA0, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x18, 0x30, 0x30,
  0xC0, 0xC6, 0x01, 0x98, 0x06, 0xC0, 0x0F, 0x00, 0x30, 0xC0, 0x07, 0x80,
  0x19, 0x00, 0x33, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x08, 0x06, 0x18, 0x0C,
  0x30, 0x10, 0x60, 0x60, 0x40, 0xC0, 0xC1, 0x81, 0x82, 0x03, 0x0C, 0x02,
  0x18, 0x06, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x13, 0x00, 0x36, 0x00, 0x68,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x0F,
  0xC0, 0xE0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x07, 0xC0, 0x78, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x07, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x07, 0xE0, 0x38, 0x00,
  0x0C, 0x00, 0x1F, 0xC0, 0x58, 0x70, 0x78, 0x0F, 0xF8, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 35, 10, 3, -35 },
  { 19, 9, 13, 15, 3, -35 },
  { 34, 19, 35, 21, 1, -35 },
  { 118, 16, 40, 20, 2, -37 },
  { 198, 25, 35, 29, 2, -35 },
  { 308, 18, 35, 20, 2, -35 },
  { 387, 2, 13, 8, 3, -35 },
  { 391, 9, 43, 13, 2, -35 },
  { 440, 9, 43, 13, 2, -35 },
  { 489, 13, 13, 17, 2, -37 },
  { 511, 17, 23, 20, 1, -29 },
  { 560, 4, 11, 9, 2, -5 },
  { 566, 11, 2, 13, 1, -14 },
  { 569, 3, 4, 9, 3, -4 },
  { 571, 15, 35, 17, 1, -35 },
  { 637, 15, 35, 20, 2, -35 },
  { 703, 8, 35, 20, 4, -35 },
  { 738, 15, 35, 20, 2, -35 },
  { 804, 15, 35, 20, 2, -35 },
  { 870, 18, 35, 20, 1, -35 },
  { 949, 16, 35, 20, 2, -35 },
  { 1019, 16, 36, 20, 2, -35 },
  { 1091, 15, 35, 20, 2, -35 },
  { 1157, 16, 35, 20, 2, -35 },
  { 1227, 15, 35, 20, 2, -35 },
  { 1293, 3, 26, 9, 3, -26 },
  { 1303, 4, 32, 9, 2, -26 },
  { 1319, 17, 21, 20, 1, -28 },
  { 1364, 17, 12, 20, 1, -23 },
  { 1390, 17, 21, 20, 1, -28 },
  { 1435, 11, 35, 13, 1, -35 },
  { 1484, 25, 39, 30, 3, -35 },
  { 1606, 19, 35, 19, 0, -35 },
  { 1690, 16, 35, 22, 4, -35 },
  { 1760, 16, 35, 21, 3, -35 },
  { 1830, 17, 35, 24, 4, -35 },
  { 1905, 13, 35, 19, 4, -35 },
  { 1962, 13, 35, 18, 4, -35 },
  { 2019, 20, 35, 26, 3, -35 },
  { 2107, 17, 35, 24, 4, -35 },
  { 2182, 8, 35, 11, 2, -35 },
  { 2217, 8, 44, 10, -2, -35 },
  { 2261, 15, 35, 19, 4, -35 },
  { 2327, 12, 35, 17, 4, -35 },
  { 2380, 25, 35, 33, 4, -35 },
  { 2490, 18, 35, 25, 4, -35 },
  { 2569, 20, 35, 25, 3, -35 },
  { 2657, 14, 35, 20, 4, -35 },
  { 2719, 20, 43, 25, 3, -35 },
  { 2827, 15, 35, 20, 4, -35 },
  { 2893, 15, 35, 19, 2, -35 },
  { 2959, 17, 35, 17, 0, -35 },
  { 3034, 18, 35, 24, 3, -35 },
  { 3113, 19, 35, 19, 0, -35 },
  { 3197, 32, 35, 32, 0, -35 },
  { 3337, 16, 35, 17, 0, -35 },
  { 3407, 16, 35, 16, 0, -35 },
  { 3477, 14, 35, 16, 1, -35 },
  { 3539, 9, 43, 15, 4, -35 },
  { 3588, 15, 35, 16, 1, -35 },
  { 3654, 9, 43, 15, 2, -35 },
  { 3703, 18, 17, 20, 1, -35 },
  { 3742, 20, 2, 20, 0, 4 },
  { 3747, 7, 7, 11, 2, -37 },
  { 3754, 13, 26, 18, 2, -26 },
  { 3797, 16, 37, 21, 3, -37 },
  { 3871, 13, 26, 16, 2, -26 },
  { 3914, 16, 37, 21, 2, -37 },
  { 3988, 15, 26, 19, 2, -26 },
  { 4037, 12, 37, 11, 0, -37 },
  { 4093, 16, 38, 21, 2, -26 },
  { 4169, 14, 37, 20, 3, -37 },
  { 4234, 3, 36, 9, 3, -36 },
  { 4248, 6, 48, 9, 0, -36 },
  { 4284, 13, 37, 17, 3, -37 },
  { 4345, 2, 37, 9, 3, -37 },
  { 4355, 24, 26, 31, 3, -26 },
  { 4433, 14, 26, 20, 3, -26 },
  { 4479, 16, 26, 20, 2, -26 },
  { 4531, 16, 37, 21, 3, -26 },
  { 4605, 16, 37, 21, 2, -26 },
  { 4679, 10, 26, 13, 3, -26 },
  { 4712, 12, 26, 16, 2, -26 },
  { 4751, 9, 32, 11, 1, -32 },
  { 4787, 14, 26, 20, 3, -26 },
  { 4833, 15, 26, 15, 0, -26 },
  { 4882, 26, 26, 26, 0, -26 },
  { 4967, 14, 26, 16, 1, -26 },
  { 5013, 15, 38, 16, 1, -26 },
  { 5085, 11, 26, 13, 1, -26 },
  { 5121, 13, 43, 17, 2, -35 },
  { 5191, 1, 49, 19, 9, -37 },
  { 5198, 13, 43, 17, 2, -35 },
  { 5268, 17, 5, 20, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT49PT7B_H_
