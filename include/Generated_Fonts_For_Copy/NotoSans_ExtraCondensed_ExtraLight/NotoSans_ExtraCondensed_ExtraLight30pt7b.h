#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFD, 0x55, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x20,
  0x08, 0x81, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x3F, 0xF8, 0x84, 0x11,
  0x02, 0x20, 0x44, 0x10, 0x82, 0x11, 0xFF, 0xC8, 0x41, 0x08, 0x21, 0x04,
  0x40, 0x88, 0x11, 0x04, 0x20, 0x08, 0x02, 0x01, 0xF1, 0xA2, 0x48, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x12, 0x06, 0x80, 0x60, 0x0E, 0x02, 0xC0, 0x88,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x23, 0x89, 0x9F, 0xC0, 0x80, 0x20, 0x08,
  0x00, 0x10, 0x00, 0xD0, 0x21, 0x10, 0x82, 0x21, 0x08, 0x42, 0x10, 0x88,
  0x21, 0x10, 0x42, 0x20, 0x84, 0x81, 0x09, 0x39, 0x12, 0x8A, 0x29, 0x16,
  0x92, 0x22, 0x28, 0x40, 0x90, 0x81, 0x21, 0x02, 0x42, 0x08, 0x84, 0x10,
  0x88, 0x21, 0x10, 0x82, 0x21, 0x03, 0x80, 0x18, 0x06, 0xC0, 0x88, 0x11,
  0x02, 0x20, 0x44, 0x08, 0x81, 0x10, 0x34, 0x03, 0x80, 0x60, 0x14, 0x04,
  0x40, 0x88, 0xA0, 0x94, 0x12, 0x81, 0x50, 0x32, 0x02, 0x60, 0xA4, 0x34,
  0x7C, 0x40, 0xFE, 0x19, 0x88, 0xC4, 0x23, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x84, 0x20, 0x84, 0x10, 0x40, 0xC1, 0x82, 0x0C, 0x10,
  0x40, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x86, 0x10,
  0x42, 0x08, 0x42, 0x00, 0x08, 0x08, 0x08, 0xEB, 0x1C, 0x14, 0x24, 0x62,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xFF, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x2D, 0x24, 0xA0, 0xFC, 0xF0, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x00, 0x0C,
  0x0C, 0xC2, 0x11, 0x82, 0x40, 0x90, 0x24, 0x09, 0x02, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x02, 0x40, 0x90, 0x24, 0x08, 0x86,
  0x31, 0x07, 0x80, 0x0C, 0xF6, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x1D, 0xC4, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x3F, 0xF0, 0x1C,
  0x19, 0xC8, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0xC3,
  0xC0, 0x18, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x81, 0x3F, 0x80, 0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0xC8, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x7F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x10,
  0xC0, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x1A,
  0x0C, 0x7E, 0x00, 0x07, 0x07, 0x61, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x17, 0xCE, 0x1B, 0x02, 0xC0, 0xB0, 0x3C, 0x05, 0x01, 0x40,
  0xD0, 0x34, 0x09, 0x82, 0x21, 0x87, 0xC0, 0xFF, 0xC0, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x0C,
  0xC6, 0x09, 0x02, 0x40, 0x90, 0x34, 0x09, 0x02, 0x21, 0x04, 0x80, 0xC0,
  0x78, 0x21, 0x10, 0x2C, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02, 0x61,
  0x8F, 0xC0, 0x1C, 0x19, 0x90, 0x48, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xE0, 0x50, 0x28, 0x32, 0x28, 0xE4, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x60, 0x63, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x5A, 0x4B, 0x40, 0x00, 0x40, 0x30, 0x30, 0x30, 0x30, 0x30, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x40, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x00, 0x80, 0x00, 0x38, 0xEE,
  0x02, 0x02, 0x03, 0x03, 0x02, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x30, 0x30, 0x01, 0x00, 0x1D, 0xC0,
  0x40, 0x41, 0x00, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x41, 0xE3, 0x84,
  0x43, 0x18, 0x86, 0x21, 0x0C, 0x42, 0x18, 0x84, 0x31, 0x08, 0x62, 0x10,
  0xC4, 0x63, 0x88, 0xC5, 0x0A, 0x5A, 0x08, 0x46, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x20, 0x03, 0x80, 0x06, 0x00, 0x60, 0x0A, 0x00,
  0x90, 0x09, 0x00, 0x90, 0x19, 0x01, 0x18, 0x10, 0x81, 0x08, 0x10, 0x82,
  0x08, 0x3F, 0xC2, 0x04, 0x20, 0x46, 0x04, 0x40, 0x24, 0x02, 0x40, 0x2C,
  0x02, 0x80, 0x30, 0xFF, 0x20, 0x68, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0A,
  0x02, 0x81, 0x3F, 0x88, 0x32, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0A, 0x06, 0xFE, 0x00, 0x07, 0x06, 0x33, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x43, 0xF0, 0xFE, 0x10,
  0x32, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x14, 0x02, 0x80, 0x50, 0x1A, 0x06,
  0x41, 0x8F, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x03, 0x81, 0xC7,
  0x30, 0x16, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01,
  0x40, 0x12, 0x01, 0x30, 0x10, 0xFE, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFE, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F,
  0x80, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x62, 0x17, 0x80, 0x80, 0xE0, 0x48, 0x12, 0x08, 0x86,
  0x21, 0x08, 0x82, 0x20, 0x90, 0x2C, 0x0B, 0x83, 0x20, 0xCC, 0x21, 0x08,
  0x62, 0x08, 0x83, 0x20, 0x48, 0x1A, 0x02, 0x80, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x03, 0xE0, 0x07, 0xA0, 0x05,
  0xA0, 0x05, 0xA0, 0x0D, 0x90, 0x09, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11,
  0x88, 0x11, 0x88, 0x11, 0x8C, 0x31, 0x84, 0x21, 0x84, 0x21, 0x84, 0x61,
  0x82, 0x41, 0x82, 0x41, 0x82, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC0, 0x3C, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C, 0x41, 0x8C,
  0x30, 0x86, 0x10, 0xC1, 0x18, 0x23, 0x02, 0x60, 0x4C, 0x05, 0x80, 0xB0,
  0x1E, 0x01, 0xC0, 0x38, 0x02, 0x06, 0x03, 0x98, 0x20, 0x44, 0x06, 0xC0,
  0x28, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3C, 0x02, 0x40, 0x26, 0x04, 0x30,
  0xC1, 0xF8, 0xFE, 0x40, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0xDF, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x06, 0x03, 0x98, 0x20, 0x44, 0x06, 0xC0, 0x28, 0x02, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x3C, 0x02, 0x40, 0x26, 0x04, 0x30, 0xC1, 0xF8, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0xFE, 0x20, 0x48, 0x1A, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0xA0, 0x4F, 0xE2, 0x30, 0x84, 0x21,
  0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x1A, 0x02, 0x80, 0xC0, 0x0E, 0x0C,
  0x66, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x81,
  0x3F, 0x80, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x78, 0x09, 0x01, 0x30, 0x43, 0xF0, 0x80, 0x38,
  0x05, 0x00, 0xA0, 0x34, 0x04, 0xC0, 0x88, 0x11, 0x06, 0x20, 0x84, 0x10,
  0x42, 0x08, 0xC1, 0x10, 0x22, 0x06, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x40, 0xC0, 0x60, 0x34, 0x06, 0x02, 0x40, 0x60, 0x24, 0x06,
  0x02, 0x40, 0xA0, 0x66, 0x09, 0x04, 0x20, 0x90, 0x42, 0x09, 0x04, 0x20,
  0x90, 0x42, 0x11, 0x0C, 0x31, 0x08, 0x81, 0x10, 0x88, 0x11, 0x08, 0x81,
  0x10, 0x88, 0x12, 0x09, 0x00, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x50,
  0x0A, 0x05, 0x00, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x40, 0xC8, 0x22, 0x08,
  0xC6, 0x11, 0x04, 0x40, 0xA0, 0x28, 0x0A, 0x01, 0x00, 0xC0, 0x28, 0x0A,
  0x04, 0x81, 0x10, 0xC4, 0x21, 0x08, 0x24, 0x09, 0x03, 0xC0, 0x40, 0x80,
  0xD0, 0x24, 0x09, 0x06, 0x21, 0x08, 0x42, 0x30, 0x48, 0x12, 0x04, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0xFF, 0x01, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0xFF, 0xFF,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0x80, 0x60, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0xFC, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x07, 0xF0, 0x0C, 0x01, 0xC0, 0x48, 0x09, 0x83, 0x10, 0x42, 0x18,
  0x22, 0x04, 0xC0, 0x50, 0x0C, 0xFF, 0xF0, 0xC2, 0x08, 0x20, 0x80, 0x3E,
  0x43, 0x01, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61, 0x41, 0x81, 0x81, 0x81,
  0x83, 0x43, 0x7D, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x78, 0xA1, 0x30, 0x2C, 0x0A, 0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0B, 0x02, 0xC0, 0xA8, 0x49, 0xE0, 0x1F, 0x30, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x1F,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x79, 0x21, 0x58,
  0x34, 0x0D, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x05,
  0x03, 0x40, 0xC8, 0x53, 0xE4, 0x1E, 0x10, 0x90, 0x68, 0x14, 0x0A, 0x07,
  0x03, 0xFF, 0x80, 0x60, 0x10, 0x08, 0x04, 0x03, 0x00, 0x82, 0x3F, 0x0E,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1E, 0x48, 0x54, 0x0D,
  0x03, 0x40, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x05, 0x03, 0x40,
  0xD0, 0x32, 0x14, 0x79, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x90, 0x67,
  0xF0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x3C, 0xA3, 0x60,
  0xB0, 0x50, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x06, 0xB8, 0x0A, 0xAA, 0xAA, 0xAA, 0xA0, 0x23, 0x20, 0x00,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xE0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x83, 0x82, 0x84, 0x8C, 0x88,
  0x90, 0x90, 0xB8, 0xC8, 0xC8, 0x84, 0x84, 0x86, 0x82, 0x82, 0x81, 0xFF,
  0xFF, 0xFE, 0x9E, 0x79, 0x45, 0x0B, 0x0E, 0x16, 0x08, 0x38, 0x10, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x9E, 0x51, 0xB0, 0x58,
  0x28, 0x14, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x1F, 0x08, 0x64, 0x09, 0x02, 0x40, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x05, 0x01, 0x40, 0x90, 0x22, 0x18, 0x7C, 0x9E, 0x28,
  0x4C, 0x0B, 0x02, 0x80, 0xA0, 0x28, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0A,
  0x02, 0xC0, 0xB0, 0x6A, 0x12, 0x78, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x1E, 0x48, 0x56, 0x0D, 0x03, 0x40, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x05, 0x03, 0x40, 0xD0, 0x32, 0x14, 0x79, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x9E, 0x8C, 0x30, 0xC2,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3E, 0x42, 0x80, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x02, 0x02, 0x03, 0x02, 0x82, 0xFC,
  0x42, 0x10, 0x8F, 0xA1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x70, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x83, 0x43, 0x7D, 0x80, 0xE0, 0x50, 0x68, 0x24, 0x13, 0x08,
  0x8C, 0x44, 0x22, 0x11, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x30, 0x10, 0x81,
  0x83, 0x41, 0x82, 0x41, 0x82, 0x41, 0x82, 0x43, 0x42, 0x62, 0x44, 0x22,
  0x44, 0x22, 0x44, 0x22, 0x44, 0x24, 0x24, 0x14, 0x28, 0x14, 0x28, 0x14,
  0x28, 0x14, 0x28, 0x18, 0x18, 0x08, 0x10, 0x40, 0xB0, 0xC8, 0x44, 0x61,
  0x20, 0x90, 0x30, 0x18, 0x0C, 0x0E, 0x04, 0x82, 0x42, 0x11, 0x09, 0x07,
  0x81, 0x40, 0xD0, 0x24, 0x09, 0x82, 0x21, 0x08, 0x42, 0x10, 0xC4, 0x12,
  0x04, 0x81, 0x20, 0x68, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x0E, 0x00, 0xFC, 0x10, 0x42, 0x08, 0x61, 0x04,
  0x20, 0x82, 0x10, 0x43, 0x08, 0x3F, 0x07, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0xE0, 0x30, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C,
  0x07, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x30, 0xC0, 0x78, 0x63, 0x38, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 7, 9, 2, -21 },
  { 12, 11, 21, 13, 1, -21 },
  { 41, 10, 25, 12, 1, -23 },
  { 73, 15, 22, 18, 1, -22 },
  { 115, 11, 22, 12, 1, -22 },
  { 146, 1, 7, 5, 2, -21 },
  { 147, 5, 26, 8, 2, -21 },
  { 164, 6, 26, 8, 1, -21 },
  { 184, 8, 8, 11, 1, -23 },
  { 192, 10, 14, 12, 1, -18 },
  { 210, 3, 7, 6, 1, -3 },
  { 213, 6, 1, 8, 1, -9 },
  { 214, 2, 2, 6, 2, -2 },
  { 215, 9, 21, 10, 1, -21 },
  { 239, 10, 22, 12, 1, -22 },
  { 267, 6, 21, 12, 2, -21 },
  { 283, 10, 22, 12, 1, -22 },
  { 311, 10, 22, 12, 1, -22 },
  { 339, 12, 22, 12, 0, -22 },
  { 372, 10, 21, 12, 1, -21 },
  { 399, 10, 22, 12, 1, -22 },
  { 427, 10, 21, 12, 1, -21 },
  { 454, 10, 22, 12, 1, -22 },
  { 482, 9, 22, 12, 1, -22 },
  { 507, 2, 16, 6, 2, -16 },
  { 511, 3, 20, 6, 1, -16 },
  { 519, 10, 13, 12, 1, -17 },
  { 536, 10, 7, 12, 1, -14 },
  { 545, 10, 13, 12, 1, -17 },
  { 562, 8, 22, 8, 0, -22 },
  { 584, 15, 25, 18, 2, -22 },
  { 631, 12, 21, 12, 0, -21 },
  { 663, 10, 21, 13, 2, -21 },
  { 690, 10, 22, 13, 2, -22 },
  { 718, 11, 21, 14, 2, -21 },
  { 747, 8, 21, 12, 2, -21 },
  { 768, 8, 21, 11, 2, -21 },
  { 789, 12, 22, 16, 2, -22 },
  { 822, 11, 21, 15, 2, -21 },
  { 851, 5, 21, 7, 1, -21 },
  { 865, 5, 26, 6, -1, -21 },
  { 882, 10, 21, 12, 2, -21 },
  { 909, 8, 21, 10, 2, -21 },
  { 930, 16, 21, 20, 2, -21 },
  { 972, 11, 21, 16, 2, -21 },
  { 1001, 12, 22, 16, 2, -22 },
  { 1034, 9, 21, 12, 2, -21 },
  { 1058, 12, 27, 16, 2, -22 },
  { 1099, 10, 21, 12, 2, -21 },
  { 1126, 10, 22, 12, 1, -22 },
  { 1154, 10, 21, 10, 0, -21 },
  { 1181, 11, 21, 15, 2, -21 },
  { 1210, 11, 21, 11, 0, -21 },
  { 1239, 20, 21, 20, 0, -21 },
  { 1292, 10, 21, 10, 0, -21 },
  { 1319, 10, 21, 10, 0, -21 },
  { 1346, 8, 21, 10, 1, -21 },
  { 1367, 6, 26, 9, 2, -21 },
  { 1387, 9, 21, 10, 1, -21 },
  { 1411, 6, 26, 9, 1, -21 },
  { 1431, 11, 10, 12, 1, -21 },
  { 1445, 12, 1, 12, 0, 3 },
  { 1447, 5, 5, 7, 1, -23 },
  { 1451, 8, 16, 11, 1, -16 },
  { 1467, 10, 23, 13, 2, -23 },
  { 1496, 8, 16, 10, 1, -16 },
  { 1512, 10, 23, 13, 1, -23 },
  { 1541, 9, 16, 12, 1, -16 },
  { 1559, 7, 23, 7, 0, -23 },
  { 1580, 10, 23, 13, 1, -16 },
  { 1609, 9, 23, 13, 2, -23 },
  { 1635, 2, 22, 6, 2, -22 },
  { 1641, 4, 29, 6, 0, -22 },
  { 1656, 8, 23, 10, 2, -23 },
  { 1679, 1, 23, 5, 2, -23 },
  { 1682, 15, 16, 19, 2, -16 },
  { 1712, 9, 16, 13, 2, -16 },
  { 1730, 10, 16, 12, 1, -16 },
  { 1750, 10, 23, 13, 2, -16 },
  { 1779, 10, 23, 13, 1, -16 },
  { 1808, 6, 16, 8, 2, -16 },
  { 1820, 8, 16, 10, 1, -16 },
  { 1836, 5, 20, 7, 1, -20 },
  { 1849, 8, 16, 13, 2, -16 },
  { 1865, 9, 16, 9, 0, -16 },
  { 1883, 16, 16, 16, 0, -16 },
  { 1915, 9, 16, 10, 0, -16 },
  { 1933, 10, 23, 10, 0, -16 },
  { 1962, 6, 16, 8, 1, -16 },
  { 1974, 8, 26, 10, 1, -21 },
  { 2000, 1, 30, 11, 5, -23 },
  { 2004, 8, 26, 10, 1, -21 },
  { 2030, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT30PT7B_H_
