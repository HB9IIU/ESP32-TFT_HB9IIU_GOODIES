#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x60, 0x99, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22,
  0x04, 0x40, 0x88, 0x11, 0x1F, 0xF8, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x8F, 0xFC, 0x22, 0x08, 0x41, 0x10, 0x22, 0x04, 0x40, 0x88, 0x00, 0x08,
  0x04, 0x0F, 0xC9, 0x28, 0x84, 0x42, 0x21, 0x10, 0xC8, 0x34, 0x06, 0x01,
  0xC0, 0xB0, 0x48, 0x22, 0x11, 0x09, 0x44, 0xBF, 0x81, 0x00, 0x80, 0x40,
  0x30, 0x42, 0x42, 0x22, 0x11, 0x11, 0x08, 0x88, 0x44, 0x42, 0x24, 0x11,
  0x24, 0x89, 0x54, 0x54, 0x52, 0xA2, 0x65, 0x10, 0x48, 0x82, 0x44, 0x12,
  0x21, 0x11, 0x08, 0x88, 0x44, 0x44, 0x1C, 0x18, 0x09, 0x04, 0x41, 0x10,
  0x44, 0x11, 0x02, 0x40, 0xA0, 0x18, 0x0C, 0x04, 0x82, 0x22, 0x84, 0xA1,
  0x28, 0x32, 0x0C, 0x83, 0x31, 0xA7, 0xCC, 0xFE, 0x08, 0x84, 0x42, 0x21,
  0x08, 0x44, 0x21, 0x08, 0x42, 0x08, 0x42, 0x18, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x42,
  0x22, 0x00, 0x10, 0x22, 0x4B, 0xE1, 0x05, 0x11, 0x00, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x55,
  0xA0, 0xF8, 0xC0, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x00, 0x1C, 0x26, 0x42, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41,
  0x42, 0x22, 0x3C, 0x09, 0xDB, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x38, 0xC6, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFF, 0x3C, 0xC6,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x38, 0x06, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x82, 0xFC, 0x01, 0x00, 0xC0, 0x30, 0x14, 0x05, 0x02,
  0x40, 0x90, 0x44, 0x11, 0x08, 0x42, 0x11, 0x04, 0x41, 0x20, 0x4F, 0xFC,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0xFC, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x82, 0xFC,
  0x0E, 0x11, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0xBE, 0xC3, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x41, 0x42, 0x3E, 0xFF, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x1C, 0x62, 0x41, 0x81, 0x81, 0xC1, 0x41, 0x62, 0x3C, 0x18,
  0x26, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3E, 0x38, 0x66, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x43, 0x3D, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x04, 0x78, 0xC0, 0x0C, 0x50, 0x00, 0x01, 0x56, 0x80, 0x00,
  0x80, 0xC1, 0x83, 0x06, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x00, 0x79, 0x98, 0x10, 0x20,
  0x20, 0x81, 0x02, 0x08, 0x30, 0x41, 0x02, 0x04, 0x00, 0x00, 0x00, 0x40,
  0xC0, 0x03, 0x80, 0x31, 0x81, 0x03, 0x08, 0x04, 0x20, 0x09, 0x00, 0x24,
  0x3C, 0x91, 0x11, 0x88, 0x86, 0x22, 0x18, 0x88, 0x62, 0x21, 0x88, 0x86,
  0x22, 0x24, 0x54, 0x91, 0xDC, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0F, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x48,
  0x21, 0x08, 0x42, 0x10, 0xFC, 0x20, 0x90, 0x24, 0x09, 0x02, 0x40, 0x60,
  0x18, 0x04, 0xF0, 0x86, 0x83, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xFC,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x07, 0x0C, 0x48,
  0x04, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x03, 0xE0, 0xF0, 0x47, 0x20, 0xD0, 0x28,
  0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x02, 0x81, 0x43, 0x3F, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0xFA, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xFC, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x07, 0x83, 0x0C, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x07, 0xC0, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x20, 0x22, 0x04, 0x3F, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xBC, 0x81, 0x82, 0x82, 0x84, 0x8C, 0x88, 0x90, 0x90, 0xA0, 0xB0,
  0xD0, 0x88, 0x88, 0x8C, 0x84, 0x86, 0x82, 0x83, 0x81, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0xF8, 0x80, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3A, 0x01, 0xD0, 0x16,
  0x80, 0xB2, 0x05, 0x90, 0x4C, 0x82, 0x64, 0x13, 0x10, 0x98, 0x88, 0xC4,
  0x46, 0x12, 0x30, 0xA1, 0x85, 0x0C, 0x18, 0x60, 0x82, 0x80, 0xE0, 0x70,
  0x34, 0x1A, 0x0D, 0x06, 0x43, 0x21, 0x88, 0xC4, 0x61, 0x30, 0x98, 0x4C,
  0x16, 0x0B, 0x03, 0x81, 0xC0, 0x60, 0x20, 0x0F, 0x02, 0x30, 0x81, 0x20,
  0x24, 0x06, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x02, 0x20, 0x46, 0x10, 0x7C, 0x00, 0xE0, 0x8C,
  0x82, 0x82, 0x81, 0x81, 0x81, 0x83, 0x82, 0x86, 0xFC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x02, 0x30, 0x81, 0x20, 0x24, 0x06,
  0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80,
  0x50, 0x0A, 0x02, 0x20, 0x46, 0x10, 0x7C, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x30, 0xE0, 0x9C, 0x82, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8,
  0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x81, 0x1E, 0x61, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x20, 0x18, 0x06, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xA0, 0x8F, 0x80, 0x80,
  0x60, 0x18, 0x09, 0x02, 0x40, 0x90, 0x24, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x03, 0x00, 0xC0, 0x80,
  0x80, 0xC0, 0x40, 0x50, 0x20, 0x28, 0x28, 0x24, 0x14, 0x12, 0x0A, 0x09,
  0x05, 0x04, 0x42, 0x82, 0x22, 0x22, 0x11, 0x11, 0x08, 0x88, 0x84, 0x44,
  0x41, 0x22, 0x40, 0xA0, 0xA0, 0x50, 0x50, 0x28, 0x28, 0x0C, 0x14, 0x06,
  0x0C, 0x02, 0x02, 0x00, 0x40, 0xA0, 0x88, 0x44, 0x62, 0x20, 0x90, 0x50,
  0x28, 0x0C, 0x04, 0x03, 0x02, 0x81, 0x41, 0x10, 0x88, 0x44, 0x41, 0x20,
  0xA0, 0x60, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x88, 0x48, 0x14,
  0x0A, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x20, 0x81, 0x03, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81, 0x02, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x87, 0xE0, 0x04, 0x01, 0x00, 0xA0, 0x48, 0x11, 0x0C, 0x42,
  0x09, 0x82, 0x40, 0x70, 0x10, 0xFF, 0xC0, 0x84, 0x21, 0x3C, 0x88, 0x08,
  0x10, 0x20, 0x47, 0xB1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x01, 0x02, 0x06, 0x07, 0xC0, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x3D, 0x63, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x43, 0x3D, 0x3C, 0x62, 0x42, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x61, 0x3E, 0x1C, 0xC2, 0x08, 0x20, 0x8F, 0x88, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3D, 0x63, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01,
  0x01, 0x01, 0x83, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x2F, 0x63, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xC7, 0xFF,
  0xE0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x21, 0x42, 0x89, 0x22, 0x45, 0x0D, 0x1A, 0x24,
  0x44, 0x89, 0x0A, 0x14, 0x30, 0xFF, 0xFF, 0xF0, 0xB8, 0xEC, 0x51, 0x86,
  0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82,
  0x18, 0x21, 0x82, 0x18, 0x21, 0xBD, 0x8F, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x3C, 0x31, 0x10, 0x48, 0x28, 0x14,
  0x0A, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x48, 0x24, 0x31, 0xF0, 0xBC, 0xC2,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x63, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xBE, 0x31, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x7F,
  0x18, 0x20, 0x81, 0x02, 0x06, 0x0C, 0x10, 0x41, 0x87, 0xE0, 0x44, 0x4F,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x70, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x6F, 0x40, 0x81, 0x81, 0x42, 0x42,
  0x42, 0x42, 0x24, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x18, 0x83, 0x05,
  0x0C, 0x24, 0x30, 0x90, 0xC2, 0x45, 0x09, 0x12, 0x42, 0x49, 0x09, 0x24,
  0x24, 0x90, 0xA1, 0x42, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x80, 0x41,
  0x42, 0x22, 0x24, 0x14, 0x14, 0x08, 0x18, 0x14, 0x34, 0x24, 0x22, 0x42,
  0xC1, 0xC1, 0x41, 0x41, 0x42, 0x22, 0x22, 0x22, 0x24, 0x14, 0x14, 0x14,
  0x18, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x30, 0xE0, 0xF8, 0x42, 0x21,
  0x08, 0x84, 0x62, 0x11, 0x08, 0x7C, 0x02, 0x18, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xC7, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0xC0, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x70, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x38, 0x00, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 7, 8, 2, -19 },
  { 8, 11, 19, 11, 0, -19 },
  { 35, 9, 22, 10, 1, -20 },
  { 60, 13, 19, 15, 1, -19 },
  { 91, 10, 19, 11, 1, -19 },
  { 115, 1, 7, 4, 2, -19 },
  { 116, 5, 23, 7, 1, -19 },
  { 131, 5, 23, 7, 1, -19 },
  { 146, 7, 7, 9, 1, -20 },
  { 153, 9, 12, 11, 1, -15 },
  { 167, 2, 6, 5, 1, -3 },
  { 169, 5, 1, 7, 1, -8 },
  { 170, 1, 2, 5, 2, -2 },
  { 171, 7, 19, 9, 1, -19 },
  { 188, 8, 19, 10, 1, -19 },
  { 207, 5, 19, 10, 2, -19 },
  { 219, 8, 19, 10, 1, -19 },
  { 238, 8, 19, 10, 1, -19 },
  { 257, 10, 19, 10, 0, -19 },
  { 281, 8, 19, 10, 1, -19 },
  { 300, 8, 19, 10, 1, -19 },
  { 319, 8, 19, 10, 1, -19 },
  { 338, 8, 19, 10, 1, -19 },
  { 357, 8, 19, 10, 1, -19 },
  { 376, 1, 14, 5, 2, -14 },
  { 378, 2, 17, 5, 1, -14 },
  { 383, 9, 11, 11, 1, -15 },
  { 396, 9, 6, 11, 1, -12 },
  { 403, 9, 11, 11, 1, -15 },
  { 416, 7, 19, 7, 0, -19 },
  { 433, 14, 21, 16, 1, -19 },
  { 470, 10, 19, 10, 0, -19 },
  { 494, 8, 19, 11, 2, -19 },
  { 513, 9, 19, 11, 1, -19 },
  { 535, 9, 19, 13, 2, -19 },
  { 557, 7, 19, 10, 2, -19 },
  { 574, 7, 19, 9, 2, -19 },
  { 591, 11, 19, 14, 1, -19 },
  { 618, 9, 19, 13, 2, -19 },
  { 640, 4, 19, 6, 1, -19 },
  { 650, 4, 24, 5, -1, -19 },
  { 662, 8, 19, 10, 2, -19 },
  { 681, 7, 19, 9, 2, -19 },
  { 698, 13, 19, 17, 2, -19 },
  { 729, 9, 19, 13, 2, -19 },
  { 751, 11, 19, 14, 1, -19 },
  { 778, 8, 19, 11, 2, -19 },
  { 797, 11, 23, 14, 1, -19 },
  { 829, 8, 19, 11, 2, -19 },
  { 848, 8, 19, 10, 1, -19 },
  { 867, 9, 19, 9, 0, -19 },
  { 889, 9, 19, 13, 2, -19 },
  { 911, 10, 19, 10, 0, -19 },
  { 935, 17, 19, 17, 0, -19 },
  { 976, 9, 19, 9, 0, -19 },
  { 998, 9, 19, 9, 0, -19 },
  { 1020, 7, 19, 9, 1, -19 },
  { 1037, 5, 23, 8, 2, -19 },
  { 1052, 7, 19, 9, 1, -19 },
  { 1069, 5, 23, 8, 1, -19 },
  { 1084, 10, 10, 11, 0, -19 },
  { 1097, 10, 1, 10, 0, 2 },
  { 1099, 4, 4, 6, 1, -20 },
  { 1101, 7, 14, 10, 1, -14 },
  { 1114, 8, 20, 11, 2, -20 },
  { 1134, 7, 14, 8, 1, -14 },
  { 1147, 8, 20, 11, 1, -20 },
  { 1167, 8, 14, 10, 1, -14 },
  { 1181, 6, 20, 6, 0, -20 },
  { 1196, 8, 20, 11, 1, -14 },
  { 1216, 7, 20, 11, 2, -20 },
  { 1234, 1, 19, 5, 2, -19 },
  { 1237, 3, 25, 5, 0, -19 },
  { 1247, 7, 20, 9, 2, -20 },
  { 1265, 1, 20, 5, 2, -20 },
  { 1268, 12, 14, 16, 2, -14 },
  { 1289, 7, 14, 11, 2, -14 },
  { 1302, 9, 14, 11, 1, -14 },
  { 1318, 8, 20, 11, 2, -14 },
  { 1338, 8, 20, 11, 1, -14 },
  { 1358, 5, 14, 7, 2, -14 },
  { 1367, 6, 14, 8, 1, -14 },
  { 1378, 4, 17, 6, 1, -17 },
  { 1387, 7, 14, 11, 2, -14 },
  { 1400, 8, 14, 8, 0, -14 },
  { 1414, 14, 14, 14, 0, -14 },
  { 1439, 8, 14, 8, 0, -14 },
  { 1453, 8, 20, 9, 0, -14 },
  { 1473, 5, 14, 7, 1, -14 },
  { 1482, 7, 23, 9, 1, -19 },
  { 1503, 1, 26, 10, 4, -20 },
  { 1507, 7, 23, 9, 1, -19 },
  { 1528, 9, 2, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT26PT7B_H_
