#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFA, 0x00, 0xFC, 0xC3, 0x85, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x84, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20,
  0x80, 0x43, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x7F, 0xFE, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x10,
  0x41, 0xFF, 0xF8, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x30,
  0x18, 0x60, 0x30, 0xC0, 0x41, 0x00, 0x82, 0x00, 0x02, 0x00, 0x10, 0x01,
  0xC0, 0x3F, 0xE3, 0x23, 0x31, 0x01, 0x08, 0x18, 0x40, 0xC2, 0x06, 0x10,
  0x30, 0x80, 0x84, 0x06, 0x20, 0x1D, 0x00, 0x38, 0x00, 0xE0, 0x02, 0xC0,
  0x13, 0x00, 0x8C, 0x04, 0x30, 0x20, 0x81, 0x04, 0x08, 0x20, 0x43, 0x02,
  0x14, 0x11, 0xBE, 0xF8, 0x3F, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x0F, 0x80, 0x81, 0x10, 0x10, 0x63, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x86, 0x04, 0x10, 0x80, 0x82, 0x10, 0x10, 0x46, 0x02, 0x08,
  0x80, 0x41, 0x11, 0x88, 0x26, 0x79, 0x04, 0x91, 0xB1, 0x92, 0x12, 0x26,
  0xC2, 0x7C, 0x98, 0x62, 0x12, 0x0C, 0x06, 0x41, 0x80, 0x88, 0x30, 0x11,
  0x06, 0x06, 0x20, 0xC0, 0x86, 0x18, 0x10, 0xC3, 0x06, 0x08, 0x40, 0x81,
  0x08, 0x10, 0x33, 0x06, 0x03, 0xC0, 0x04, 0x00, 0x3C, 0x01, 0x18, 0x04,
  0x20, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x10, 0x80, 0x42, 0x01,
  0x98, 0x02, 0x40, 0x0E, 0x00, 0x30, 0x01, 0xE0, 0x0C, 0x80, 0x63, 0x0D,
  0x04, 0x24, 0x18, 0xB0, 0x22, 0xC0, 0x4B, 0x01, 0xEC, 0x03, 0x30, 0x0C,
  0x40, 0x71, 0x81, 0x63, 0x1C, 0xC7, 0xC1, 0xF5, 0x55, 0x50, 0x06, 0x18,
  0x20, 0x83, 0x06, 0x08, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x81, 0x03,
  0x02, 0x06, 0x06, 0xC0, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x06, 0x04, 0x08,
  0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x30, 0xC0, 0x08, 0x02, 0x00, 0x82,
  0x21, 0xEB, 0xC7, 0x01, 0xC0, 0x48, 0x23, 0x10, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x33, 0x32, 0x26, 0x44, 0xC0, 0xFF, 0x7D, 0x80, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x00, 0x04,
  0x03, 0xE0, 0xC2, 0x30, 0x66, 0x04, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x1A, 0x03, 0x60, 0x44, 0x18, 0xC6,
  0x0F, 0x80, 0x06, 0x3C, 0xDB, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x02, 0x03, 0xF8, 0x60, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0x06, 0x03, 0xF8, 0xE0,
  0xE4, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC1, 0xF0, 0x1F, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x06, 0x40,
  0xE7, 0xF8, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x58, 0x01, 0x60, 0x0D,
  0x80, 0x26, 0x01, 0x98, 0x04, 0x60, 0x31, 0x80, 0x86, 0x06, 0x18, 0x10,
  0x60, 0xC1, 0x82, 0x06, 0x18, 0x18, 0x40, 0x63, 0x01, 0x88, 0x06, 0x3F,
  0xFF, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x7F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xF0, 0xC1, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0xC8, 0x18, 0xFF, 0x00, 0x0F, 0xC1, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x87, 0x09,
  0xF8, 0xA0, 0xCC, 0x06, 0xC0, 0x2C, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x02, 0x40, 0x24, 0x06, 0x60, 0x43, 0x0C, 0x1F, 0x80,
  0x40, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x00, 0x1F, 0xC1, 0x83, 0x08, 0x0C, 0xC0, 0x26, 0x01, 0x20,
  0x09, 0x80, 0x4C, 0x02, 0x20, 0x31, 0x81, 0x06, 0x10, 0x1B, 0x00, 0x70,
  0x06, 0xC0, 0x63, 0x06, 0x0C, 0x60, 0x32, 0x00, 0x90, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0D, 0x00, 0x68, 0x02, 0x60, 0x31, 0x83, 0x07, 0xF0, 0x02,
  0x01, 0xF8, 0x30, 0xC2, 0x06, 0x60, 0x24, 0x03, 0x40, 0x34, 0x01, 0xC0,
  0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x36, 0x03, 0x60, 0x33, 0x05, 0x1F,
  0x90, 0x61, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x01, 0x83, 0xF0, 0x7D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xB0, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x32, 0x26,
  0x44, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x00, 0x10, 0x7F, 0x20, 0xC0, 0x60,
  0x10, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x20,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x0C, 0x06, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0C, 0x00,
  0xC3, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x13, 0x01, 0x83, 0x40, 0xF8,
  0x28, 0x31, 0x07, 0x0C, 0x20, 0xE1, 0x04, 0x1C, 0x20, 0x83, 0x04, 0x10,
  0x60, 0x82, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x30, 0x43, 0x06, 0x08, 0x60,
  0xE1, 0x0C, 0x3C, 0x33, 0xC5, 0x83, 0xCF, 0x90, 0x30, 0xC2, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x40,
  0x0F, 0xF0, 0x00, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x6C,
  0x00, 0x98, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x18, 0xC0, 0x20, 0x80,
  0x41, 0x01, 0x82, 0x03, 0x06, 0x04, 0x0C, 0x0F, 0xF8, 0x1F, 0xF0, 0x60,
  0x30, 0xC0, 0x61, 0x00, 0x42, 0x00, 0x8C, 0x01, 0x98, 0x03, 0x20, 0x02,
  0x40, 0x05, 0x80, 0x0F, 0x00, 0x18, 0xFF, 0x88, 0x1C, 0x80, 0x68, 0x02,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x68, 0x0C,
  0xFF, 0x08, 0x3C, 0x80, 0x68, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x02, 0x80, 0x68, 0x3C, 0xFF, 0x00, 0x00,
  0x80, 0x3F, 0xC3, 0x02, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x82, 0x0F, 0xF0, 0xFF, 0x04, 0x1E,
  0x20, 0x19, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0xD0, 0x0C,
  0x80, 0xC4, 0x1C, 0x3F, 0x80, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xEF, 0xFA, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x00, 0x60, 0x03, 0xFC, 0x0E, 0x07, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03, 0x20,
  0x03, 0x30, 0x03, 0x18, 0x03, 0x0E, 0x07, 0x03, 0xFE, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x4F, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0xF8, 0xE0, 0x80, 0x38, 0x06, 0x80,
  0xC8, 0x08, 0x81, 0x88, 0x10, 0x83, 0x08, 0x60, 0x86, 0x08, 0xC0, 0x88,
  0x09, 0x80, 0xB8, 0x0A, 0x80, 0xEC, 0x0C, 0x40, 0x86, 0x08, 0x20, 0x83,
  0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x02, 0x80,
  0x30, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xD0, 0x00, 0x7A, 0x00, 0x0B, 0x60,
  0x01, 0x64, 0x00, 0x6C, 0x80, 0x09, 0x98, 0x01, 0x31, 0x00, 0x66, 0x20,
  0x08, 0xC4, 0x01, 0x18, 0xC0, 0x63, 0x08, 0x0C, 0x61, 0x01, 0x0C, 0x30,
  0x21, 0x82, 0x0C, 0x30, 0x41, 0x06, 0x0C, 0x20, 0xC1, 0x8C, 0x18, 0x11,
  0x03, 0x03, 0x20, 0x60, 0x6C, 0x0C, 0x05, 0x81, 0x80, 0xA0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x80, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xE8, 0x03, 0xB0,
  0x0E, 0x40, 0x39, 0x80, 0xE2, 0x03, 0x88, 0x0E, 0x30, 0x38, 0x40, 0xE1,
  0x83, 0x82, 0x0E, 0x0C, 0x38, 0x10, 0xE0, 0x63, 0x81, 0x8E, 0x02, 0x38,
  0x0C, 0xE0, 0x13, 0x80, 0x6E, 0x00, 0xB8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xF0, 0x18, 0x38, 0x30, 0x08,
  0x20, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x30, 0x08, 0x1C, 0x38, 0x0F, 0xE0,
  0xFF, 0x10, 0x72, 0x03, 0x40, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x0D, 0x03, 0x3F, 0xC7, 0x80, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xE0, 0x18, 0x38, 0x30, 0x08, 0x20, 0x0C,
  0x60, 0x04, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x30, 0x0C, 0x30, 0x08, 0x1C, 0x30, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0xFF, 0x08,
  0x38, 0x80, 0xC8, 0x06, 0x80, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x06, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x78, 0xFE, 0x08, 0x60, 0x82, 0x08,
  0x30, 0x81, 0x08, 0x18, 0x80, 0x88, 0x0C, 0x80, 0xC8, 0x04, 0x80, 0x68,
  0x02, 0x80, 0x30, 0x02, 0x03, 0xFD, 0xC0, 0xA0, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x1A, 0x06, 0x7F, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x02, 0x60, 0x31, 0x83, 0x07, 0xF0, 0xC0, 0x07,
  0x00, 0x14, 0x00, 0xD0, 0x03, 0x60, 0x09, 0x80, 0x22, 0x01, 0x88, 0x06,
  0x20, 0x10, 0xC0, 0x43, 0x01, 0x04, 0x0C, 0x10, 0x30, 0x60, 0x81, 0x82,
  0x02, 0x18, 0x08, 0x60, 0x31, 0x00, 0xC4, 0x01, 0x30, 0x04, 0xC0, 0x12,
  0x00, 0x68, 0x00, 0xA0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x08,
  0x01, 0xA0, 0x0E, 0x00, 0xD0, 0x07, 0x00, 0x48, 0x02, 0x80, 0x26, 0x01,
  0x40, 0x33, 0x00, 0xA0, 0x18, 0x80, 0xD8, 0x0C, 0x40, 0x6C, 0x04, 0x20,
  0x32, 0x02, 0x18, 0x11, 0x03, 0x0C, 0x08, 0x81, 0x82, 0x04, 0x60, 0x81,
  0x06, 0x30, 0x40, 0xC3, 0x08, 0x20, 0x61, 0x04, 0x30, 0x30, 0x82, 0x18,
  0x08, 0x41, 0x88, 0x04, 0x60, 0xC4, 0x03, 0x30, 0x26, 0x01, 0x90, 0x13,
  0x00, 0x48, 0x09, 0x80, 0x24, 0x04, 0x80, 0x16, 0x03, 0x40, 0x0F, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x19, 0x00, 0x8C, 0x0C, 0x20, 0x41, 0x06, 0x0C, 0x30, 0x21, 0x01, 0x18,
  0x0C, 0x80, 0x24, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xB0, 0x04, 0x80, 0x64, 0x02, 0x30, 0x30, 0x81, 0x04, 0x08, 0x30, 0xC0,
  0x84, 0x06, 0x60, 0x32, 0x00, 0xB0, 0x06, 0xC0, 0x1A, 0x00, 0x90, 0x0C,
  0xC0, 0x42, 0x02, 0x10, 0x30, 0xC1, 0x02, 0x08, 0x10, 0xC0, 0xC4, 0x02,
  0x20, 0x13, 0x00, 0xD0, 0x02, 0x80, 0x1C, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0xFF, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0xC0, 0x08,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x03, 0x00, 0x0C,
  0x00, 0x58, 0x01, 0x20, 0x08, 0xC0, 0x21, 0x01, 0x06, 0x04, 0x08, 0x30,
  0x31, 0x80, 0xC6, 0x01, 0x30, 0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC6, 0x18, 0x61, 0x04, 0x3F, 0x84, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x01, 0xE3, 0xFC, 0xC1, 0xB0, 0x34, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x40, 0x68, 0x15, 0x86, 0x9F, 0x90, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xF8, 0xB0,
  0xCA, 0x04, 0xC0, 0x6C, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0xC0, 0x2C, 0x06, 0xA0,
  0x4B, 0x0C, 0x9F, 0x80, 0x1F, 0x98, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x23, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x31, 0xF3, 0x30, 0xB6, 0x07, 0x40, 0x7C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x34, 0x07, 0x60, 0x53, 0x09, 0x1F, 0x10, 0x1F,
  0x04, 0x11, 0x83, 0x20, 0x2C, 0x07, 0x80, 0xE0, 0x0C, 0x01, 0x80, 0x3F,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC1, 0x0F, 0xE0, 0x07, 0x86, 0x46, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x7F, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x1F, 0x93, 0x0F, 0x60, 0x74, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03,
  0x40, 0x76, 0x07, 0x30, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x6C, 0x1C, 0x7F, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x27, 0xEB, 0x1B, 0x83, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x5D, 0x80, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x11, 0xCE, 0x00, 0x00,
  0x00, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x8C, 0x6E, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x68, 0x12, 0x0C, 0x86,
  0x21, 0x08, 0xC2, 0x20, 0x98, 0x2E, 0x0A, 0x83, 0x30, 0xC4, 0x21, 0x88,
  0x22, 0x08, 0x83, 0x20, 0x48, 0x1A, 0x02, 0x80, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x9F, 0x1F, 0x28, 0x6C, 0x6C, 0x0A, 0x0F, 0x03, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x9F, 0xAC,
  0x2E, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1F,
  0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x2C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x02, 0x40,
  0x26, 0x06, 0x30, 0xC1, 0xF8, 0x9F, 0x8B, 0x0C, 0xA0, 0x4C, 0x06, 0xC0,
  0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x02, 0x80, 0x2C, 0x02, 0xC0, 0x6A, 0x04, 0xB0, 0xC9, 0xF8, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x1F, 0x93, 0x09, 0x60, 0x74, 0x07, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C,
  0x03, 0x40, 0x76, 0x07, 0x30, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x9F, 0x62, 0x86,
  0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x00, 0x3F, 0xD8, 0x24, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x2C, 0x19, 0xFC, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x18, 0x1E, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xF0,
  0x56, 0x35, 0xF9, 0xC0, 0x34, 0x02, 0x40, 0x64, 0x06, 0x60, 0x42, 0x04,
  0x20, 0x42, 0x0C, 0x30, 0x83, 0x08, 0x10, 0x81, 0x18, 0x19, 0x81, 0x90,
  0x09, 0x00, 0xB0, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60, 0xC0, 0x60, 0x34,
  0x06, 0x02, 0x40, 0x70, 0x26, 0x07, 0x02, 0x60, 0xD0, 0x62, 0x0D, 0x06,
  0x20, 0x90, 0x42, 0x09, 0x84, 0x30, 0x98, 0x41, 0x18, 0x8C, 0x11, 0x08,
  0x81, 0x10, 0x88, 0x19, 0x0C, 0x81, 0xB0, 0x58, 0x0B, 0x05, 0x80, 0xA0,
  0x50, 0x0A, 0x05, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0x60, 0x30, 0xC0,
  0x68, 0x19, 0x82, 0x10, 0xC3, 0x18, 0x22, 0x04, 0xC0, 0xD0, 0x0E, 0x01,
  0x80, 0x30, 0x07, 0x01, 0xA0, 0x26, 0x0C, 0x41, 0x0C, 0x60, 0x88, 0x1B,
  0x01, 0x40, 0x30, 0x40, 0x16, 0x03, 0x60, 0x22, 0x02, 0x20, 0x23, 0x06,
  0x30, 0x41, 0x04, 0x10, 0x41, 0x8C, 0x18, 0x80, 0x88, 0x08, 0x80, 0xD8,
  0x0D, 0x00, 0x50, 0x05, 0x00, 0x70, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x09, 0x80, 0xF0, 0x00, 0x7F,
  0x01, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30,
  0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xFF, 0x03, 0x83, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x60, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x1C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x01, 0x83, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0xE0, 0xE0, 0x00, 0x7C, 0x0E, 0x38, 0x60, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 7, 10, 12, 2, -27 },
  { 17, 15, 27, 16, 1, -27 },
  { 68, 13, 31, 15, 1, -29 },
  { 119, 19, 28, 22, 2, -28 },
  { 186, 14, 28, 15, 1, -28 },
  { 235, 2, 10, 7, 2, -27 },
  { 238, 7, 33, 10, 2, -27 },
  { 267, 7, 33, 10, 1, -27 },
  { 296, 10, 10, 13, 2, -29 },
  { 309, 13, 17, 15, 1, -22 },
  { 337, 4, 9, 7, 1, -4 },
  { 342, 8, 1, 10, 1, -11 },
  { 343, 3, 3, 7, 2, -3 },
  { 345, 11, 27, 13, 1, -27 },
  { 383, 11, 28, 15, 2, -28 },
  { 422, 7, 27, 15, 3, -27 },
  { 446, 12, 28, 15, 1, -28 },
  { 488, 12, 28, 15, 1, -28 },
  { 530, 14, 27, 15, 1, -27 },
  { 578, 12, 27, 15, 2, -27 },
  { 619, 12, 28, 15, 2, -27 },
  { 661, 11, 27, 15, 2, -27 },
  { 699, 13, 27, 15, 1, -27 },
  { 743, 12, 28, 15, 1, -28 },
  { 785, 3, 20, 7, 2, -20 },
  { 793, 4, 25, 7, 1, -20 },
  { 806, 13, 15, 15, 1, -21 },
  { 831, 13, 9, 15, 1, -18 },
  { 846, 13, 15, 15, 1, -21 },
  { 871, 9, 28, 10, 1, -28 },
  { 903, 19, 30, 23, 2, -27 },
  { 975, 15, 27, 15, 0, -27 },
  { 1026, 12, 27, 17, 3, -27 },
  { 1067, 13, 28, 16, 2, -28 },
  { 1113, 13, 27, 18, 3, -27 },
  { 1157, 10, 27, 15, 3, -27 },
  { 1191, 10, 27, 14, 3, -27 },
  { 1225, 16, 28, 20, 2, -28 },
  { 1281, 13, 27, 19, 3, -27 },
  { 1325, 6, 27, 9, 1, -27 },
  { 1346, 7, 34, 7, -2, -27 },
  { 1376, 12, 27, 15, 3, -27 },
  { 1417, 10, 27, 13, 3, -27 },
  { 1451, 19, 27, 25, 3, -27 },
  { 1516, 14, 27, 20, 3, -27 },
  { 1564, 16, 28, 20, 2, -28 },
  { 1620, 11, 27, 15, 3, -27 },
  { 1658, 16, 34, 20, 2, -28 },
  { 1726, 12, 27, 16, 3, -27 },
  { 1767, 11, 28, 15, 2, -28 },
  { 1806, 13, 27, 13, 0, -27 },
  { 1850, 13, 27, 19, 3, -27 },
  { 1894, 14, 27, 14, 0, -27 },
  { 1942, 25, 27, 25, 0, -27 },
  { 2027, 13, 27, 13, 0, -27 },
  { 2071, 13, 27, 13, 0, -27 },
  { 2115, 11, 27, 13, 1, -27 },
  { 2153, 7, 33, 12, 3, -27 },
  { 2182, 11, 27, 13, 1, -27 },
  { 2220, 8, 33, 12, 1, -27 },
  { 2253, 14, 13, 15, 1, -27 },
  { 2276, 15, 2, 15, 0, 3 },
  { 2280, 5, 6, 9, 2, -29 },
  { 2284, 11, 20, 14, 1, -20 },
  { 2312, 12, 29, 16, 3, -29 },
  { 2356, 9, 20, 12, 2, -20 },
  { 2379, 12, 29, 16, 2, -29 },
  { 2423, 11, 20, 15, 2, -20 },
  { 2451, 9, 29, 8, 0, -29 },
  { 2484, 12, 29, 16, 2, -20 },
  { 2528, 10, 29, 16, 3, -29 },
  { 2565, 3, 28, 7, 2, -28 },
  { 2576, 5, 37, 7, 0, -28 },
  { 2600, 10, 29, 13, 3, -29 },
  { 2637, 1, 29, 7, 3, -29 },
  { 2641, 18, 20, 24, 3, -20 },
  { 2686, 10, 20, 16, 3, -20 },
  { 2711, 12, 20, 16, 2, -20 },
  { 2741, 12, 29, 16, 3, -20 },
  { 2785, 12, 29, 16, 2, -20 },
  { 2829, 7, 20, 10, 3, -20 },
  { 2847, 10, 20, 12, 1, -20 },
  { 2872, 7, 25, 8, 1, -25 },
  { 2894, 10, 20, 16, 3, -20 },
  { 2919, 12, 20, 12, 0, -20 },
  { 2949, 20, 20, 20, 0, -20 },
  { 2999, 11, 20, 12, 1, -20 },
  { 3027, 12, 29, 12, 0, -20 },
  { 3071, 8, 20, 10, 1, -20 },
  { 3091, 9, 33, 13, 2, -27 },
  { 3129, 1, 38, 15, 7, -29 },
  { 3134, 9, 33, 13, 2, -27 },
  { 3172, 13, 3, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT38PT7B_H_
