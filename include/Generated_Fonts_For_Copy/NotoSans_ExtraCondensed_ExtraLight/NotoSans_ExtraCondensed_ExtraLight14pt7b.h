#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xFF, 0x28, 0xA2, 0x9F, 0x49, 0x2F, 0x94, 0x51, 0x40,
  0x23, 0xE9, 0x4A, 0x30, 0x45, 0x2D, 0x5C, 0x40, 0xC9, 0x52, 0xC5, 0x8B,
  0xDD, 0x4A, 0x95, 0x4A, 0x98, 0x71, 0x45, 0x14, 0x21, 0x89, 0x66, 0x89,
  0xD0, 0xF0, 0x5A, 0xAA, 0xA9, 0xA5, 0x55, 0x5A, 0x4B, 0xD0, 0x21, 0x09,
  0xF2, 0x10, 0xE0, 0xE0, 0x80, 0x11, 0x12, 0x22, 0x44, 0x48, 0xE9, 0x99,
  0x99, 0x99, 0x96, 0x74, 0x92, 0x49, 0x24, 0xE1, 0x11, 0x12, 0x44, 0x8F,
  0xE1, 0x11, 0x62, 0x11, 0x1E, 0x10, 0x8C, 0x65, 0x2A, 0x5F, 0x10, 0x80,
  0xE8, 0x88, 0xE1, 0x11, 0x1E, 0x78, 0x88, 0xE9, 0x99, 0x9E, 0xF1, 0x12,
  0x22, 0x44, 0x48, 0x72, 0x52, 0x93, 0x2A, 0x31, 0x8B, 0x80, 0xE9, 0x99,
  0x9F, 0x11, 0x2E, 0x82, 0x83, 0x80, 0x09, 0xB0, 0x83, 0x04, 0xF8, 0x01,
  0xF0, 0xC1, 0x06, 0x32, 0x60, 0xE1, 0x12, 0x24, 0x44, 0x04, 0x38, 0x8A,
  0x0D, 0xDA, 0xB5, 0x6A, 0xD5, 0x95, 0x01, 0xE0, 0x21, 0x0C, 0xA5, 0x3D,
  0x31, 0x8C, 0x40, 0xF4, 0x63, 0x2F, 0x4A, 0x31, 0x8F, 0x80, 0x7C, 0x21,
  0x08, 0x42, 0x10, 0x83, 0xC0, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0x80,
  0xF8, 0x88, 0xF8, 0x88, 0x8F, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x7A, 0x08,
  0x20, 0x82, 0x78, 0x61, 0x85, 0xF0, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x8C,
  0x40, 0xEA, 0xAA, 0xB0, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x94, 0xA9, 0x4C,
  0x52, 0x94, 0x94, 0xC0, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x83, 0x07, 0x1E,
  0x3C, 0x74, 0xEA, 0xD5, 0x93, 0x24, 0x8C, 0x73, 0x9A, 0xD6, 0x73, 0x8C,
  0x40, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xC0, 0xE9, 0x99, 0x9E,
  0x88, 0x88, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xC1, 0x02, 0xE4,
  0xA5, 0x29, 0x72, 0x92, 0x94, 0x40, 0xF8, 0x88, 0x42, 0x11, 0x1E, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8B,
  0x80, 0x8C, 0x62, 0x94, 0xA9, 0x4A, 0x21, 0x00, 0x88, 0xC4, 0x62, 0x2A,
  0x95, 0x52, 0xA9, 0x54, 0xA6, 0x22, 0x11, 0x00, 0x8A, 0x94, 0xA2, 0x11,
  0x4A, 0x94, 0x40, 0x8C, 0x94, 0xA6, 0x10, 0x84, 0x21, 0x00, 0x71, 0x12,
  0x22, 0x44, 0x4F, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x84, 0x44, 0x22, 0x21,
  0x11, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x21, 0x92, 0x98, 0x80, 0xFC, 0xA4,
  0xC4, 0x9F, 0x6F, 0x88, 0x8E, 0x99, 0x99, 0x99, 0xF0, 0x72, 0x49, 0x27,
  0x11, 0x17, 0x99, 0x99, 0x99, 0xF0, 0x69, 0x99, 0xE8, 0x8F, 0x29, 0x74,
  0x92, 0x49, 0x00, 0x69, 0x99, 0x99, 0x9F, 0x11, 0xF0, 0x88, 0x8E, 0x99,
  0x99, 0x99, 0x90, 0x9F, 0xC0, 0x41, 0x55, 0x55, 0xC0, 0x88, 0x89, 0xAA,
  0xCC, 0xAA, 0x90, 0xFF, 0xE0, 0x6D, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9,
  0x69, 0x99, 0x99, 0x99, 0x69, 0x99, 0x99, 0x9E, 0x69, 0x99, 0x99, 0x9F,
  0x88, 0x80, 0x69, 0x99, 0x99, 0x9F, 0x11, 0x10, 0x72, 0x49, 0x24, 0x78,
  0x84, 0x21, 0x1F, 0x5D, 0x24, 0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x99,
  0x55, 0x66, 0x20, 0x93, 0x25, 0x6B, 0x56, 0xCC, 0x89, 0x00, 0xD5, 0x22,
  0x65, 0x90, 0x99, 0x55, 0x62, 0x22, 0x4C, 0x64, 0xA4, 0xB8, 0x29, 0x24,
  0xA2, 0x49, 0x30, 0xFF, 0xFC, 0x89, 0x24, 0x9A, 0x49, 0x60, 0x6C, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 4, 4, 1, -10 },
  { 4, 6, 10, 6, 0, -10 },
  { 12, 5, 12, 6, 0, -11 },
  { 20, 7, 10, 8, 1, -10 },
  { 29, 6, 10, 6, 0, -10 },
  { 37, 1, 4, 2, 1, -10 },
  { 38, 2, 12, 4, 1, -10 },
  { 41, 2, 12, 4, 1, -10 },
  { 44, 3, 4, 5, 1, -11 },
  { 46, 5, 6, 6, 0, -8 },
  { 50, 1, 3, 3, 1, -1 },
  { 51, 3, 1, 4, 0, -4 },
  { 52, 1, 1, 3, 1, -1 },
  { 53, 4, 10, 5, 0, -10 },
  { 58, 4, 10, 6, 1, -10 },
  { 63, 3, 10, 6, 1, -10 },
  { 67, 4, 10, 6, 1, -10 },
  { 72, 4, 10, 6, 1, -10 },
  { 77, 5, 10, 6, 0, -10 },
  { 84, 4, 10, 6, 1, -10 },
  { 89, 4, 10, 6, 1, -10 },
  { 94, 4, 10, 6, 1, -10 },
  { 99, 5, 10, 6, 0, -10 },
  { 106, 4, 10, 6, 1, -10 },
  { 111, 1, 7, 3, 1, -7 },
  { 112, 1, 9, 3, 1, -7 },
  { 114, 5, 6, 6, 0, -8 },
  { 118, 5, 4, 6, 0, -7 },
  { 121, 5, 6, 6, 0, -8 },
  { 125, 4, 10, 4, 0, -10 },
  { 130, 7, 11, 9, 1, -10 },
  { 140, 5, 10, 5, 0, -10 },
  { 147, 5, 10, 6, 1, -10 },
  { 154, 5, 10, 6, 1, -10 },
  { 161, 5, 10, 7, 1, -10 },
  { 168, 4, 10, 5, 1, -10 },
  { 173, 4, 10, 5, 1, -10 },
  { 178, 6, 10, 7, 1, -10 },
  { 186, 5, 10, 7, 1, -10 },
  { 193, 2, 10, 3, 1, -10 },
  { 196, 3, 13, 3, -1, -10 },
  { 201, 5, 10, 6, 1, -10 },
  { 208, 4, 10, 5, 1, -10 },
  { 213, 7, 10, 9, 1, -10 },
  { 222, 5, 10, 7, 1, -10 },
  { 229, 6, 10, 7, 1, -10 },
  { 237, 4, 10, 6, 1, -10 },
  { 242, 6, 12, 7, 1, -10 },
  { 251, 5, 10, 6, 1, -10 },
  { 258, 4, 10, 6, 1, -10 },
  { 263, 5, 10, 5, 0, -10 },
  { 270, 5, 10, 7, 1, -10 },
  { 277, 5, 10, 5, 0, -10 },
  { 284, 9, 10, 9, 0, -10 },
  { 296, 5, 10, 5, 0, -10 },
  { 303, 5, 10, 5, 0, -10 },
  { 310, 4, 10, 5, 0, -10 },
  { 315, 3, 12, 4, 1, -10 },
  { 320, 4, 10, 5, 0, -10 },
  { 325, 3, 12, 4, 0, -10 },
  { 330, 5, 5, 6, 0, -10 },
  { 334, 6, 1, 6, 0, 1 },
  { 335, 2, 3, 3, 1, -11 },
  { 336, 3, 8, 5, 1, -8 },
  { 339, 4, 11, 6, 1, -11 },
  { 345, 3, 8, 4, 1, -8 },
  { 348, 4, 11, 6, 1, -11 },
  { 354, 4, 8, 5, 1, -8 },
  { 358, 3, 11, 3, 0, -11 },
  { 363, 4, 11, 6, 1, -8 },
  { 369, 4, 11, 6, 1, -11 },
  { 375, 1, 10, 3, 1, -10 },
  { 377, 2, 13, 3, 0, -10 },
  { 381, 4, 11, 5, 1, -11 },
  { 387, 1, 11, 2, 1, -11 },
  { 389, 7, 8, 9, 1, -8 },
  { 396, 4, 8, 6, 1, -8 },
  { 400, 4, 8, 6, 1, -8 },
  { 404, 4, 11, 6, 1, -8 },
  { 410, 4, 11, 6, 1, -8 },
  { 416, 3, 8, 4, 1, -8 },
  { 419, 4, 8, 4, 0, -8 },
  { 423, 3, 9, 3, 0, -9 },
  { 427, 4, 7, 6, 1, -7 },
  { 431, 4, 7, 4, 0, -7 },
  { 435, 7, 7, 7, 0, -7 },
  { 442, 4, 7, 5, 0, -7 },
  { 446, 4, 10, 5, 0, -7 },
  { 451, 3, 7, 4, 0, -7 },
  { 454, 3, 12, 5, 1, -10 },
  { 459, 1, 14, 5, 2, -11 },
  { 461, 3, 12, 5, 1, -10 },
  { 466, 5, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT14PT7B_H_
