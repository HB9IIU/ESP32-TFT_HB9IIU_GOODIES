#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x0F,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83,
  0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x30,
  0x60, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x08, 0x3F, 0xFF, 0xC1, 0x02, 0x00,
  0x81, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x10,
  0x04, 0x08, 0x02, 0x04, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x41, 0x80, 0x60,
  0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01,
  0x02, 0x00, 0x81, 0x00, 0xC1, 0x80, 0x01, 0x00, 0x02, 0x00, 0x1F, 0x80,
  0xFF, 0xE3, 0x90, 0xCC, 0x20, 0x18, 0x40, 0x20, 0x80, 0xC1, 0x01, 0x82,
  0x03, 0x04, 0x02, 0x08, 0x06, 0x10, 0x0C, 0x20, 0x0E, 0x40, 0x0E, 0x80,
  0x07, 0x00, 0x03, 0x80, 0x05, 0xC0, 0x08, 0xC0, 0x10, 0xC0, 0x20, 0xC0,
  0x41, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x18, 0x08, 0x30, 0x10,
  0xCC, 0x23, 0x1F, 0xFC, 0x07, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x1C, 0x00, 0x00, 0xD8, 0x06, 0x06, 0x30, 0x10, 0x10, 0x40,
  0xC0, 0xC1, 0x03, 0x03, 0x06, 0x08, 0x0C, 0x18, 0x60, 0x20, 0x61, 0x80,
  0x81, 0x84, 0x02, 0x06, 0x30, 0x08, 0x18, 0xC0, 0x20, 0x62, 0x00, 0x81,
  0x88, 0x03, 0x06, 0x63, 0xCC, 0x11, 0x11, 0xB0, 0x44, 0xC2, 0x43, 0x32,
  0x09, 0x8C, 0x88, 0x33, 0xE2, 0x60, 0xC7, 0x19, 0x83, 0x00, 0x46, 0x04,
  0x01, 0x18, 0x10, 0x0C, 0x60, 0x40, 0x21, 0x81, 0x00, 0x86, 0x04, 0x06,
  0x18, 0x30, 0x10, 0x60, 0xC0, 0x40, 0x83, 0x03, 0x02, 0x08, 0x08, 0x0C,
  0x20, 0x20, 0x11, 0x81, 0x80, 0x7C, 0x07, 0x80, 0x07, 0xE0, 0x06, 0x18,
  0x03, 0x0C, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10,
  0x20, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x08, 0x00, 0xCC, 0x00, 0x2C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x0C, 0x80, 0x0C, 0x60, 0xCC, 0x18,
  0x66, 0x04, 0x32, 0x03, 0x1B, 0x00, 0x89, 0x80, 0x6C, 0xC0, 0x16, 0x60,
  0x0E, 0x10, 0x03, 0x08, 0x03, 0x86, 0x01, 0xE3, 0x01, 0x90, 0xE3, 0x8C,
  0x3F, 0x83, 0xFF, 0xFF, 0xFC, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x03, 0xC0, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x06, 0x00, 0x40,
  0x04, 0x08, 0x42, 0xF4, 0xF1, 0xF8, 0x06, 0x00, 0xB0, 0x19, 0x83, 0x08,
  0x60, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x26, 0x66, 0x44,
  0xC8, 0x80, 0xFF, 0xFF, 0xF0, 0xDF, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x7F, 0x01, 0x86, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0x46, 0x01, 0x90, 0x06,
  0x40, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00,
  0x2C, 0x00, 0xB0, 0x02, 0x40, 0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x30,
  0x30, 0xC0, 0x81, 0xCE, 0x03, 0xF0, 0x03, 0x0F, 0x1F, 0x3B, 0x73, 0xC3,
  0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x0F, 0x01, 0xFF, 0x0E, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xFE,
  0x38, 0x19, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x07, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x1B, 0x83, 0x8F,
  0xF8, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0x50, 0x00,
  0xD0, 0x00, 0x90, 0x01, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x06,
  0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x10, 0x30,
  0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0xC0, 0x10, 0xC0, 0x10, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x5F, 0x83, 0xFF, 0x84, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x80, 0x73, 0x83, 0x87, 0xF8, 0x00,
  0x01, 0xE0, 0x1F, 0xC0, 0xE0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x3F,
  0x0D, 0xC7, 0x3C, 0x0C, 0xE0, 0x1B, 0x80, 0x6C, 0x00, 0xB0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0x98,
  0x06, 0x60, 0x18, 0xC0, 0xC1, 0x87, 0x03, 0xF0, 0x03, 0x00, 0xFF, 0xF8,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x2C,
  0x00, 0xB0, 0x02, 0xC0, 0x09, 0x00, 0x66, 0x01, 0x98, 0x0C, 0x30, 0x70,
  0x63, 0x80, 0xF8, 0x01, 0xC0, 0x0D, 0xC0, 0x61, 0x83, 0x03, 0x18, 0x06,
  0xC0, 0x1B, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x19, 0x80, 0x63, 0x87, 0x07, 0xF0, 0x0F, 0x00, 0xFE,
  0x0C, 0x18, 0xC0, 0x64, 0x03, 0x60, 0x0B, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x60,
  0x2B, 0x03, 0x4F, 0xF2, 0x1F, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x61, 0x0E, 0x0F,
  0xE0, 0x5F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xBE, 0x27, 0x77,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x66, 0x64, 0x4C,
  0x88, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x3C, 0x3F, 0xC8, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x01, 0xFE,
  0x00, 0x0E, 0x07, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x02,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x40, 0x18, 0x19,
  0x81, 0xFC, 0x13, 0x02, 0x18, 0x24, 0x0C, 0x30, 0x68, 0x10, 0x60, 0xD0,
  0x60, 0xC1, 0xE0, 0xC1, 0x83, 0xC1, 0x03, 0x07, 0x82, 0x06, 0x0F, 0x04,
  0x08, 0x1E, 0x08, 0x10, 0x3C, 0x10, 0x20, 0x78, 0x20, 0xC0, 0xB0, 0x41,
  0x81, 0x20, 0xC2, 0x86, 0x41, 0x8D, 0x0C, 0x81, 0xF3, 0x71, 0x81, 0xC3,
  0xC3, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x2C, 0x00,
  0x36, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x60, 0x06, 0x30, 0x03, 0x08,
  0x01, 0x04, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x20, 0x10,
  0x18, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0xFF, 0x03, 0x00, 0x81, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x08, 0x60, 0x04, 0x20, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x24, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0xFF, 0xE1, 0x80,
  0xE3, 0x00, 0x66, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x03, 0x18, 0x1E, 0x3F,
  0xF0, 0x60, 0x38, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x2C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0xCC, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xFC,
  0x18, 0x08, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE1, 0x80, 0xFF, 0xFF, 0xC0, 0xC0, 0xF0,
  0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x1C, 0x03, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01,
  0x8C, 0x00, 0x31, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0xE0, 0x78, 0x0F, 0xFC,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0xFE,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x3F, 0x80, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x7F,
  0xBE, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01,
  0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0xCC,
  0x03, 0x30, 0x0D, 0xC0, 0x35, 0x80, 0xF6, 0x03, 0x8C, 0x0C, 0x30, 0x30,
  0x60, 0xC1, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC,
  0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xC0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFD, 0x00, 0x01, 0xFB, 0x00, 0x02, 0xF6, 0x00, 0x0D,
  0xE4, 0x00, 0x1B, 0xC8, 0x00, 0x27, 0x98, 0x00, 0xCF, 0x30, 0x01, 0x9E,
  0x20, 0x02, 0x3C, 0x60, 0x04, 0x78, 0xC0, 0x18, 0xF0, 0x80, 0x31, 0xE1,
  0x80, 0x43, 0xC3, 0x01, 0x87, 0x82, 0x03, 0x0F, 0x04, 0x04, 0x1E, 0x0C,
  0x18, 0x3C, 0x18, 0x30, 0x78, 0x10, 0x40, 0xF0, 0x30, 0x81, 0xE0, 0x63,
  0x03, 0xC0, 0x46, 0x07, 0x80, 0xC8, 0x0F, 0x01, 0xB0, 0x1E, 0x01, 0x60,
  0x3C, 0x02, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0x80, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xD8, 0x01, 0xD8, 0x01, 0xC8, 0x01,
  0xCC, 0x01, 0xC4, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC3, 0x01, 0xC3, 0x01,
  0xC1, 0x01, 0xC1, 0x81, 0xC0, 0x81, 0xC0, 0xC1, 0xC0, 0x41, 0xC0, 0x61,
  0xC0, 0x61, 0xC0, 0x31, 0xC0, 0x31, 0xC0, 0x11, 0xC0, 0x19, 0xC0, 0x09,
  0xC0, 0x0D, 0xC0, 0x0D, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0x30, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x03, 0x08, 0x00, 0x63, 0x00, 0x04, 0x60, 0x00, 0xCC, 0x00, 0x19,
  0x00, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x16,
  0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x38, 0x0E, 0x03,
  0xC7, 0x80, 0x1F, 0xC0, 0xFF, 0xC6, 0x07, 0x30, 0x0D, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xD8, 0x0C, 0xFF, 0xC7, 0xF8, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x38, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x03, 0x08, 0x00, 0x63,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x2C,
  0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x78,
  0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC4, 0x00, 0x10, 0xC0, 0x06, 0x18,
  0x00, 0xC1, 0x80, 0x30, 0x38, 0x0C, 0x03, 0xC7, 0x80, 0x1F, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0xFF, 0xC3, 0x03, 0x8C, 0x03, 0x30, 0x06, 0xC0,
  0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x01, 0xB0,
  0x06, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x30, 0xF0, 0xFF, 0x03, 0x04, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0xC3, 0x03, 0x0C, 0x06, 0x30, 0x18, 0xC0, 0x33,
  0x00, 0xCC, 0x01, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xC0, 0x07,
  0xE0, 0xFF, 0xCC, 0x02, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x1B,
  0x83, 0x9F, 0xF8, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C,
  0x1C, 0x38, 0x0F, 0xF0, 0xC0, 0x01, 0xE0, 0x00, 0x90, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x10, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18,
  0x02, 0x04, 0x01, 0x02, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20,
  0x10, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x04, 0x00, 0x86, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x18, 0x80, 0x04, 0x40, 0x02, 0x60, 0x01, 0xB0, 0x00,
  0xD0, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x07,
  0x00, 0x1A, 0x00, 0x38, 0x00, 0xD8, 0x01, 0xC0, 0x0C, 0xC0, 0x0A, 0x00,
  0x66, 0x00, 0x50, 0x03, 0x30, 0x06, 0x80, 0x18, 0x80, 0x36, 0x00, 0x86,
  0x01, 0xB0, 0x0C, 0x30, 0x0D, 0x80, 0x61, 0x80, 0x44, 0x03, 0x04, 0x02,
  0x20, 0x18, 0x20, 0x31, 0x80, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x0C, 0x60,
  0x60, 0x60, 0x41, 0x03, 0x01, 0x02, 0x08, 0x10, 0x08, 0x30, 0x60, 0x80,
  0x61, 0x83, 0x0C, 0x03, 0x0C, 0x18, 0x60, 0x18, 0x40, 0x43, 0x00, 0x42,
  0x02, 0x10, 0x03, 0x30, 0x19, 0x80, 0x19, 0x80, 0xCC, 0x00, 0xCC, 0x06,
  0x60, 0x06, 0x40, 0x13, 0x00, 0x12, 0x00, 0x90, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x70, 0x06, 0x60, 0x18, 0xC0, 0x30, 0xC0, 0xC1, 0x81,
  0x81, 0x02, 0x03, 0x0C, 0x06, 0x18, 0x04, 0x20, 0x0C, 0xC0, 0x19, 0x80,
  0x16, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x05,
  0x80, 0x19, 0x00, 0x33, 0x00, 0x46, 0x01, 0x84, 0x03, 0x0C, 0x0C, 0x18,
  0x18, 0x10, 0x20, 0x30, 0xC0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0,
  0x01, 0x80, 0xC0, 0x0E, 0x80, 0x19, 0x80, 0x33, 0x00, 0x42, 0x01, 0x86,
  0x03, 0x0C, 0x04, 0x08, 0x18, 0x18, 0x30, 0x30, 0x40, 0x21, 0x80, 0x63,
  0x00, 0xC4, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x40, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x04, 0x30, 0x0C,
  0x30, 0x08, 0x18, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x60,
  0x06, 0xC0, 0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xC3, 0x06, 0x0C, 0x18,
  0x20, 0x40, 0x06, 0x03, 0xFC, 0x60, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0xFF, 0x38, 0x36, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0B, 0x61,
  0xB3, 0xF3, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0E, 0x0C, 0xFE, 0x36, 0x0C, 0xF0,
  0x1B, 0x80, 0x6E, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x02, 0xE0, 0x1B, 0x80, 0x6F, 0x03, 0x36, 0x1C, 0x8F, 0xC0,
  0x03, 0xC1, 0xFC, 0x60, 0x98, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x08, 0x7F, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x1C, 0x31, 0xFC, 0xCE, 0x1B, 0x30, 0x3D, 0x80, 0x76, 0x00, 0xD0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x60, 0x1D,
  0x80, 0x73, 0x03, 0x4E, 0x19, 0x1F, 0xC4, 0x03, 0x00, 0xFE, 0x0C, 0x18,
  0x60, 0x66, 0x03, 0x30, 0x09, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x04, 0x70, 0xC1, 0xFE, 0x01, 0x80,
  0xFC, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x7F, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x07, 0x00, 0x7F,
  0x13, 0x86, 0xCC, 0x07, 0x60, 0x1D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x07, 0x60, 0x1C, 0xC0, 0xB3,
  0x86, 0xC7, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0E, 0x60, 0x71, 0xFF, 0x80, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x38, 0xCF, 0xCD, 0x86, 0xF0, 0x3E, 0x03, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x10, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x37, 0xB0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC0, 0x8C, 0x18, 0xC3, 0x0C, 0x30,
  0xC6, 0x0C, 0x40, 0xCC, 0x0D, 0xC0, 0xD6, 0x0F, 0x60, 0xE2, 0x0C, 0x30,
  0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x08, 0xC0, 0xCC, 0x04, 0xC0, 0x6C, 0x06,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x01, 0xC4, 0xFE, 0x3F, 0xA4, 0x33, 0x0D, 0x40, 0xD0, 0x3A, 0x03, 0x81,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x03, 0x08, 0xFE, 0x98, 0x6B, 0x03, 0xA0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x03, 0x00, 0x7F, 0x83, 0x83, 0x08, 0x06, 0x60, 0x19, 0x00,
  0x24, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0x98,
  0x02, 0x60, 0x18, 0xC0, 0xC1, 0x87, 0x03, 0xF0, 0x03, 0x82, 0x3F, 0x89,
  0x83, 0x2C, 0x04, 0xA0, 0x1A, 0x80, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xB8, 0x06, 0xE0, 0x1B, 0x40, 0xCD, 0x86,
  0x33, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x13,
  0x86, 0xCC, 0x0F, 0x60, 0x1D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x07, 0x60, 0x1C, 0xC0, 0xB3, 0x86,
  0xC3, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xC7, 0xA6, 0x1A,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x0E,
  0x07, 0xF9, 0x81, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x20, 0x0D, 0x01, 0xB0, 0x67, 0xF8, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x19,
  0x1F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x05, 0x60, 0x57, 0x19, 0x3F, 0x10,
  0xC0, 0x1A, 0x00, 0xD8, 0x06, 0xC0, 0x26, 0x01, 0x10, 0x18, 0x80, 0xC6,
  0x04, 0x30, 0x20, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x84, 0x04, 0x60, 0x23,
  0x01, 0x98, 0x0C, 0x80, 0x64, 0x01, 0x60, 0x0B, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x18, 0x06, 0x80, 0x30, 0x0D, 0x80, 0xE0, 0x13, 0x01,
  0xE0, 0x26, 0x02, 0xC0, 0xC4, 0x05, 0x81, 0x8C, 0x19, 0x02, 0x18, 0x32,
  0x04, 0x30, 0x66, 0x18, 0x20, 0x8C, 0x30, 0x41, 0x18, 0x60, 0xC6, 0x10,
  0x81, 0x8C, 0x21, 0x03, 0x10, 0x66, 0x02, 0x20, 0xCC, 0x04, 0xC0, 0x90,
  0x0D, 0x81, 0x20, 0x1B, 0x02, 0x40, 0x14, 0x07, 0x80, 0x28, 0x0F, 0x00,
  0x70, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x00, 0x40, 0x33, 0x01,
  0x98, 0x18, 0x60, 0xC3, 0x04, 0x08, 0x60, 0x62, 0x01, 0x30, 0x0D, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x06, 0x80, 0x26, 0x03, 0x10, 0x10,
  0xC1, 0x86, 0x0C, 0x18, 0xC0, 0xC6, 0x03, 0x60, 0x1B, 0x00, 0x60, 0x60,
  0x0D, 0x80, 0x32, 0x00, 0x88, 0x06, 0x30, 0x18, 0xC0, 0x61, 0x01, 0x04,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x82, 0x02, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0x44, 0x01, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x07, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x7F,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x3F, 0xFF, 0xFC, 0x01, 0xE0, 0x60, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x03, 0xC0, 0x7C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x3E, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x07, 0x80, 0xF0, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x0F, 0x81, 0xE0, 0x00, 0x08, 0x00, 0x7F, 0x01,
  0xC1, 0xC7, 0x80, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 8, 11, 14, 3, -31 },
  { 24, 17, 31, 19, 1, -31 },
  { 90, 15, 36, 18, 1, -33 },
  { 158, 22, 32, 26, 2, -32 },
  { 246, 17, 32, 18, 1, -32 },
  { 314, 2, 11, 8, 3, -31 },
  { 317, 8, 38, 12, 2, -31 },
  { 355, 8, 38, 12, 2, -31 },
  { 393, 12, 11, 15, 2, -33 },
  { 410, 16, 21, 18, 1, -26 },
  { 452, 4, 11, 8, 2, -5 },
  { 458, 10, 2, 12, 1, -13 },
  { 461, 3, 3, 8, 3, -3 },
  { 463, 13, 31, 15, 1, -31 },
  { 514, 14, 32, 18, 2, -32 },
  { 570, 8, 31, 18, 3, -31 },
  { 601, 14, 32, 18, 2, -32 },
  { 657, 13, 32, 18, 2, -32 },
  { 709, 16, 32, 18, 1, -32 },
  { 773, 14, 31, 18, 2, -31 },
  { 828, 14, 33, 18, 2, -32 },
  { 886, 13, 31, 18, 2, -31 },
  { 937, 14, 32, 18, 2, -32 },
  { 993, 13, 32, 18, 2, -32 },
  { 1045, 3, 24, 8, 3, -24 },
  { 1054, 4, 30, 8, 2, -24 },
  { 1069, 16, 19, 18, 1, -25 },
  { 1107, 16, 11, 18, 1, -21 },
  { 1129, 16, 19, 18, 1, -25 },
  { 1167, 10, 32, 12, 1, -32 },
  { 1207, 23, 36, 27, 2, -32 },
  { 1311, 17, 31, 17, 0, -31 },
  { 1377, 15, 31, 19, 3, -31 },
  { 1436, 15, 32, 19, 2, -32 },
  { 1496, 16, 31, 21, 3, -31 },
  { 1558, 12, 31, 17, 3, -31 },
  { 1605, 12, 31, 16, 3, -31 },
  { 1652, 19, 32, 23, 2, -32 },
  { 1728, 15, 31, 22, 3, -31 },
  { 1787, 7, 31, 10, 2, -31 },
  { 1815, 7, 39, 9, -2, -31 },
  { 1850, 14, 31, 17, 3, -31 },
  { 1905, 11, 31, 15, 3, -31 },
  { 1948, 23, 31, 29, 3, -31 },
  { 2038, 16, 31, 23, 3, -31 },
  { 2100, 19, 32, 23, 2, -32 },
  { 2176, 13, 31, 18, 3, -31 },
  { 2227, 19, 39, 23, 2, -32 },
  { 2320, 14, 31, 18, 3, -31 },
  { 2375, 13, 32, 17, 2, -32 },
  { 2427, 15, 31, 15, 0, -31 },
  { 2486, 16, 31, 22, 3, -31 },
  { 2548, 17, 31, 17, 0, -31 },
  { 2614, 29, 31, 29, 0, -31 },
  { 2727, 15, 31, 15, 0, -31 },
  { 2786, 15, 31, 15, 0, -31 },
  { 2845, 13, 31, 15, 1, -31 },
  { 2896, 8, 38, 14, 4, -31 },
  { 2934, 13, 31, 15, 1, -31 },
  { 2985, 8, 38, 14, 2, -31 },
  { 3023, 16, 15, 18, 1, -31 },
  { 3053, 18, 1, 18, 0, 4 },
  { 3056, 6, 7, 10, 2, -34 },
  { 3062, 12, 24, 17, 2, -24 },
  { 3098, 14, 33, 19, 3, -33 },
  { 3156, 11, 24, 14, 2, -24 },
  { 3189, 14, 33, 19, 2, -33 },
  { 3247, 13, 24, 17, 2, -24 },
  { 3286, 11, 34, 10, 0, -34 },
  { 3333, 14, 35, 19, 2, -24 },
  { 3395, 12, 33, 18, 3, -33 },
  { 3445, 2, 32, 8, 3, -32 },
  { 3453, 5, 43, 8, 0, -32 },
  { 3480, 12, 33, 15, 3, -33 },
  { 3530, 2, 33, 8, 3, -33 },
  { 3539, 21, 24, 27, 3, -24 },
  { 3602, 12, 24, 18, 3, -24 },
  { 3638, 14, 24, 18, 2, -24 },
  { 3680, 14, 34, 19, 3, -24 },
  { 3740, 14, 34, 19, 2, -24 },
  { 3800, 9, 24, 12, 3, -24 },
  { 3827, 11, 24, 14, 2, -24 },
  { 3860, 8, 29, 10, 1, -29 },
  { 3889, 12, 23, 18, 3, -23 },
  { 3924, 13, 23, 14, 0, -23 },
  { 3962, 23, 23, 23, 0, -23 },
  { 4029, 13, 23, 14, 1, -23 },
  { 4067, 14, 34, 14, 0, -23 },
  { 4127, 10, 23, 12, 1, -23 },
  { 4156, 11, 38, 15, 2, -31 },
  { 4209, 1, 44, 17, 8, -33 },
  { 4215, 11, 38, 15, 2, -31 },
  { 4268, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT44PT7B_H_
