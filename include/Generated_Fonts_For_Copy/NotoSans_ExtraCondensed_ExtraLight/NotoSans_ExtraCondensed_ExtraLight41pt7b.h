#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xC1, 0x83, 0x04, 0x06, 0x08, 0x06, 0x08, 0x06, 0x08,
  0x06, 0x08, 0x04, 0x18, 0x04, 0x18, 0x04, 0x18, 0x04, 0x10, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0C, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x30, 0x08, 0x30,
  0x08, 0x30, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x20,
  0x10, 0x20, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x40, 0x10, 0x40,
  0x30, 0x40, 0x30, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xFE, 0x33,
  0x19, 0x8C, 0x04, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x10,
  0xC0, 0x63, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80,
  0x33, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0x40, 0xC1, 0x03, 0x0C,
  0x0C, 0x30, 0x30, 0xB0, 0xCE, 0xFF, 0xE0, 0x3E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x01, 0x07, 0xC0, 0x20, 0x46, 0x02, 0x04, 0x20, 0x60,
  0xC3, 0x04, 0x08, 0x30, 0x40, 0x81, 0x0C, 0x08, 0x10, 0x80, 0x81, 0x08,
  0x08, 0x11, 0x80, 0x81, 0x10, 0x08, 0x11, 0x00, 0x81, 0x31, 0xC8, 0x32,
  0x26, 0xC3, 0x26, 0x24, 0x26, 0x43, 0x46, 0x44, 0x13, 0xC4, 0xC1, 0x18,
  0xCC, 0x10, 0x08, 0xC1, 0x00, 0x8C, 0x10, 0x18, 0xC1, 0x01, 0x0C, 0x10,
  0x10, 0xC1, 0x03, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x30, 0x60, 0x43,
  0x04, 0x06, 0x20, 0x40, 0x3C, 0x07, 0x00, 0x0F, 0x80, 0x18, 0xC0, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x18, 0xC0, 0x08, 0x80, 0x0D, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1A,
  0x00, 0x33, 0x00, 0x21, 0x06, 0x61, 0x86, 0x40, 0xC6, 0xC0, 0x44, 0xC0,
  0x64, 0xC0, 0x2C, 0xC0, 0x3C, 0xC0, 0x18, 0x40, 0x18, 0x40, 0x3C, 0x60,
  0x64, 0x30, 0xC6, 0x1F, 0x83, 0xFF, 0xC0, 0x06, 0x08, 0x30, 0xC1, 0x86,
  0x0C, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x81, 0x03, 0x06, 0x04, 0x0C, 0x0C,
  0x18, 0x18, 0xC0, 0x81, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x04,
  0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC3, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x42, 0x1E, 0x5E, 0x3E, 0x03, 0x00, 0xD0, 0x31, 0x04, 0x31, 0x02,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x6D,
  0xB4, 0xB6, 0x80, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0xFC, 0x0C, 0x30, 0x40, 0xC6, 0x02, 0x30,
  0x11, 0x00, 0xD8, 0x06, 0xC0, 0x16, 0x00, 0xB0, 0x05, 0x80, 0x2C, 0x01,
  0x60, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x05, 0x80, 0x2C,
  0x01, 0x60, 0x0B, 0x00, 0x48, 0x06, 0x40, 0x33, 0x01, 0x18, 0x18, 0x60,
  0xC1, 0x8C, 0x07, 0xC0, 0x06, 0x1C, 0x69, 0x96, 0x38, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x0E, 0x03, 0xFC, 0x30, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0x0C, 0x07, 0xF8, 0xC0, 0xC8,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x18, 0x1F, 0x01, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x06, 0xC0, 0xCF, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x00,
  0x1A, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x10, 0x06, 0x20, 0x08, 0x40, 0x30,
  0x80, 0x41, 0x00, 0x82, 0x03, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20,
  0xC0, 0x41, 0x00, 0x86, 0x01, 0x08, 0x02, 0x1F, 0xFF, 0xC0, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x7F,
  0xE3, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x8C, 0x0F, 0xFC, 0x20, 0x70, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x19, 0x83, 0x8F, 0xF8, 0x00, 0x00,
  0x80, 0x3F, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xF8, 0x6E, 0xE3, 0xC1, 0x9C,
  0x06, 0xC0, 0x36, 0x00, 0xB0, 0x05, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x40, 0x12, 0x00, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x0F, 0xE0,
  0x08, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x3F, 0x81, 0x83, 0x0C, 0x06, 0x60, 0x19, 0x80, 0x26, 0x00, 0x98, 0x02,
  0x60, 0x08, 0x80, 0x63, 0x01, 0x84, 0x0C, 0x0C, 0x60, 0x1B, 0x00, 0x30,
  0x03, 0xF0, 0x18, 0x60, 0xC0, 0xC2, 0x01, 0x98, 0x02, 0x40, 0x0D, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x00, 0x36, 0x00, 0x8C, 0x06, 0x38,
  0x30, 0x3F, 0x80, 0x06, 0x03, 0xF8, 0x70, 0xC6, 0x06, 0xC0, 0x2C, 0x02,
  0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03,
  0xC0, 0x34, 0x05, 0x60, 0xD3, 0xF9, 0x1E, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x83, 0x87, 0xE0,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x6D, 0x90, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xB6, 0xD2, 0xD2, 0x00, 0x00, 0x04, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0x80,
  0x00, 0x1C, 0x7F, 0x20, 0xC0, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x81, 0x80, 0x01,
  0xFE, 0x00, 0x18, 0x1C, 0x03, 0x00, 0x30, 0x10, 0x00, 0x81, 0x80, 0x06,
  0x18, 0x00, 0x10, 0xC0, 0x00, 0xC4, 0x00, 0x02, 0x60, 0x7E, 0x12, 0x06,
  0x30, 0xD0, 0x61, 0x86, 0x83, 0x08, 0x3C, 0x10, 0x40, 0xE1, 0x82, 0x07,
  0x0C, 0x10, 0x38, 0x60, 0x81, 0xC3, 0x04, 0x0E, 0x18, 0x20, 0x70, 0xC1,
  0x07, 0x86, 0x18, 0x3C, 0x30, 0xC1, 0x60, 0x87, 0x09, 0x06, 0x68, 0xC8,
  0x1E, 0x7C, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x08, 0x00, 0x7F, 0xC0, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x06, 0x60, 0x06, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x30,
  0x0C, 0x30, 0x08, 0x10, 0x08, 0x10, 0x18, 0x18, 0x18, 0x18, 0x1F, 0xF8,
  0x1F, 0xF8, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0xFF, 0xC6, 0x07, 0x30, 0x0D, 0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x6C, 0x0E, 0x7F, 0xC3, 0x07,
  0x98, 0x06, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x87, 0xCF, 0xF8, 0x00,
  0x00, 0xF0, 0x1F, 0xF0, 0xE0, 0x46, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x04, 0x0F, 0xF0, 0xFF, 0x81, 0x83, 0xC3, 0x01, 0xC6, 0x01,
  0x8C, 0x01, 0x98, 0x01, 0x30, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0B,
  0x00, 0x16, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x05, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0xB0, 0x02,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x63, 0x01, 0x86, 0x3E, 0x0F, 0xF0, 0x00,
  0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xB0, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0F, 0xFE, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F,
  0xF7, 0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xFF,
  0x81, 0x80, 0x61, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x20,
  0x00, 0x98, 0x00, 0x46, 0x00, 0x21, 0x80, 0x10, 0x70, 0x38, 0x1F, 0xF8,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x04, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0xFC, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x37, 0xC0, 0xC0, 0x1E, 0x01,
  0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x43, 0x06, 0x18, 0x60, 0xC3, 0x06,
  0x30, 0x31, 0x01, 0x98, 0x0D, 0x80, 0x6E, 0x03, 0xF0, 0x1C, 0xC0, 0xC6,
  0x06, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x60, 0x63, 0x03, 0x18, 0x08,
  0xC0, 0x66, 0x01, 0x30, 0x0D, 0x80, 0x2C, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x5F, 0x00, 0x06, 0xE8,
  0x00, 0x37, 0x40, 0x01, 0x3B, 0x00, 0x19, 0xC8, 0x00, 0xCE, 0x40, 0x04,
  0x73, 0x00, 0x23, 0x98, 0x03, 0x1C, 0x40, 0x18, 0xE3, 0x00, 0x87, 0x18,
  0x0C, 0x38, 0x40, 0x61, 0xC2, 0x02, 0x0E, 0x18, 0x30, 0x70, 0x41, 0x83,
  0x82, 0x08, 0x1C, 0x18, 0x40, 0xE0, 0xC6, 0x07, 0x02, 0x30, 0x38, 0x19,
  0x01, 0xC0, 0xD8, 0x0E, 0x02, 0xC0, 0x70, 0x14, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x00, 0x80, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1D, 0x00,
  0x3B, 0x00, 0x76, 0x00, 0xE4, 0x01, 0xCC, 0x03, 0x88, 0x07, 0x18, 0x0E,
  0x10, 0x1C, 0x30, 0x38, 0x60, 0x70, 0x40, 0xE0, 0xC1, 0xC0, 0x83, 0x81,
  0x87, 0x01, 0x0E, 0x03, 0x1C, 0x02, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x09,
  0xC0, 0x1B, 0x80, 0x17, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0xFC, 0x03, 0x07, 0x03, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x04, 0xC0,
  0x02, 0x60, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x83, 0x01, 0x80, 0xE1, 0xC0,
  0x3F, 0x80, 0xFF, 0x8C, 0x1C, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0,
  0xCF, 0xF8, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0xFC, 0x03, 0x07, 0x03, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x02, 0x40, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x04, 0xC0,
  0x02, 0x60, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x83, 0x01, 0x80, 0xE1, 0xC0,
  0x3F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0xFF, 0x86, 0x0E, 0x30, 0x19, 0x80, 0x6C,
  0x03, 0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x00, 0xB0, 0x0D, 0x80,
  0x6C, 0x06, 0x60, 0x73, 0x1E, 0x1F, 0xE0, 0xC3, 0x06, 0x18, 0x30, 0x41,
  0x83, 0x0C, 0x08, 0x60, 0x63, 0x01, 0x18, 0x0C, 0xC0, 0x26, 0x01, 0xB0,
  0x0D, 0x80, 0x3C, 0x01, 0x80, 0x07, 0x01, 0xFF, 0x30, 0x16, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x06, 0xC1,
  0xCF, 0xF8, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0D, 0x80, 0x26, 0x01, 0x8E, 0x1C, 0x1F, 0xE0, 0xC0, 0x03, 0xC0, 0x02,
  0x40, 0x06, 0x40, 0x06, 0x60, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x20, 0x0C,
  0x30, 0x0C, 0x30, 0x08, 0x10, 0x08, 0x10, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x18, 0x10, 0x08, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0x04, 0x60,
  0x04, 0x60, 0x06, 0x40, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x04, 0x00, 0x68, 0x01, 0xC0,
  0x0D, 0x00, 0x38, 0x01, 0x30, 0x05, 0x00, 0x66, 0x00, 0xA0, 0x0C, 0xC0,
  0x14, 0x01, 0x88, 0x06, 0xC0, 0x21, 0x00, 0xD8, 0x04, 0x30, 0x19, 0x01,
  0x86, 0x02, 0x20, 0x30, 0xC0, 0x44, 0x06, 0x08, 0x18, 0xC0, 0x81, 0x03,
  0x18, 0x10, 0x30, 0x61, 0x06, 0x06, 0x08, 0x20, 0xC0, 0x41, 0x04, 0x18,
  0x08, 0x60, 0xC2, 0x01, 0x8C, 0x18, 0xC0, 0x31, 0x83, 0x18, 0x06, 0x20,
  0x23, 0x00, 0x44, 0x04, 0x40, 0x09, 0x80, 0xC8, 0x01, 0xB0, 0x1B, 0x00,
  0x36, 0x03, 0x60, 0x06, 0x80, 0x2C, 0x00, 0x50, 0x05, 0x00, 0x0A, 0x00,
  0xA0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x60, 0x0C, 0xC0, 0x63,
  0x01, 0x84, 0x04, 0x18, 0x30, 0x60, 0x80, 0x82, 0x03, 0x18, 0x04, 0x40,
  0x13, 0x00, 0x6C, 0x00, 0xA0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x06, 0x80, 0x1B, 0x00, 0x4C, 0x03, 0x10, 0x08, 0x60, 0x60, 0x81, 0x82,
  0x04, 0x0C, 0x30, 0x10, 0x80, 0x66, 0x01, 0x98, 0x02, 0xC0, 0x0C, 0xC0,
  0x0D, 0x00, 0x66, 0x01, 0x98, 0x04, 0x20, 0x30, 0xC0, 0xC3, 0x02, 0x04,
  0x18, 0x10, 0x60, 0x61, 0x00, 0x8C, 0x02, 0x30, 0x0C, 0x80, 0x16, 0x00,
  0x58, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x7F, 0xE0, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0x01, 0x00, 0x07, 0x00, 0x0A, 0x00,
  0x36, 0x00, 0x44, 0x01, 0x8C, 0x02, 0x08, 0x0C, 0x18, 0x10, 0x10, 0x60,
  0x30, 0x80, 0x23, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xC0, 0xFF, 0xFF, 0x80,
  0xC1, 0x82, 0x0C, 0x18, 0x30, 0x3F, 0x0E, 0x30, 0x03, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x7F, 0x98, 0x36, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xE0, 0x76, 0x16, 0x7C, 0xC0,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x7C, 0x27, 0x31, 0x60, 0xCA, 0x03, 0x60, 0x1B, 0x00,
  0x58, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x40, 0x6A, 0x06, 0x4C,
  0x72, 0x3F, 0x00, 0x0F, 0xC7, 0x33, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x38, 0x47, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x7C, 0xCE,
  0x76, 0x60, 0xF6, 0x03, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xD0, 0x06, 0xC0, 0x76, 0x06, 0x98, 0x64, 0x7E, 0x20, 0x0F, 0x83,
  0x9C, 0x20, 0x66, 0x06, 0x40, 0x2C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x18,
  0x01, 0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x01, 0x38, 0x20, 0xFE, 0x07, 0xC3, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x1F, 0xCF, 0xF0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x0F, 0x89,
  0xEE, 0x4C, 0x1E, 0xC0, 0x74, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1A, 0x01, 0xD8, 0x0E, 0xC0, 0xF3, 0x0D, 0x8F, 0xCC, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x40, 0x31, 0xFF,
  0x07, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x11, 0xF2, 0x67, 0x58, 0x3A, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0xBC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xC6, 0x00, 0x00, 0x00, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x1B, 0xDC, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x1A, 0x02, 0x40, 0xC8, 0x11,
  0x06, 0x21, 0x84, 0x20, 0x8C, 0x13, 0x02, 0x70, 0x5E, 0x0A, 0x41, 0x8C,
  0x30, 0x84, 0x18, 0x83, 0x10, 0x22, 0x06, 0x40, 0x48, 0x0D, 0x01, 0xA0,
  0x18, 0xFF, 0xFF, 0xFF, 0xFE, 0x8F, 0x07, 0x89, 0x98, 0xCE, 0xA0, 0xD0,
  0x6A, 0x05, 0x02, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x38, 0x06,
  0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38,
  0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03,
  0x8F, 0x93, 0x3A, 0xC1, 0xD0, 0x3C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x0F, 0x81, 0xC7, 0x08, 0x18,
  0xC0, 0x64, 0x01, 0x60, 0x0B, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1A, 0x00,
  0x98, 0x0C, 0x40, 0x43, 0x06, 0x0F, 0xE0, 0x8F, 0x84, 0xC6, 0x2C, 0x19,
  0x40, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x16, 0x01,
  0xA8, 0x0D, 0x40, 0xC9, 0x8E, 0x47, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x0F,
  0x88, 0xC6, 0x4C, 0x1E, 0xC0, 0x74, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1A, 0x00, 0xD8, 0x0E, 0xC0, 0xF3, 0x0D, 0x8F, 0xCC, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x8F, 0x9E, 0xB0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1F, 0x87, 0x1D, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x40, 0x6E, 0x1C, 0xFE, 0x00, 0x20, 0x40, 0x81, 0x02,
  0x0F, 0xFF, 0x90, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x78, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x56,
  0x1A, 0x7E, 0x40, 0xC0, 0x1C, 0x01, 0x40, 0x36, 0x03, 0x60, 0x26, 0x02,
  0x20, 0x62, 0x06, 0x30, 0x43, 0x04, 0x10, 0xC1, 0x0C, 0x18, 0xC1, 0x88,
  0x08, 0x80, 0x98, 0x0D, 0x80, 0xD0, 0x05, 0x00, 0x70, 0x07, 0x00, 0x60,
  0xC0, 0x30, 0x0A, 0x01, 0x80, 0x50, 0x0C, 0x06, 0xC0, 0xF0, 0x36, 0x07,
  0x81, 0x10, 0x24, 0x08, 0x81, 0x20, 0x44, 0x09, 0x06, 0x30, 0xCC, 0x31,
  0x86, 0x61, 0x04, 0x21, 0x08, 0x21, 0x08, 0xC1, 0x98, 0x46, 0x0C, 0xC3,
  0x20, 0x26, 0x19, 0x01, 0x20, 0x48, 0x09, 0x02, 0xC0, 0x68, 0x16, 0x03,
  0xC0, 0xE0, 0x0C, 0x07, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x34,
  0x06, 0x60, 0x62, 0x0C, 0x30, 0xC3, 0x08, 0x11, 0x81, 0x90, 0x0B, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xB0, 0x19, 0x01, 0x18, 0x30, 0x82,
  0x0C, 0x60, 0xC4, 0x06, 0xC0, 0x6C, 0x03, 0x40, 0x1B, 0x00, 0xD8, 0x04,
  0x40, 0x22, 0x03, 0x18, 0x18, 0xC0, 0x82, 0x04, 0x10, 0x60, 0xC3, 0x06,
  0x10, 0x10, 0x80, 0x8C, 0x06, 0x60, 0x32, 0x00, 0x90, 0x05, 0x80, 0x3C,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x03, 0xE0, 0x1E, 0x00, 0x7F,
  0xBF, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x07, 0xFC,
  0x03, 0xC1, 0xC0, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x38, 0x38, 0x07, 0x00,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x06, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x70, 0x38, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x06, 0x0F, 0x02, 0x00, 0x7E, 0x07, 0x0E, 0x38, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 7, 10, 13, 3, -29 },
  { 18, 16, 29, 18, 1, -29 },
  { 76, 14, 33, 16, 1, -31 },
  { 134, 20, 30, 24, 2, -30 },
  { 209, 16, 30, 17, 1, -30 },
  { 269, 1, 10, 7, 3, -29 },
  { 271, 7, 35, 11, 2, -29 },
  { 302, 7, 35, 11, 2, -29 },
  { 333, 11, 11, 14, 2, -31 },
  { 349, 14, 19, 17, 1, -24 },
  { 383, 3, 9, 8, 2, -4 },
  { 387, 9, 2, 11, 1, -12 },
  { 390, 2, 3, 8, 3, -3 },
  { 391, 12, 29, 14, 1, -29 },
  { 435, 13, 30, 16, 2, -30 },
  { 484, 7, 29, 16, 3, -29 },
  { 510, 13, 30, 16, 2, -30 },
  { 559, 12, 30, 16, 2, -30 },
  { 604, 15, 29, 16, 1, -29 },
  { 659, 13, 29, 16, 2, -29 },
  { 707, 13, 31, 16, 2, -30 },
  { 758, 12, 29, 16, 2, -29 },
  { 802, 14, 30, 16, 1, -30 },
  { 855, 12, 30, 16, 2, -30 },
  { 900, 2, 22, 8, 3, -22 },
  { 906, 3, 27, 8, 2, -22 },
  { 917, 14, 17, 17, 1, -23 },
  { 947, 14, 11, 17, 1, -20 },
  { 967, 14, 17, 17, 1, -23 },
  { 997, 9, 30, 11, 1, -30 },
  { 1031, 21, 33, 25, 2, -29 },
  { 1118, 16, 29, 16, 0, -29 },
  { 1176, 13, 29, 18, 3, -29 },
  { 1224, 14, 30, 17, 2, -30 },
  { 1277, 15, 29, 20, 3, -29 },
  { 1332, 11, 29, 16, 3, -29 },
  { 1372, 11, 29, 15, 3, -29 },
  { 1412, 17, 30, 22, 2, -30 },
  { 1476, 14, 29, 20, 3, -29 },
  { 1527, 6, 29, 10, 2, -29 },
  { 1549, 7, 36, 8, -2, -29 },
  { 1581, 13, 29, 16, 3, -29 },
  { 1629, 10, 29, 14, 3, -29 },
  { 1666, 21, 29, 27, 3, -29 },
  { 1743, 15, 29, 21, 3, -29 },
  { 1798, 17, 30, 21, 2, -30 },
  { 1862, 12, 29, 17, 3, -29 },
  { 1906, 17, 37, 21, 2, -30 },
  { 1985, 13, 29, 17, 3, -29 },
  { 2033, 12, 30, 16, 2, -30 },
  { 2078, 14, 29, 14, 0, -29 },
  { 2129, 14, 29, 20, 3, -29 },
  { 2180, 16, 29, 16, 0, -29 },
  { 2238, 27, 29, 27, 0, -29 },
  { 2336, 14, 29, 14, 0, -29 },
  { 2387, 14, 29, 14, 0, -29 },
  { 2438, 12, 29, 14, 1, -29 },
  { 2482, 8, 36, 13, 3, -29 },
  { 2518, 12, 29, 14, 1, -29 },
  { 2562, 8, 36, 13, 1, -29 },
  { 2598, 15, 14, 17, 1, -29 },
  { 2625, 17, 1, 16, 0, 4 },
  { 2628, 6, 6, 10, 2, -31 },
  { 2633, 11, 22, 15, 2, -22 },
  { 2664, 13, 31, 18, 3, -31 },
  { 2715, 10, 22, 13, 2, -22 },
  { 2743, 13, 31, 18, 2, -31 },
  { 2794, 12, 22, 16, 2, -22 },
  { 2827, 10, 31, 9, 0, -31 },
  { 2866, 13, 32, 18, 2, -22 },
  { 2918, 11, 31, 17, 3, -31 },
  { 2961, 2, 30, 8, 3, -30 },
  { 2969, 5, 40, 8, 0, -30 },
  { 2994, 11, 31, 14, 3, -31 },
  { 3037, 1, 31, 7, 3, -31 },
  { 3041, 20, 22, 26, 3, -22 },
  { 3096, 11, 22, 17, 3, -22 },
  { 3127, 13, 22, 17, 2, -22 },
  { 3163, 13, 32, 18, 3, -22 },
  { 3215, 13, 32, 18, 2, -22 },
  { 3267, 8, 22, 11, 3, -22 },
  { 3289, 11, 22, 13, 1, -22 },
  { 3320, 7, 27, 9, 1, -27 },
  { 3344, 11, 22, 17, 3, -22 },
  { 3375, 12, 22, 13, 0, -22 },
  { 3408, 21, 22, 22, 0, -22 },
  { 3466, 12, 22, 13, 1, -22 },
  { 3499, 13, 32, 13, 0, -22 },
  { 3551, 9, 22, 11, 1, -22 },
  { 3576, 10, 36, 14, 2, -29 },
  { 3621, 2, 41, 16, 7, -31 },
  { 3632, 10, 36, 14, 2, -29 },
  { 3677, 14, 3, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT41PT7B_H_
