#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00,
  0x00, 0xDF, 0xF0, 0xE1, 0xF0, 0x7C, 0x1F, 0x06, 0xC1, 0xB0, 0x2C, 0x0B,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x80, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x81, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x02, 0x02, 0x00, 0x20, 0x20, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x04, 0x04,
  0x00, 0x40, 0x40, 0x04, 0x04, 0x0F, 0xFF, 0xFE, 0x0C, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x01, 0xFF,
  0xC1, 0xCC, 0x71, 0xC6, 0x08, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30,
  0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x18, 0xC0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x06, 0xE0, 0x03, 0x1C, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x60, 0xC0,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x02, 0x01, 0x83,
  0x00, 0xC1, 0xA0, 0x63, 0x9E, 0x37, 0x87, 0xFF, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xC0, 0x0C, 0x03, 0x18, 0x02, 0x01, 0x82, 0x01, 0x80, 0x60, 0xC0, 0x60,
  0x10, 0x30, 0x10, 0x04, 0x0C, 0x0C, 0x03, 0x01, 0x03, 0x00, 0xC0, 0x40,
  0x80, 0x30, 0x10, 0x60, 0x0C, 0x06, 0x18, 0x03, 0x01, 0x84, 0x00, 0xC0,
  0x63, 0x00, 0x30, 0x10, 0xC0, 0x0C, 0x04, 0x20, 0x03, 0x01, 0x18, 0xF8,
  0x40, 0xC6, 0x73, 0x10, 0x31, 0x18, 0x66, 0x0C, 0xC4, 0x19, 0x82, 0x33,
  0x02, 0x31, 0x88, 0xC0, 0x8F, 0xC6, 0x30, 0x30, 0xE1, 0x88, 0x0C, 0x00,
  0x42, 0x03, 0x00, 0x30, 0x80, 0xC0, 0x0C, 0x20, 0x30, 0x02, 0x08, 0x0C,
  0x01, 0x82, 0x03, 0x00, 0x60, 0x80, 0xC0, 0x10, 0x20, 0x30, 0x0C, 0x0C,
  0x0C, 0x03, 0x03, 0x02, 0x00, 0x80, 0xC0, 0x80, 0x60, 0x10, 0x60, 0x18,
  0x06, 0x18, 0x04, 0x01, 0xCC, 0x03, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x01, 0x82, 0x00, 0x10, 0xC0, 0x03, 0x30, 0x00, 0x26, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0xC1,
  0x81, 0x98, 0x30, 0x26, 0x03, 0x04, 0xC0, 0x61, 0x98, 0x06, 0x33, 0x00,
  0x66, 0x40, 0x0C, 0xC8, 0x00, 0xF1, 0x80, 0x1E, 0x30, 0x01, 0x86, 0x00,
  0x38, 0xC0, 0x0F, 0x0C, 0x03, 0x31, 0xC0, 0xE6, 0x1C, 0x78, 0x61, 0xFC,
  0x0E, 0x04, 0x00, 0x00, 0xFB, 0x6D, 0xB2, 0x49, 0x24, 0x03, 0x83, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x8C, 0x77,
  0xFF, 0x01, 0xE0, 0x07, 0x00, 0x12, 0x00, 0xCC, 0x06, 0x18, 0x30, 0x30,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x39, 0x8C, 0x63, 0x39,
  0x8C, 0x62, 0x31, 0x80, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x0C, 0x38, 0x18,
  0x1C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x02, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x18,
  0x0C, 0x1C, 0x18, 0x0F, 0x78, 0x07, 0xE0, 0x03, 0x83, 0xC3, 0x63, 0x33,
  0x1B, 0x0F, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x07, 0xC0, 0x3F, 0xF0, 0x70, 0x38, 0x40, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0x70, 0x38, 0xC0, 0x1C, 0x80, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x1C,
  0xF0, 0x78, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10,
  0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30, 0x04, 0x06, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x3F, 0xFC,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x67, 0xC0, 0x7F, 0xF8, 0x60, 0x3C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x80, 0x18, 0xF0, 0xF0, 0x7F, 0xE0, 0x00, 0x78,
  0x03, 0xFE, 0x07, 0x82, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x67, 0xF0, 0x4F, 0x3C, 0x58, 0x0C, 0xD0, 0x06,
  0xF0, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x18, 0x0C, 0x0E, 0x38, 0x07, 0xF0,
  0x01, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x06, 0x07, 0x06, 0x01, 0xC7, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0x60, 0x70, 0x18, 0x70,
  0x07, 0x60, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xCE, 0x01, 0xC1, 0x81, 0x80,
  0x61, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x58,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x03,
  0x30, 0x03, 0x0C, 0x03, 0x83, 0x87, 0x80, 0xFF, 0x00, 0x0C, 0x00, 0x07,
  0xC0, 0x0F, 0xF0, 0x18, 0x38, 0x30, 0x1C, 0x60, 0x0C, 0x60, 0x04, 0x60,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x07, 0x60,
  0x0F, 0x70, 0x0B, 0x38, 0x1B, 0x1F, 0xF3, 0x0F, 0xC3, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x21, 0xE0, 0x3F,
  0x80, 0x0C, 0x00, 0x7F, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x33, 0xCE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE7, 0x31, 0x8C, 0xE6, 0x31, 0x88, 0xC4, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x0F, 0xF8, 0xC0, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x0F,
  0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x08, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x19, 0x80, 0x7F, 0x06, 0x60, 0x39, 0xC1, 0x90, 0x18, 0x30,
  0x6C, 0x0C, 0x0C, 0x0B, 0x03, 0x03, 0x03, 0xC0, 0xC0, 0x80, 0xF0, 0x20,
  0x20, 0x3C, 0x18, 0x08, 0x0F, 0x06, 0x06, 0x03, 0xC1, 0x81, 0x80, 0xE0,
  0x60, 0x60, 0x38, 0x18, 0x18, 0x0F, 0x06, 0x06, 0x03, 0xC1, 0x81, 0x80,
  0xB0, 0x60, 0x60, 0x6C, 0x18, 0x18, 0x1B, 0x03, 0x0F, 0x06, 0xC0, 0xC2,
  0xC3, 0x30, 0x1F, 0x9F, 0xC4, 0x03, 0xC3, 0xC1, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x01,
  0x98, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xF0, 0xC0, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xE0,
  0xFF, 0xF0, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8,
  0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xC0, 0x61, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x20, 0x78, 0xF0, 0x1F, 0xF0, 0x00, 0xC0, 0xFF,
  0xE0, 0x30, 0x7E, 0x0C, 0x01, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01,
  0xCC, 0x00, 0x33, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x1C, 0x30, 0x0E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3F, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00,
  0xE0, 0x1E, 0x1C, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB8, 0x00,
  0x0C, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0xC0, 0x06, 0x07, 0xC3, 0xF0, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x30, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x3C, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0xFE, 0xF8,
  0xC0, 0x07, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30,
  0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x80,
  0xC3, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xDE, 0x00,
  0xF7, 0x00, 0xE3, 0x00, 0xE3, 0x80, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF4, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x6F, 0x60, 0x00,
  0x1B, 0xC8, 0x00, 0x0C, 0xF3, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0xCF, 0x30,
  0x00, 0x23, 0xC6, 0x00, 0x18, 0xF1, 0x80, 0x06, 0x3C, 0x60, 0x01, 0x8F,
  0x08, 0x00, 0xC3, 0xC3, 0x00, 0x30, 0xF0, 0xC0, 0x0C, 0x3C, 0x10, 0x06,
  0x0F, 0x06, 0x01, 0x83, 0xC1, 0x80, 0x60, 0xF0, 0x60, 0x10, 0x3C, 0x0C,
  0x0C, 0x0F, 0x03, 0x03, 0x03, 0xC0, 0xC0, 0xC0, 0xF0, 0x18, 0x60, 0x3C,
  0x06, 0x18, 0x0F, 0x01, 0x86, 0x03, 0xC0, 0x23, 0x00, 0xF0, 0x0C, 0xC0,
  0x3C, 0x03, 0x30, 0x0F, 0x00, 0xC8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07,
  0x30, 0x01, 0xCC, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x08, 0x01, 0xC3,
  0x00, 0x70, 0xC0, 0x1C, 0x18, 0x07, 0x06, 0x01, 0xC0, 0xC0, 0x70, 0x30,
  0x1C, 0x06, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x70, 0x0C, 0x1C, 0x03, 0x07,
  0x00, 0x61, 0xC0, 0x18, 0x70, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x11, 0xC0,
  0x06, 0x70, 0x01, 0x9C, 0x00, 0x37, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0x81,
  0xC0, 0x38, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x38, 0x00, 0xC0, 0xC0, 0x0E, 0x03, 0x80,
  0xE0, 0x0F, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0xC1, 0x87,
  0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0x60, 0x06, 0xC0, 0x1D, 0x80, 0x73, 0x03, 0xC7, 0xFF, 0x0F, 0xF0,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0x81,
  0xC0, 0x38, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x38, 0x00, 0xC0, 0xC0, 0x0E, 0x03, 0x00,
  0xE0, 0x0F, 0x3E, 0x00, 0x3F, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0xC3, 0xF0, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0x03, 0xF0, 0x0F, 0xFF, 0x1C, 0x06,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x80, 0x1C, 0xFC, 0xF8, 0x7F, 0xE0, 0x03, 0x00, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x0C, 0x60, 0x03, 0x0E, 0x01, 0x81, 0xE3, 0xE0, 0x3F, 0xE0,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01,
  0x86, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x10, 0x60,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80,
  0x03, 0x20, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xD8, 0x00, 0x70,
  0x00, 0x66, 0x00, 0x1C, 0x00, 0x19, 0x80, 0x07, 0x80, 0x06, 0x60, 0x01,
  0xE0, 0x03, 0x18, 0x00, 0x58, 0x00, 0xC3, 0x00, 0x36, 0x00, 0x30, 0xC0,
  0x0D, 0x80, 0x0C, 0x30, 0x03, 0x30, 0x03, 0x0C, 0x00, 0xCC, 0x01, 0x81,
  0x80, 0x33, 0x00, 0x60, 0x60, 0x08, 0xC0, 0x18, 0x18, 0x06, 0x30, 0x06,
  0x06, 0x01, 0x84, 0x03, 0x01, 0x80, 0x61, 0x80, 0xC0, 0x30, 0x18, 0x60,
  0x30, 0x0C, 0x04, 0x18, 0x0C, 0x03, 0x03, 0x06, 0x03, 0x00, 0xC0, 0xC0,
  0x81, 0x80, 0x30, 0x30, 0x30, 0x60, 0x06, 0x0C, 0x0C, 0x18, 0x01, 0x82,
  0x03, 0x06, 0x00, 0x61, 0x80, 0xC1, 0x80, 0x18, 0x60, 0x10, 0xC0, 0x02,
  0x18, 0x06, 0x30, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x63, 0x00,
  0x0C, 0xC0, 0x19, 0x80, 0x03, 0x30, 0x02, 0x60, 0x00, 0x6C, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x36, 0x00, 0x06, 0x80, 0x0D, 0x80, 0x01, 0xE0, 0x03,
  0x40, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x30, 0x01, 0x98, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x60, 0x60, 0x30, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x00,
  0xC6, 0x00, 0x62, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x03, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x60, 0x0E, 0x30, 0x03,
  0x38, 0x01, 0x98, 0x00, 0x7C, 0x00, 0x30, 0xC0, 0x01, 0xB0, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x31,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x7F, 0xFE, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0xFF,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x1C, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0xFF,
  0xFF, 0xF8, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xE0,
  0xE1, 0xC2, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x07, 0xFC, 0x78, 0x33, 0x00,
  0xD8, 0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x60, 0x2D, 0xC3, 0x33, 0xF8, 0xC1, 0x80, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87,
  0xF0, 0x9E, 0x78, 0x90, 0x1C, 0xA0, 0x0C, 0xA0, 0x0E, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xA0, 0x0C, 0xA0, 0x0C, 0x90,
  0x18, 0x9C, 0x78, 0x8F, 0xE0, 0x01, 0x80, 0x07, 0xF8, 0x78, 0xC7, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x70, 0xC1, 0xFE, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x7F, 0x18, 0xF1, 0xCC, 0x60,
  0x36, 0x60, 0x0B, 0x30, 0x07, 0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x76,
  0x00, 0x3B, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x0E, 0xC0,
  0x07, 0x60, 0x03, 0xB0, 0x01, 0xCC, 0x01, 0x66, 0x00, 0xB1, 0x80, 0x98,
  0xF1, 0xCC, 0x3F, 0xC6, 0x01, 0x00, 0x07, 0xF0, 0x0E, 0x38, 0x18, 0x18,
  0x30, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x02, 0x0E, 0x1E, 0x07, 0xFC,
  0x00, 0x40, 0x03, 0xE0, 0xFC, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0xF9, 0xFF, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x07, 0xF1, 0x1E, 0x39,
  0x18, 0x0D, 0x30, 0x05, 0x30, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x07, 0x30, 0x05, 0x30, 0x0D, 0x18, 0x09, 0x1E, 0x39,
  0x0F, 0xE1, 0x01, 0x81, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x60, 0x1C, 0x7E, 0xF8,
  0x1F, 0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x8F,
  0xE2, 0x73, 0xC9, 0x03, 0xAC, 0x06, 0xA0, 0x1B, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x7F,
  0xB0, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0x0C, 0x71, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x61,
  0xBE, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x03, 0x40,
  0x32, 0x01, 0x90, 0x18, 0x80, 0xC4, 0x0C, 0x20, 0xC1, 0x06, 0x08, 0x60,
  0x47, 0x02, 0x30, 0x13, 0xC0, 0x96, 0x05, 0x90, 0x28, 0xC1, 0x86, 0x0C,
  0x18, 0x40, 0xC2, 0x03, 0x10, 0x18, 0x80, 0xC4, 0x03, 0x20, 0x19, 0x00,
  0x68, 0x03, 0x40, 0x1A, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x8F,
  0xC1, 0xFC, 0x9C, 0xE3, 0x9E, 0xB0, 0x32, 0x06, 0xA0, 0x34, 0x03, 0xE0,
  0x14, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x8F, 0xE2, 0x71, 0xC9,
  0x03, 0xA8, 0x06, 0xA0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xF0, 0x0F, 0x1E,
  0x06, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x18,
  0x0C, 0x07, 0x1E, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x87, 0xF0, 0x9C, 0x78,
  0x98, 0x1C, 0xB0, 0x0C, 0xA0, 0x0C, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xE0, 0x06, 0xA0, 0x0C, 0xB0, 0x0C, 0x98, 0x18, 0x9C, 0x78,
  0x8F, 0xE0, 0x81, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x07, 0xF1, 0x0E, 0x39, 0x18, 0x0D, 0x30, 0x05, 0x30, 0x05,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x30, 0x05,
  0x30, 0x0D, 0x18, 0x09, 0x1E, 0x39, 0x07, 0xE1, 0x01, 0x81, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x8F, 0xCF, 0xE6, 0x16,
  0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x00, 0x1F, 0xE3, 0x87, 0x60, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x7F, 0x1E, 0x7F, 0xC0, 0xC0, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x83, 0xFF, 0xFF, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x39, 0x0F, 0x81, 0x00,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x74, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0xB0, 0x0B, 0x70, 0x36, 0x79,
  0xCC, 0x7F, 0x18, 0x10, 0x00, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0C, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x18, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x20, 0x0C, 0x60, 0x04, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x80,
  0x0C, 0x00, 0xF0, 0x07, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x00, 0x70, 0x06,
  0x40, 0x16, 0x01, 0x98, 0x0D, 0x80, 0x46, 0x03, 0x60, 0x31, 0x80, 0xC8,
  0x0C, 0x60, 0x33, 0x03, 0x08, 0x08, 0xC0, 0xC3, 0x06, 0x30, 0x60, 0xC1,
  0x8C, 0x18, 0x30, 0x61, 0x06, 0x0C, 0x18, 0x61, 0x81, 0x8C, 0x18, 0x40,
  0x63, 0x06, 0x30, 0x18, 0xC1, 0x8C, 0x06, 0x30, 0x23, 0x00, 0x88, 0x0C,
  0xC0, 0x36, 0x03, 0x20, 0x0D, 0x80, 0xD8, 0x03, 0x60, 0x36, 0x00, 0xD8,
  0x05, 0x80, 0x14, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x61, 0x80, 0xC3, 0x01,
  0x83, 0x06, 0x06, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x0D, 0x80, 0x1B, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x18,
  0xC0, 0x31, 0x80, 0xC3, 0x01, 0x83, 0x06, 0x06, 0x0C, 0x06, 0x30, 0x0C,
  0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x38, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x1B,
  0x00, 0x66, 0x00, 0xCC, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x60,
  0x30, 0x40, 0x60, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x02, 0x0C, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0xB0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x38, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xF0, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0xE0, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x3F, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0xF3, 0xC0,
  0x60, 0x3D, 0xF0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 36, 10, 4, -36 },
  { 15, 10, 13, 16, 3, -36 },
  { 32, 20, 36, 22, 1, -36 },
  { 122, 17, 42, 20, 2, -39 },
  { 212, 26, 37, 30, 2, -37 },
  { 333, 19, 38, 21, 2, -37 },
  { 424, 3, 13, 9, 3, -36 },
  { 429, 9, 44, 14, 3, -36 },
  { 479, 9, 44, 14, 2, -36 },
  { 529, 14, 14, 18, 2, -39 },
  { 554, 18, 24, 21, 1, -30 },
  { 608, 5, 12, 9, 2, -5 },
  { 616, 11, 2, 14, 1, -15 },
  { 619, 3, 4, 10, 3, -4 },
  { 621, 15, 36, 17, 1, -36 },
  { 689, 16, 37, 20, 2, -37 },
  { 763, 9, 36, 20, 4, -36 },
  { 804, 16, 37, 20, 2, -37 },
  { 878, 16, 38, 20, 2, -37 },
  { 954, 19, 37, 20, 1, -37 },
  { 1042, 16, 36, 20, 2, -36 },
  { 1114, 16, 38, 20, 2, -37 },
  { 1190, 16, 36, 20, 2, -36 },
  { 1262, 17, 38, 20, 2, -37 },
  { 1343, 16, 38, 20, 2, -37 },
  { 1419, 3, 27, 10, 3, -27 },
  { 1430, 5, 34, 10, 2, -27 },
  { 1452, 18, 22, 21, 1, -29 },
  { 1502, 18, 12, 21, 1, -24 },
  { 1529, 18, 22, 21, 1, -29 },
  { 1579, 12, 37, 14, 1, -37 },
  { 1635, 26, 42, 31, 3, -37 },
  { 1772, 20, 36, 20, 0, -36 },
  { 1862, 16, 36, 22, 4, -36 },
  { 1934, 17, 38, 21, 3, -37 },
  { 2015, 18, 36, 25, 4, -36 },
  { 2096, 13, 36, 20, 4, -36 },
  { 2155, 13, 36, 18, 4, -36 },
  { 2214, 21, 38, 27, 3, -37 },
  { 2314, 17, 36, 25, 4, -36 },
  { 2391, 8, 36, 12, 2, -36 },
  { 2427, 8, 45, 10, -2, -36 },
  { 2472, 16, 36, 20, 4, -36 },
  { 2544, 13, 36, 18, 4, -36 },
  { 2603, 26, 36, 34, 4, -36 },
  { 2720, 18, 36, 26, 4, -36 },
  { 2801, 21, 38, 26, 3, -37 },
  { 2901, 15, 36, 21, 4, -36 },
  { 2969, 21, 46, 26, 3, -37 },
  { 3090, 16, 36, 21, 4, -36 },
  { 3162, 16, 38, 20, 2, -37 },
  { 3238, 17, 36, 18, 0, -36 },
  { 3315, 18, 37, 25, 4, -36 },
  { 3399, 19, 36, 19, 0, -36 },
  { 3485, 34, 36, 34, 0, -36 },
  { 3638, 17, 36, 18, 0, -36 },
  { 3715, 17, 36, 17, 0, -36 },
  { 3792, 15, 36, 17, 1, -36 },
  { 3860, 10, 44, 16, 4, -36 },
  { 3915, 15, 36, 17, 1, -36 },
  { 3983, 10, 44, 16, 2, -36 },
  { 4038, 19, 17, 21, 1, -36 },
  { 4079, 21, 1, 20, 0, 5 },
  { 4082, 8, 8, 12, 2, -39 },
  { 4090, 14, 28, 19, 2, -27 },
  { 4139, 16, 40, 22, 4, -39 },
  { 4219, 13, 28, 16, 2, -27 },
  { 4265, 17, 40, 22, 2, -39 },
  { 4350, 16, 28, 20, 2, -27 },
  { 4406, 11, 39, 11, 1, -39 },
  { 4460, 16, 39, 22, 2, -27 },
  { 4538, 14, 39, 21, 4, -39 },
  { 4607, 3, 37, 9, 3, -37 },
  { 4621, 6, 49, 9, 0, -37 },
  { 4658, 13, 39, 17, 4, -39 },
  { 4722, 1, 39, 9, 4, -39 },
  { 4727, 24, 27, 32, 4, -27 },
  { 4808, 14, 27, 21, 4, -27 },
  { 4856, 17, 28, 21, 2, -27 },
  { 4916, 16, 39, 22, 4, -27 },
  { 4994, 16, 39, 22, 2, -27 },
  { 5072, 9, 27, 14, 4, -27 },
  { 5103, 12, 28, 16, 2, -27 },
  { 5145, 9, 34, 11, 1, -33 },
  { 5184, 15, 28, 21, 3, -27 },
  { 5237, 16, 27, 16, 0, -27 },
  { 5291, 26, 27, 27, 1, -27 },
  { 5379, 15, 27, 17, 1, -27 },
  { 5430, 15, 39, 17, 1, -27 },
  { 5504, 12, 27, 14, 1, -27 },
  { 5545, 12, 44, 18, 3, -36 },
  { 5611, 2, 51, 20, 9, -39 },
  { 5624, 13, 44, 18, 2, -36 },
  { 5696, 17, 4, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT51PT7B_H_
