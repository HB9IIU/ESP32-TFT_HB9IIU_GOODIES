#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC9, 0x24, 0x90, 0x00, 0x6F,
  0x80, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x02,
  0x0C, 0x02, 0x08, 0x06, 0x08, 0x06, 0x08, 0x06, 0x08, 0x06, 0x08, 0x04,
  0x08, 0x04, 0x18, 0x04, 0x18, 0x7F, 0xFF, 0x04, 0x10, 0x0C, 0x10, 0x0C,
  0x10, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x30, 0x08, 0x30, 0x08,
  0x30, 0xFF, 0xFE, 0x18, 0x20, 0x18, 0x20, 0x18, 0x20, 0x10, 0x20, 0x10,
  0x20, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x30, 0x40, 0x30, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x03, 0xFC, 0x39, 0x19, 0x84, 0x06, 0x10, 0x10,
  0x40, 0xC1, 0x03, 0x04, 0x0C, 0x10, 0x10, 0x40, 0x61, 0x01, 0x84, 0x03,
  0x90, 0x07, 0x40, 0x07, 0x00, 0x07, 0x00, 0x17, 0x00, 0x46, 0x01, 0x0C,
  0x04, 0x30, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0x10, 0xC0, 0x43,
  0xC1, 0x1B, 0xFF, 0xC0, 0xF8, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x3C,
  0x01, 0x03, 0x30, 0x18, 0x10, 0x80, 0x81, 0x86, 0x04, 0x0C, 0x10, 0x60,
  0x40, 0x82, 0x02, 0x04, 0x10, 0x10, 0x21, 0x80, 0x81, 0x08, 0x04, 0x08,
  0x40, 0x20, 0x46, 0x01, 0x02, 0x20, 0x08, 0x11, 0x1E, 0x60, 0x99, 0x1B,
  0x0C, 0x98, 0x48, 0x44, 0x82, 0x66, 0x64, 0x19, 0xE2, 0x20, 0xC0, 0x11,
  0x06, 0x01, 0x88, 0x10, 0x08, 0x40, 0x80, 0x42, 0x04, 0x06, 0x10, 0x60,
  0x20, 0x83, 0x01, 0x04, 0x18, 0x18, 0x20, 0xC0, 0x81, 0x04, 0x04, 0x0C,
  0x20, 0x60, 0x23, 0x02, 0x00, 0xF0, 0x0F, 0x80, 0x18, 0xC0, 0x18, 0x40,
  0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x40,
  0x18, 0x40, 0x08, 0xC0, 0x0C, 0x80, 0x0D, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1B, 0x00, 0x31, 0x00, 0x21, 0x82, 0x60, 0x82, 0x40, 0xC6, 0xC0, 0x46,
  0xC0, 0x64, 0xC0, 0x34, 0xC0, 0x1C, 0xC0, 0x18, 0x40, 0x18, 0x60, 0x3C,
  0x60, 0x66, 0x30, 0xC6, 0x1F, 0x83, 0xFA, 0xAA, 0xA8, 0x03, 0x06, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0xC0, 0x81,
  0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x83,
  0x02, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC3,
  0x06, 0x08, 0x30, 0x41, 0x86, 0x08, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0E, 0x4E, 0x7F, 0x03, 0x00, 0x50, 0x13, 0x06, 0x31, 0x83, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x36, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0x80, 0xFC, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x0F, 0x80, 0xC6, 0x0C, 0x18, 0x40,
  0x46, 0x03, 0x20, 0x19, 0x00, 0x58, 0x02, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x48, 0x02, 0x60, 0x33, 0x01,
  0x88, 0x08, 0x60, 0xC1, 0xCC, 0x07, 0xC0, 0x03, 0x07, 0x1F, 0x3B, 0x63,
  0xC3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x3F, 0x87, 0x06, 0x10, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x7F, 0xFC, 0x3F, 0x87, 0x07, 0x20, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x7C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xCC,
  0x0E, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0B,
  0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x10, 0xC0,
  0x61, 0x80, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xC0,
  0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x7F, 0xE3, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0D, 0xF8, 0x7D, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0D, 0x00, 0xCC, 0x1C, 0x3F,
  0xC0, 0x07, 0xF0, 0x70, 0x86, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xFC, 0x6C, 0x33,
  0x80, 0xDC, 0x06, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x00, 0x98, 0x0C, 0x60, 0x63, 0x86,
  0x0F, 0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x1F, 0xC1, 0x83, 0x18, 0x0C, 0x80, 0x2C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x13, 0x01, 0x98, 0x0C, 0x60,
  0xC1, 0x8C, 0x07, 0xC0, 0x3C, 0x03, 0x30, 0x30, 0x63, 0x01, 0x10, 0x0D,
  0x80, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0xF0,
  0x06, 0xC0, 0x63, 0x06, 0x0F, 0xE0, 0x1F, 0x81, 0x86, 0x18, 0x18, 0x80,
  0x4C, 0x03, 0x60, 0x1A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xEC, 0x0F, 0x70, 0xD9, 0xFC, 0x81,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x01, 0x84, 0x38, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x67, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x36, 0x66,
  0x64, 0xCC, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x04, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x01, 0x00, 0x00, 0xFE, 0x30, 0xC0, 0x18, 0x02, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x0E,
  0x1E, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x00,
  0xC3, 0x00, 0x01, 0x08, 0x00, 0x06, 0x60, 0x18, 0x19, 0x81, 0xF8, 0x24,
  0x0C, 0x60, 0x90, 0x61, 0x82, 0x41, 0x86, 0x0F, 0x04, 0x18, 0x3C, 0x10,
  0x60, 0xF0, 0xC1, 0x83, 0xC3, 0x06, 0x0F, 0x0C, 0x18, 0x3C, 0x30, 0x60,
  0xF0, 0xC1, 0x82, 0xC3, 0x06, 0x0B, 0x04, 0x28, 0x64, 0x18, 0xA1, 0x90,
  0x66, 0xCC, 0x40, 0xF1, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x40,
  0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x60, 0x06, 0x20, 0x06, 0x20,
  0x04, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x1F, 0xF8, 0x1F, 0xFC, 0x10, 0x0C, 0x30, 0x04,
  0x30, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x02, 0x60, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0x83, 0x0F, 0x8C, 0x03, 0x30,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x0F, 0x8F, 0xFC, 0x30, 0x1C, 0xC0, 0x13,
  0x00, 0x6C, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC1, 0xE3, 0xFF, 0x00, 0x03,
  0xFE, 0x0E, 0x18, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x60, 0x7F, 0x80, 0xFF, 0x81, 0x8F, 0xC3,
  0x01, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x33, 0x00, 0xC6, 0x03,
  0x8C, 0x7C, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3F, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0xE0, 0xC0, 0x08,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0C, 0x80, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x03, 0x07, 0x03, 0xC0, 0xFF,
  0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x6F, 0x84, 0x00, 0xC0, 0x1B, 0x00, 0xCC, 0x03,
  0x30, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x08, 0x30, 0x60, 0xC3, 0x03, 0x0C,
  0x0C, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x70, 0x0D, 0xC0, 0x3D, 0x00, 0xE6,
  0x03, 0x08, 0x0C, 0x30, 0x30, 0x40, 0xC1, 0x83, 0x02, 0x0C, 0x0C, 0x30,
  0x10, 0xC0, 0x63, 0x00, 0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x30,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x40, 0x00, 0xBD, 0x00,
  0x06, 0xF6, 0x00, 0x1B, 0xC8, 0x00, 0x4F, 0x20, 0x01, 0x3C, 0xC0, 0x0C,
  0xF3, 0x00, 0x23, 0xC4, 0x00, 0x8F, 0x18, 0x06, 0x3C, 0x60, 0x18, 0xF0,
  0x80, 0x43, 0xC2, 0x03, 0x0F, 0x0C, 0x0C, 0x3C, 0x10, 0x20, 0xF0, 0x40,
  0x83, 0xC1, 0x86, 0x0F, 0x06, 0x10, 0x3C, 0x08, 0x40, 0xF0, 0x33, 0x03,
  0xC0, 0xCC, 0x0F, 0x01, 0x20, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x30, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xD0, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xC8, 0x03, 0xCC, 0x03, 0xC4,
  0x03, 0xC6, 0x03, 0xC2, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x03, 0xC1,
  0x83, 0xC0, 0x83, 0xC0, 0xC3, 0xC0, 0x43, 0xC0, 0x63, 0xC0, 0x23, 0xC0,
  0x33, 0xC0, 0x33, 0xC0, 0x13, 0xC0, 0x1B, 0xC0, 0x0B, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x07, 0xF8, 0x03, 0x87, 0x01, 0x80, 0x60,
  0xC0, 0x08, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x19, 0x80, 0x06, 0x40,
  0x01, 0x90, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B,
  0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x20,
  0x01, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x60, 0x18, 0x0E, 0x1C, 0x01, 0xFE,
  0x00, 0xFF, 0x06, 0x7E, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0B, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x2C, 0x03, 0x60, 0x1B,
  0x01, 0x98, 0x38, 0xFF, 0x86, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x07, 0xF8, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x08, 0x30,
  0x03, 0x08, 0x00, 0x46, 0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0x90, 0x00,
  0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00,
  0xC3, 0x00, 0x20, 0x60, 0x18, 0x0E, 0x1C, 0x01, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0xFF, 0x03, 0x3F, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0x4C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0,
  0x33, 0x01, 0x8C, 0x0E, 0x3F, 0xE0, 0xFF, 0x03, 0x0C, 0x0C, 0x10, 0x30,
  0x60, 0xC0, 0x83, 0x03, 0x0C, 0x04, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC,
  0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x30, 0x1F, 0xF1, 0xC1, 0x98, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xCC, 0x0E, 0x7F, 0xC0, 0xFF, 0xFC, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x04,
  0x80, 0x19, 0x80, 0x33, 0x80, 0xC3, 0x83, 0x03, 0xFC, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04,
  0x20, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30,
  0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0x34, 0x00, 0x60, 0x02, 0x40, 0x06, 0x00, 0x66, 0x00, 0xE0, 0x06,
  0x60, 0x0E, 0x00, 0x66, 0x00, 0xB0, 0x04, 0x20, 0x0B, 0x00, 0xC2, 0x00,
  0x90, 0x0C, 0x30, 0x19, 0x00, 0xC3, 0x01, 0x90, 0x0C, 0x30, 0x19, 0x80,
  0x81, 0x01, 0x18, 0x18, 0x10, 0x10, 0x81, 0x81, 0x83, 0x08, 0x18, 0x18,
  0x30, 0x81, 0x01, 0x83, 0x0C, 0x10, 0x08, 0x20, 0xC3, 0x00, 0xC2, 0x04,
  0x30, 0x0C, 0x60, 0x43, 0x00, 0xC6, 0x04, 0x20, 0x04, 0x60, 0x62, 0x00,
  0x44, 0x06, 0x60, 0x06, 0x40, 0x26, 0x00, 0x6C, 0x02, 0x60, 0x06, 0xC0,
  0x24, 0x00, 0x2C, 0x03, 0xC0, 0x02, 0x80, 0x3C, 0x00, 0x28, 0x01, 0xC0,
  0x03, 0x80, 0x18, 0x00, 0x38, 0x01, 0x80, 0x60, 0x0C, 0xC0, 0x23, 0x01,
  0x84, 0x06, 0x18, 0x10, 0x60, 0xC0, 0x83, 0x03, 0x08, 0x0C, 0x60, 0x11,
  0x00, 0x6C, 0x00, 0xB0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x02,
  0x80, 0x1B, 0x00, 0x6C, 0x01, 0x10, 0x0C, 0x60, 0x21, 0x81, 0x82, 0x06,
  0x0C, 0x10, 0x30, 0xC0, 0x62, 0x01, 0x98, 0x02, 0x60, 0x0F, 0x00, 0x30,
  0xC0, 0x0F, 0x00, 0x24, 0x01, 0x98, 0x06, 0x20, 0x10, 0x80, 0xC3, 0x03,
  0x04, 0x08, 0x10, 0x60, 0x61, 0x80, 0x84, 0x02, 0x30, 0x0C, 0xC0, 0x12,
  0x00, 0x48, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01,
  0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0xFF, 0x01, 0x80, 0x07, 0x00, 0x0B, 0x00, 0x36, 0x00, 0x44, 0x01, 0x8C,
  0x02, 0x08, 0x0C, 0x18, 0x18, 0x10, 0x60, 0x30, 0xC0, 0x23, 0x00, 0x66,
  0x00, 0x58, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0xC1, 0x86, 0x0C,
  0x18, 0x30, 0x40, 0x04, 0x0F, 0xF1, 0x83, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0x8F, 0xB7, 0x06, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x5C, 0x0A, 0xC2, 0x4F, 0x88, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x18, 0x33, 0xF1, 0xA0, 0xCE, 0x03, 0x50, 0x0B, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x2A, 0x03, 0x50, 0x1A,
  0x63, 0x91, 0xF8, 0x03, 0x01, 0xFC, 0x60, 0x98, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x70, 0x43, 0xF8, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x38, 0x47, 0xF2, 0x60, 0xD6, 0x02, 0xB0, 0x0D, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x06, 0x80, 0x36, 0x02, 0xB0, 0x14,
  0xE3, 0x23, 0xF1, 0x02, 0x01, 0xFC, 0x30, 0x62, 0x06, 0x60, 0x34, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x11, 0x83,
  0x0F, 0xE0, 0x07, 0xC3, 0x90, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x0F, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x06, 0x00, 0xFE, 0x4C, 0x1A, 0xC0,
  0x56, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xD0,
  0x06, 0xC0, 0x56, 0x02, 0x9C, 0x64, 0x7E, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1A, 0x00, 0xCE, 0x3C, 0x3F, 0x80,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x70, 0xCF, 0xC9, 0x0E, 0xA0, 0x6A, 0x02, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xBE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xC6, 0x20, 0x00,
  0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x88, 0x56, 0xE0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x03, 0x60, 0x4C, 0x19, 0x86, 0x30, 0xC6, 0x30, 0xC4, 0x11, 0x82, 0x60,
  0x4E, 0x0B, 0x41, 0x4C, 0x31, 0x86, 0x18, 0xC3, 0x18, 0x23, 0x06, 0x60,
  0x4C, 0x0D, 0x81, 0xB0, 0x16, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x06, 0x01, 0x09, 0xF8, 0xFE, 0xB0, 0xC8, 0x6A, 0x05, 0x03,
  0xC0, 0x70, 0x3C, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60,
  0x1C, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06,
  0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0,
  0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60, 0x10,
  0x02, 0x08, 0xFC, 0x90, 0x6A, 0x06, 0xA0, 0x2C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x03,
  0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x01, 0x20, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x22, 0x03, 0x1C, 0x30, 0x7F,
  0x00, 0x03, 0x04, 0x7E, 0x24, 0x19, 0x40, 0x6A, 0x01, 0x60, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x05, 0x40, 0x6B, 0x03, 0x4C,
  0x73, 0x3F, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0xFE, 0x4C, 0x1A,
  0x40, 0x56, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xD0, 0x06, 0xC0, 0x53, 0x02, 0x9C, 0x64, 0x7E, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x02, 0x8F, 0x98, 0xB0, 0xA0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x02, 0x03, 0xFC, 0xC1, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x38, 0x05, 0xC3, 0x9F, 0xE0, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x07, 0xC0, 0x74, 0x0B, 0x61, 0xB3, 0xF3, 0xC0, 0x1A, 0x00,
  0x90, 0x0C, 0xC0, 0x66, 0x03, 0x10, 0x10, 0x80, 0x86, 0x0C, 0x30, 0x60,
  0x82, 0x04, 0x10, 0x31, 0x81, 0x8C, 0x0C, 0x40, 0x22, 0x01, 0x30, 0x0D,
  0x80, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x30, 0x0D,
  0x00, 0xE0, 0x36, 0x03, 0x80, 0x98, 0x0A, 0x02, 0x60, 0x68, 0x18, 0x81,
  0xA0, 0x62, 0x04, 0xC1, 0x0C, 0x13, 0x04, 0x30, 0x44, 0x30, 0x43, 0x10,
  0xC1, 0x0C, 0x43, 0x06, 0x21, 0x88, 0x18, 0x86, 0x20, 0x66, 0x09, 0x80,
  0x98, 0x26, 0x02, 0x60, 0x90, 0x0D, 0x03, 0x40, 0x34, 0x0D, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x70, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x36,
  0x06, 0x60, 0x62, 0x0C, 0x30, 0xC1, 0x08, 0x19, 0x80, 0x90, 0x0F, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0F, 0x00, 0x90, 0x19, 0x81, 0x18, 0x30, 0xC2,
  0x0C, 0x60, 0x46, 0x06, 0xC0, 0x2C, 0x03, 0x60, 0x0B, 0x00, 0xD8, 0x06,
  0x40, 0x23, 0x01, 0x18, 0x18, 0xC0, 0xC2, 0x04, 0x18, 0x20, 0xC3, 0x06,
  0x18, 0x10, 0x80, 0xC4, 0x06, 0x60, 0x33, 0x00, 0x90, 0x04, 0x80, 0x3C,
  0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x02, 0xE0, 0x1E, 0x00, 0x7F,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x07, 0xFC,
  0x01, 0xE0, 0x78, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x0F,
  0x03, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0xF0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0F, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x78, 0x07, 0x81, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x60, 0x7C, 0x0C, 0x00, 0x1C, 0x02, 0xFE, 0x07, 0x07, 0x3C, 0x03,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 30, 8, 3, -30 },
  { 13, 7, 11, 13, 3, -30 },
  { 23, 16, 30, 18, 1, -30 },
  { 83, 14, 34, 17, 1, -32 },
  { 143, 21, 30, 25, 2, -30 },
  { 222, 16, 30, 17, 1, -30 },
  { 282, 2, 11, 7, 3, -30 },
  { 285, 8, 37, 11, 2, -30 },
  { 322, 7, 37, 11, 2, -30 },
  { 355, 11, 11, 15, 2, -32 },
  { 371, 15, 20, 17, 1, -25 },
  { 409, 4, 9, 8, 2, -4 },
  { 414, 9, 1, 11, 1, -12 },
  { 416, 2, 3, 8, 3, -3 },
  { 417, 12, 30, 14, 1, -30 },
  { 462, 13, 30, 17, 2, -30 },
  { 511, 8, 30, 17, 3, -30 },
  { 541, 13, 30, 17, 2, -30 },
  { 590, 13, 30, 17, 2, -30 },
  { 639, 15, 30, 17, 1, -30 },
  { 696, 13, 30, 17, 2, -30 },
  { 745, 13, 31, 17, 2, -30 },
  { 796, 13, 30, 17, 2, -30 },
  { 845, 13, 30, 17, 2, -30 },
  { 894, 13, 30, 17, 2, -30 },
  { 943, 2, 22, 8, 3, -22 },
  { 949, 4, 27, 8, 2, -22 },
  { 963, 15, 18, 17, 1, -24 },
  { 997, 15, 10, 17, 1, -20 },
  { 1016, 15, 18, 17, 1, -24 },
  { 1050, 10, 30, 12, 1, -30 },
  { 1088, 22, 34, 26, 2, -30 },
  { 1182, 16, 30, 16, 0, -30 },
  { 1242, 14, 30, 18, 3, -30 },
  { 1295, 15, 30, 18, 2, -30 },
  { 1352, 15, 30, 20, 3, -30 },
  { 1409, 11, 30, 16, 3, -30 },
  { 1451, 11, 30, 15, 3, -30 },
  { 1493, 18, 30, 22, 2, -30 },
  { 1561, 15, 30, 21, 3, -30 },
  { 1618, 6, 30, 10, 2, -30 },
  { 1641, 7, 38, 8, -2, -30 },
  { 1675, 14, 30, 17, 3, -30 },
  { 1728, 11, 30, 15, 3, -30 },
  { 1770, 22, 30, 28, 3, -30 },
  { 1853, 16, 30, 22, 3, -30 },
  { 1913, 18, 30, 22, 2, -30 },
  { 1981, 13, 30, 17, 3, -30 },
  { 2030, 18, 37, 22, 2, -30 },
  { 2114, 14, 30, 17, 3, -30 },
  { 2167, 13, 30, 17, 2, -30 },
  { 2216, 14, 30, 14, 0, -30 },
  { 2269, 15, 30, 21, 3, -30 },
  { 2326, 16, 30, 16, 0, -30 },
  { 2386, 28, 30, 28, 0, -30 },
  { 2491, 14, 30, 14, 0, -30 },
  { 2544, 14, 30, 14, 0, -30 },
  { 2597, 12, 30, 14, 1, -30 },
  { 2642, 8, 37, 13, 3, -30 },
  { 2679, 12, 30, 14, 1, -30 },
  { 2724, 8, 37, 13, 1, -30 },
  { 2761, 15, 15, 17, 1, -30 },
  { 2790, 17, 1, 17, 0, 4 },
  { 2793, 6, 7, 10, 2, -32 },
  { 2799, 11, 23, 16, 2, -23 },
  { 2831, 13, 32, 18, 3, -32 },
  { 2883, 11, 23, 13, 2, -23 },
  { 2915, 13, 32, 18, 2, -32 },
  { 2967, 12, 23, 16, 2, -23 },
  { 3002, 10, 32, 9, 0, -32 },
  { 3042, 13, 33, 18, 2, -23 },
  { 3096, 12, 32, 18, 3, -32 },
  { 3144, 2, 31, 8, 3, -31 },
  { 3152, 5, 41, 8, 0, -31 },
  { 3178, 11, 32, 14, 3, -32 },
  { 3222, 2, 32, 7, 3, -32 },
  { 3230, 20, 23, 26, 3, -23 },
  { 3288, 12, 23, 18, 3, -23 },
  { 3323, 13, 23, 17, 2, -23 },
  { 3361, 13, 33, 18, 3, -23 },
  { 3415, 13, 33, 18, 2, -23 },
  { 3469, 8, 23, 11, 3, -23 },
  { 3492, 11, 23, 13, 1, -23 },
  { 3524, 8, 28, 9, 1, -28 },
  { 3552, 12, 22, 18, 3, -22 },
  { 3585, 13, 22, 13, 0, -22 },
  { 3621, 22, 22, 22, 0, -22 },
  { 3682, 12, 22, 14, 1, -22 },
  { 3715, 13, 32, 14, 0, -22 },
  { 3767, 9, 22, 11, 1, -22 },
  { 3792, 11, 37, 15, 2, -30 },
  { 3843, 2, 42, 16, 7, -32 },
  { 3854, 11, 37, 15, 2, -30 },
  { 3905, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT42PT7B_H_
