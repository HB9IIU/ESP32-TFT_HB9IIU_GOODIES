#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00,
  0x00, 0x00, 0x03, 0x9D, 0xF7, 0x38, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x6E, 0x06, 0xE0, 0x66, 0x06, 0x40, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x01, 0xC0,
  0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x06, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0xFA, 0x7F, 0x07, 0x08, 0x18, 0x38, 0x20, 0x01, 0xC0, 0x80, 0x06,
  0x02, 0x00, 0x18, 0x08, 0x00, 0xE0, 0x20, 0x03, 0x80, 0x80, 0x0C, 0x02,
  0x00, 0x30, 0x08, 0x00, 0xE0, 0x20, 0x03, 0x80, 0x80, 0x06, 0x02, 0x00,
  0x1C, 0x08, 0x00, 0x30, 0x20, 0x00, 0xE0, 0x80, 0x01, 0xE2, 0x00, 0x03,
  0xC8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x27, 0xC0, 0x00, 0x87, 0x80, 0x02, 0x0F, 0x00, 0x08, 0x1C,
  0x00, 0x20, 0x38, 0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00,
  0x20, 0x1C, 0x00, 0x80, 0x70, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20,
  0x18, 0x00, 0x80, 0xC0, 0x02, 0x07, 0x30, 0x08, 0x38, 0xF8, 0x23, 0xC1,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x80,
  0x03, 0x80, 0x3F, 0xC0, 0x03, 0x00, 0x30, 0xE0, 0x03, 0x00, 0x70, 0x60,
  0x06, 0x00, 0x60, 0x70, 0x06, 0x00, 0x60, 0x30, 0x06, 0x00, 0xE0, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x38,
  0x18, 0x00, 0xC0, 0x38, 0x18, 0x00, 0xC0, 0x38, 0x18, 0x00, 0xC0, 0x18,
  0x38, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18,
  0x70, 0x00, 0xC0, 0x38, 0x60, 0x00, 0xC0, 0x38, 0x60, 0x00, 0xC0, 0x38,
  0xE1, 0xF0, 0xC0, 0x30, 0xC3, 0xF8, 0xC0, 0x30, 0xC7, 0x1C, 0xE0, 0x31,
  0xC6, 0x0C, 0x60, 0x31, 0x8C, 0x06, 0x60, 0x71, 0x8C, 0x06, 0x70, 0x63,
  0x8C, 0x06, 0x30, 0xE3, 0x0C, 0x07, 0x3F, 0xC3, 0x1C, 0x07, 0x0F, 0x87,
  0x18, 0x03, 0x00, 0x06, 0x18, 0x03, 0x00, 0x06, 0x18, 0x03, 0x00, 0x0E,
  0x18, 0x03, 0x00, 0x0C, 0x18, 0x03, 0x00, 0x0C, 0x18, 0x03, 0x00, 0x1C,
  0x18, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x38,
  0x18, 0x03, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x30, 0x0C, 0x07, 0x00, 0x70,
  0x0C, 0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xE0,
  0x06, 0x0E, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x03, 0xB8, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x30, 0x00,
  0x38, 0x38, 0x0E, 0x30, 0x18, 0x0C, 0x70, 0x1C, 0x0C, 0x60, 0x0C, 0x0C,
  0xE0, 0x06, 0x0C, 0xE0, 0x06, 0x0C, 0xE0, 0x03, 0x1C, 0xC0, 0x03, 0x98,
  0xC0, 0x01, 0x98, 0xC0, 0x01, 0xF8, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x60, 0x01, 0xF8, 0x70, 0x01, 0x98,
  0x38, 0x03, 0x9C, 0x3C, 0x0F, 0x0C, 0x1F, 0xFE, 0x0E, 0x07, 0xF8, 0x07,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xDB, 0x60, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x06,
  0x0D, 0xF1, 0x1F, 0x3F, 0xFC, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x6C, 0x00,
  0x67, 0x00, 0x61, 0x80, 0x70, 0x60, 0x30, 0x18, 0x30, 0x0E, 0x08, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x71, 0xC7,
  0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x1C, 0x61, 0x8E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x6F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x00, 0xC0, 0x30, 0x1C,
  0x03, 0x83, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC7,
  0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03,
  0x00, 0xF0, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x1C, 0x07,
  0x83, 0xB0, 0xF6, 0x3C, 0xCF, 0x1B, 0x83, 0xE0, 0x78, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0x01, 0xE0, 0x60, 0x07, 0x82, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE1, 0xE0, 0x07, 0x86,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x20, 0x00, 0x70, 0xE0, 0x0F, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01,
  0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x80, 0x07, 0x8E, 0x00,
  0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xFC, 0x03, 0xE0, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xFC, 0x0E, 0x3F, 0xF0, 0xE7,
  0x07, 0x8E, 0xC0, 0x38, 0xF8, 0x01, 0xCF, 0x00, 0x0C, 0xF0, 0x00, 0xEE,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00,
  0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC1, 0xE0, 0x38, 0x0F,
  0xDF, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x03,
  0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x06, 0x70,
  0x00, 0x33, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xE0, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70,
  0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00,
  0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x38, 0x00, 0x39, 0x80, 0x00, 0xEC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x31, 0xC0, 0x03, 0x8F, 0x00, 0x38, 0x3C, 0x03, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0x07, 0x01, 0xC0, 0x38, 0x18, 0x01, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xE7,
  0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x30, 0x00, 0xF3, 0x80, 0x0B, 0x18, 0x01, 0xB1, 0xE0, 0x33, 0x0F,
  0xFE, 0x30, 0x7F, 0xC3, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x1C, 0xF3, 0xCF,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E,
  0x30, 0xC7, 0x18, 0x63, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0x81,
  0xE2, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x07, 0xE0, 0x18, 0xC0, 0x0F, 0xF8, 0x0C,
  0x60, 0x0E, 0x0C, 0x06, 0x70, 0x0E, 0x06, 0x03, 0x38, 0x06, 0x03, 0x01,
  0xD8, 0x06, 0x03, 0x80, 0x6C, 0x03, 0x01, 0xC0, 0x36, 0x03, 0x80, 0xE0,
  0x1B, 0x01, 0x80, 0x70, 0x0D, 0x80, 0xC0, 0x38, 0x07, 0xC0, 0x60, 0x1C,
  0x03, 0xE0, 0x30, 0x0C, 0x01, 0xF0, 0x18, 0x06, 0x00, 0xF8, 0x0C, 0x03,
  0x00, 0x7C, 0x06, 0x01, 0x80, 0x3E, 0x03, 0x00, 0xC0, 0x1F, 0x01, 0x80,
  0x60, 0x1F, 0x80, 0xC0, 0x30, 0x0E, 0xC0, 0x60, 0x38, 0x06, 0x60, 0x30,
  0x1C, 0x03, 0x30, 0x1C, 0x0B, 0x01, 0x98, 0x06, 0x0D, 0x81, 0x8C, 0x03,
  0x86, 0xC1, 0xC6, 0x00, 0xE6, 0x39, 0xC3, 0x80, 0x7F, 0x1F, 0xC0, 0xC0,
  0x0E, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0x80, 0x07, 0x8C, 0x00, 0x1C, 0x60, 0x00,
  0x73, 0x00, 0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0,
  0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80,
  0x07, 0x0C, 0x00, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x18, 0x01, 0xF0,
  0xC0, 0x03, 0xC6, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x00, 0xEC, 0x00,
  0x07, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0xE6, 0x00, 0x0F, 0x30,
  0x00, 0xF1, 0x80, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0x01, 0xC0, 0xF0, 0x01, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x30, 0x03, 0xE0, 0xC0, 0x03, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x38, 0xC0, 0x01,
  0xC3, 0x00, 0x0F, 0x0C, 0x00, 0x78, 0x30, 0x0F, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0xF0, 0x00, 0x60, 0x38, 0x00, 0x04,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x60, 0xF0, 0x00, 0x0C, 0x0F, 0x00, 0x01, 0x80, 0xF8, 0x00, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0xA0, 0xE7, 0xFC, 0xFF, 0x00, 0xC0, 0x00,
  0x7C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00,
  0x38, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0,
  0x1C, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C,
  0x0E, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x70, 0x00,
  0xC7, 0x00, 0x0C, 0xF0, 0x00, 0xCF, 0x80, 0x0D, 0x98, 0x00, 0xD9, 0xC0,
  0x0F, 0x0C, 0x00, 0xE0, 0xE0, 0x0E, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x0C, 0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0,
  0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x8C,
  0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x0E,
  0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xC0, 0x00,
  0x00, 0x7F, 0x60, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0x37, 0xCC, 0x00,
  0x00, 0x1B, 0xE6, 0x00, 0x00, 0x1D, 0xF3, 0x00, 0x00, 0x0C, 0xF9, 0xC0,
  0x00, 0x06, 0x7C, 0x60, 0x00, 0x07, 0x3E, 0x30, 0x00, 0x03, 0x1F, 0x1C,
  0x00, 0x01, 0x8F, 0x86, 0x00, 0x00, 0xC7, 0xC3, 0x00, 0x00, 0xE3, 0xE1,
  0xC0, 0x00, 0x61, 0xF0, 0x60, 0x00, 0x30, 0xF8, 0x30, 0x00, 0x38, 0x7C,
  0x18, 0x00, 0x18, 0x3E, 0x0E, 0x00, 0x0C, 0x1F, 0x03, 0x00, 0x0E, 0x0F,
  0x81, 0x80, 0x06, 0x07, 0xC0, 0xE0, 0x03, 0x03, 0xE0, 0x30, 0x01, 0x81,
  0xF0, 0x18, 0x01, 0xC0, 0xF8, 0x0E, 0x00, 0xC0, 0x7C, 0x03, 0x00, 0x60,
  0x3E, 0x01, 0x80, 0x70, 0x1F, 0x00, 0xE0, 0x30, 0x0F, 0x80, 0x70, 0x18,
  0x07, 0xC0, 0x18, 0x1C, 0x03, 0xE0, 0x0C, 0x0C, 0x01, 0xF0, 0x07, 0x06,
  0x00, 0xF8, 0x01, 0x83, 0x00, 0x7C, 0x00, 0xC3, 0x80, 0x3E, 0x00, 0x71,
  0x80, 0x1F, 0x00, 0x18, 0xC0, 0x0F, 0x80, 0x0C, 0xE0, 0x07, 0xC0, 0x07,
  0x60, 0x03, 0xE0, 0x03, 0xB0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7B, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xCC, 0x00,
  0x07, 0x9C, 0x00, 0x0F, 0x18, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x30, 0x00,
  0x78, 0x70, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0xC0, 0x03, 0xC1, 0xC0, 0x07,
  0x81, 0x80, 0x0F, 0x03, 0x80, 0x1E, 0x03, 0x00, 0x3C, 0x07, 0x00, 0x78,
  0x06, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80,
  0x38, 0x0F, 0x00, 0x30, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0x60, 0x78, 0x00,
  0xE0, 0xF0, 0x00, 0xC1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x03,
  0x0F, 0x00, 0x07, 0x1E, 0x00, 0x06, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0C,
  0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x60, 0x07,
  0x8C, 0x00, 0x79, 0x80, 0x07, 0x30, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x00,
  0xD8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x01, 0xE6, 0x00, 0x78,
  0xC1, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x70, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0C, 0x00, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E,
  0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00,
  0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00,
  0x70, 0xC0, 0x0F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xC0,
  0x70, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0x01, 0xE3, 0xC0, 0x04, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x80, 0x03,
  0x8E, 0x00, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0x98,
  0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0x80, 0x0F, 0x07, 0x80,
  0x78, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00,
  0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x81,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xC3,
  0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0x80, 0x00, 0x76, 0x00, 0x01, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x78, 0x00,
  0x06, 0x70, 0x00, 0x1E, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x80, 0x00, 0xE3,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0xC0, 0x00, 0xFC, 0x00, 0x0C, 0x38, 0x00,
  0x3B, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x30,
  0x00, 0x70, 0x60, 0x00, 0xCC, 0x00, 0x1C, 0x18, 0x00, 0x73, 0x80, 0x06,
  0x07, 0x00, 0x1C, 0x60, 0x01, 0x81, 0xC0, 0x06, 0x18, 0x00, 0xE0, 0x30,
  0x01, 0x86, 0x00, 0x38, 0x0C, 0x00, 0x61, 0x80, 0x0E, 0x03, 0x00, 0x18,
  0x70, 0x03, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x0E, 0x01, 0x80, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x00, 0x30, 0x18, 0x06,
  0x03, 0x00, 0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x30, 0x70,
  0x00, 0xE0, 0xC0, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x03, 0x07, 0x00, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0,
  0x06, 0x38, 0x00, 0x0C, 0x60, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00,
  0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x37, 0x00, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x33, 0x80, 0x03, 0x8C,
  0x00, 0x1C, 0x70, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x70, 0x07,
  0x01, 0x80, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x01, 0x80, 0xC0, 0x0E,
  0x06, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0E, 0x18, 0x00, 0x31, 0xC0,
  0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0xC7,
  0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x18, 0x03,
  0x80, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x07,
  0x07, 0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x18, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xD8, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x30, 0xE0,
  0x01, 0x87, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xE0, 0x06, 0x07, 0x00, 0x70,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xE0,
  0x60, 0x07, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3, 0x80,
  0x01, 0xC1, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x30,
  0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x70,
  0x1C, 0x10, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0xFF, 0xC1, 0xFE, 0x70, 0xF0, 0x1C, 0x70,
  0x07, 0x38, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x03, 0xD8, 0x00, 0xB7,
  0x00, 0x2D, 0xC0, 0x1B, 0x38, 0x0C, 0xC7, 0xCE, 0x30, 0xFF, 0x0C, 0x06,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x40, 0x1C, 0x3F, 0xC0, 0xE3, 0xFF, 0x87, 0x38, 0x1C,
  0x3B, 0x00, 0x71, 0xD0, 0x01, 0xCF, 0x80, 0x06, 0x78, 0x00, 0x3B, 0xC0,
  0x01, 0xDE, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xF0, 0x00,
  0x37, 0x80, 0x03, 0xBC, 0x00, 0x19, 0xF0, 0x01, 0xCE, 0x80, 0x0E, 0x76,
  0x00, 0xE3, 0x98, 0x0E, 0x1C, 0x7F, 0xE0, 0xC1, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x10, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0x01, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x40, 0x30, 0x3F, 0xC3, 0x0F, 0xFE, 0x31, 0xE0, 0x73, 0x1C, 0x03,
  0xB3, 0x80, 0x1B, 0x30, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0xF7, 0x00, 0x0F, 0x38, 0x01, 0xB3, 0x80, 0x1B, 0x1C, 0x07, 0x30, 0xFF,
  0xE3, 0x07, 0xFC, 0x30, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x3F,
  0xF8, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x70, 0x03, 0x0C, 0x00, 0x63, 0x80,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x02, 0x0E, 0x01,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x07, 0xFC,
  0x0E, 0x10, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC3, 0x0F, 0xFE, 0x31,
  0xE0, 0x73, 0x1C, 0x01, 0xB3, 0x80, 0x0B, 0x30, 0x00, 0xF7, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0B, 0x38, 0x01, 0xB3, 0x80, 0x33,
  0x1E, 0x07, 0x30, 0xFF, 0xE3, 0x07, 0xFC, 0x30, 0x0E, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x40,
  0x03, 0xC7, 0x00, 0x78, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x02, 0x03, 0x87, 0xF8, 0xE3, 0xFF, 0x39,
  0xC1, 0xEE, 0xC0, 0x3B, 0xA0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xC0,
  0x2F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x04, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x1C,
  0xFC, 0xF8, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0x87, 0x01,
  0xC3, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x60, 0x38, 0x70, 0x1C,
  0x70, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9F, 0x01, 0xD9, 0x80, 0xFC, 0xE0,
  0x7C, 0x30, 0x3C, 0x18, 0x1C, 0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC3, 0x80,
  0x61, 0xC0, 0x30, 0xE0, 0x1C, 0x70, 0x06, 0x38, 0x03, 0x9C, 0x00, 0xCE,
  0x00, 0x67, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x80, 0xC3, 0xFC,
  0x07, 0xF0, 0xC7, 0xFE, 0x1F, 0xF8, 0xCE, 0x0E, 0x18, 0x3C, 0xCC, 0x07,
  0x30, 0x1C, 0xD8, 0x03, 0x60, 0x0E, 0xF0, 0x03, 0xE0, 0x06, 0xF0, 0x03,
  0xC0, 0x06, 0xF0, 0x01, 0xC0, 0x06, 0xE0, 0x01, 0xC0, 0x06, 0xE0, 0x01,
  0x80, 0x06, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x20, 0x30, 0x7F, 0x8C, 0x3F, 0xF3, 0x1C, 0x1E, 0xCC,
  0x03, 0xB2, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x1C, 0x01, 0xC3, 0x80, 0x0C,
  0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x0E,
  0x38, 0x00, 0xC1, 0xC0, 0x1C, 0x1E, 0x03, 0x80, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x06, 0x0F, 0xF0, 0x30, 0xFF, 0xE1, 0x8E,
  0x07, 0x0C, 0xC0, 0x1C, 0x66, 0x00, 0x73, 0x60, 0x01, 0x9A, 0x00, 0x0C,
  0xF0, 0x00, 0x77, 0x80, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xBC,
  0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x06, 0x7C, 0x00, 0x73, 0xA0, 0x03,
  0x1D, 0x80, 0x38, 0xE6, 0x03, 0x87, 0x1F, 0xF8, 0x38, 0x7F, 0x81, 0xC0,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC3, 0x07, 0xFE, 0x30, 0xE0,
  0x73, 0x1C, 0x01, 0xB3, 0x80, 0x1B, 0x30, 0x00, 0xF7, 0x00, 0x0F, 0x70,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x70, 0x00, 0xF3, 0x00, 0x0B, 0x38, 0x01, 0xB1, 0xC0, 0x33, 0x1E,
  0x07, 0x30, 0xFF, 0xE3, 0x07, 0xFC, 0x30, 0x0E, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC1, 0xFE, 0x1F, 0xB1,
  0xC3, 0xDC, 0x0E, 0xC0, 0x74, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x40, 0x07, 0xFC, 0x1F, 0xFF, 0x3C, 0x06,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC,
  0x3F, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xC0, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07,
  0x60, 0x03, 0xDC, 0x00, 0xB7, 0x00, 0x6C, 0xE0, 0x33, 0x1F, 0xF8, 0xC3,
  0xFC, 0x30, 0x18, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x38,
  0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x18,
  0x18, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0xE0, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1B,
  0x80, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0x60,
  0x06, 0x60, 0x07, 0x60, 0x06, 0x70, 0x07, 0x60, 0x0E, 0x70, 0x06, 0x60,
  0x0E, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x70, 0x0C, 0x30, 0x0E, 0x30,
  0x0C, 0x38, 0x0C, 0x30, 0x1C, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x0C, 0x38,
  0x18, 0x18, 0x0C, 0x18, 0x18, 0x1C, 0x1C, 0x18, 0x38, 0x1C, 0x18, 0x18,
  0x38, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x1C, 0x30, 0x0C, 0x38, 0x0C,
  0x30, 0x0E, 0x38, 0x0C, 0x70, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x30, 0x0C,
  0x60, 0x06, 0x30, 0x0E, 0x60, 0x07, 0x70, 0x06, 0x60, 0x07, 0x60, 0x06,
  0xE0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xEE, 0x00, 0x38, 0xC0, 0x07,
  0x1C, 0x01, 0xC1, 0x80, 0x38, 0x38, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x0E, 0x0E, 0x00, 0xC1, 0x80, 0x1C, 0x70, 0x01, 0x8C, 0x00, 0x3B, 0x80,
  0x03, 0x60, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00,
  0x30, 0x60, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x81,
  0x80, 0x30, 0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0E, 0x60, 0x00, 0xDC,
  0x00, 0x1C, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x77,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x38, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0xC1, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03,
  0x06, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03,
  0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x00, 0x17, 0xFF, 0x00, 0xF8, 0x1F, 0x07, 0x80, 0x1F,
  0xFA, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 46, 13, 4, -46 },
  { 30, 12, 17, 20, 4, -46 },
  { 56, 25, 46, 28, 1, -46 },
  { 200, 22, 53, 26, 2, -49 },
  { 346, 32, 47, 38, 3, -46 },
  { 534, 24, 47, 26, 2, -46 },
  { 675, 3, 17, 11, 4, -46 },
  { 682, 12, 56, 17, 3, -46 },
  { 766, 12, 56, 17, 2, -46 },
  { 850, 17, 18, 22, 3, -49 },
  { 889, 22, 29, 26, 2, -37 },
  { 969, 6, 15, 12, 2, -7 },
  { 981, 13, 3, 17, 2, -19 },
  { 986, 4, 5, 12, 4, -5 },
  { 989, 18, 46, 22, 2, -46 },
  { 1093, 20, 46, 26, 3, -46 },
  { 1208, 11, 46, 26, 5, -46 },
  { 1272, 21, 46, 26, 2, -46 },
  { 1393, 21, 47, 26, 2, -46 },
  { 1517, 24, 46, 26, 1, -46 },
  { 1655, 20, 47, 26, 3, -46 },
  { 1773, 20, 47, 26, 3, -46 },
  { 1891, 20, 46, 26, 3, -46 },
  { 2006, 21, 47, 26, 2, -46 },
  { 2130, 20, 47, 26, 2, -46 },
  { 2248, 4, 34, 12, 4, -34 },
  { 2265, 6, 42, 12, 2, -34 },
  { 2297, 22, 27, 26, 2, -36 },
  { 2372, 22, 16, 26, 2, -31 },
  { 2416, 22, 27, 26, 2, -36 },
  { 2491, 15, 46, 18, 1, -46 },
  { 2578, 33, 52, 39, 3, -46 },
  { 2793, 25, 46, 25, 0, -46 },
  { 2937, 21, 46, 28, 5, -46 },
  { 3058, 22, 47, 27, 3, -46 },
  { 3188, 22, 46, 31, 5, -46 },
  { 3315, 17, 46, 25, 5, -46 },
  { 3413, 17, 46, 23, 5, -46 },
  { 3511, 27, 47, 34, 3, -46 },
  { 3670, 22, 46, 32, 5, -46 },
  { 3797, 10, 46, 15, 2, -46 },
  { 3855, 11, 57, 12, -3, -46 },
  { 3934, 20, 46, 25, 5, -46 },
  { 4049, 16, 46, 22, 5, -46 },
  { 4141, 33, 46, 43, 5, -46 },
  { 4331, 23, 46, 33, 5, -46 },
  { 4464, 27, 47, 33, 3, -46 },
  { 4623, 19, 46, 26, 5, -46 },
  { 4733, 27, 57, 33, 3, -46 },
  { 4926, 20, 46, 27, 5, -46 },
  { 5041, 20, 47, 25, 3, -46 },
  { 5159, 21, 46, 22, 1, -46 },
  { 5280, 22, 47, 32, 5, -46 },
  { 5410, 24, 46, 24, 0, -46 },
  { 5548, 42, 46, 42, 0, -46 },
  { 5790, 21, 46, 22, 1, -46 },
  { 5911, 21, 46, 21, 0, -46 },
  { 6032, 18, 46, 21, 2, -46 },
  { 6136, 12, 56, 20, 5, -46 },
  { 6220, 18, 46, 22, 2, -46 },
  { 6324, 12, 56, 20, 2, -46 },
  { 6408, 24, 23, 26, 1, -46 },
  { 6477, 26, 2, 26, 0, 6 },
  { 6484, 9, 10, 15, 3, -49 },
  { 6496, 18, 36, 24, 2, -35 },
  { 6577, 21, 50, 28, 4, -49 },
  { 6709, 16, 36, 20, 3, -35 },
  { 6781, 20, 50, 28, 3, -49 },
  { 6906, 19, 36, 25, 3, -35 },
  { 6992, 15, 49, 14, 1, -49 },
  { 7084, 20, 50, 28, 3, -35 },
  { 7209, 18, 49, 27, 4, -49 },
  { 7320, 4, 47, 12, 4, -47 },
  { 7344, 8, 62, 12, 0, -47 },
  { 7406, 17, 49, 22, 4, -49 },
  { 7511, 3, 49, 11, 4, -49 },
  { 7530, 32, 35, 40, 4, -35 },
  { 7670, 18, 35, 27, 4, -35 },
  { 7749, 20, 36, 26, 3, -35 },
  { 7839, 21, 50, 28, 4, -35 },
  { 7971, 20, 50, 28, 3, -35 },
  { 8096, 13, 34, 17, 4, -34 },
  { 8152, 16, 36, 20, 2, -35 },
  { 8224, 12, 43, 14, 1, -42 },
  { 8289, 18, 35, 27, 4, -34 },
  { 8368, 19, 34, 20, 0, -34 },
  { 8449, 32, 34, 34, 1, -34 },
  { 8585, 19, 34, 21, 1, -34 },
  { 8666, 19, 49, 21, 1, -34 },
  { 8783, 14, 34, 17, 2, -34 },
  { 8843, 16, 56, 22, 3, -46 },
  { 8955, 2, 64, 25, 11, -49 },
  { 8971, 16, 56, 22, 3, -46 },
  { 9083, 22, 6, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT64PT7B_H_
