#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA8, 0x30, 0x99, 0x99, 0x90, 0x12, 0x12, 0x12, 0x14,
  0x7F, 0x24, 0x24, 0x24, 0x24, 0xFE, 0x24, 0x24, 0x48, 0x48, 0x21, 0xEA,
  0x28, 0xA2, 0x86, 0x0C, 0x28, 0x92, 0x49, 0xA9, 0xC2, 0x00, 0x62, 0x51,
  0x24, 0x92, 0x89, 0x44, 0xAA, 0x6B, 0x55, 0x6C, 0x8A, 0x45, 0x22, 0x92,
  0x29, 0x1C, 0x20, 0xA2, 0x44, 0x85, 0x0A, 0x08, 0x30, 0x95, 0x2A, 0x34,
  0x28, 0xCE, 0x40, 0xF8, 0x25, 0x29, 0x24, 0x92, 0x48, 0x91, 0x20, 0x91,
  0x22, 0x49, 0x24, 0x92, 0x92, 0x80, 0x25, 0xD8, 0xA9, 0x00, 0x20, 0x82,
  0x08, 0xFC, 0x82, 0x08, 0x20, 0xF0, 0xF8, 0x80, 0x04, 0x10, 0x82, 0x08,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x00, 0x31, 0x28, 0xA1, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x62, 0x49, 0xC0, 0x13, 0xD1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x72, 0x20, 0x81, 0x04, 0x20, 0x82, 0x10, 0x82, 0x10, 0x83, 0xF0,
  0x72, 0x20, 0x41, 0x04, 0x27, 0x04, 0x08, 0x10, 0x41, 0x0B, 0xC0, 0x04,
  0x18, 0x30, 0xA1, 0x44, 0x89, 0x22, 0x45, 0x0B, 0xF8, 0x20, 0x40, 0x80,
  0xFA, 0x08, 0x20, 0x82, 0x0F, 0x82, 0x04, 0x10, 0x41, 0x0B, 0xC0, 0x39,
  0x04, 0x20, 0x82, 0x0F, 0xA1, 0x86, 0x18, 0x61, 0x89, 0xE0, 0xFC, 0x10,
  0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x00, 0x72, 0x28, 0x61,
  0x85, 0x23, 0x14, 0x8A, 0x18, 0x61, 0x85, 0xE0, 0x72, 0x28, 0xA1, 0x86,
  0x18, 0x63, 0x74, 0x10, 0x82, 0x0B, 0xC0, 0x80, 0x40, 0x80, 0x00, 0x6A,
  0x04, 0x23, 0x30, 0x81, 0x81, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x83, 0x03,
  0x03, 0x0C, 0x46, 0x20, 0x74, 0x42, 0x10, 0x88, 0x44, 0x22, 0x10, 0x00,
  0x30, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x8E, 0x64, 0x99, 0x26, 0x49, 0x92,
  0x64, 0x99, 0x6A, 0x26, 0x80, 0x10, 0x02, 0x20, 0x70, 0x10, 0x20, 0x61,
  0x42, 0x84, 0x89, 0x22, 0x7C, 0x89, 0x0C, 0x18, 0x30, 0x40, 0xF9, 0x0A,
  0x14, 0x28, 0x50, 0xBE, 0x42, 0x85, 0x06, 0x0C, 0x18, 0x5F, 0x00, 0x1E,
  0x41, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x07, 0x80,
  0xF1, 0x1A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x5F,
  0x00, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x08, 0x7C, 0xFC, 0x21,
  0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x40, 0x1E, 0x21, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x87, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xE9, 0x24,
  0x92, 0x49, 0x25, 0xC0, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x86,
  0x18, 0xA2, 0x92, 0x8A, 0x38, 0x92, 0x48, 0xA2, 0x86, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0xC0, 0x70, 0x1C, 0x06, 0x83,
  0xA0, 0xE8, 0x5A, 0x16, 0x45, 0x91, 0x64, 0x98, 0xA6, 0x29, 0x8C, 0x61,
  0x10, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x8B, 0x16, 0x1C, 0x38,
  0x30, 0x40, 0x38, 0x46, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x42, 0x42, 0x3C, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08,
  0x20, 0x82, 0x00, 0x38, 0x46, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x42, 0x3C, 0x04, 0x04, 0x02, 0xF1, 0x12, 0x14, 0x28,
  0x50, 0xA1, 0x7C, 0x91, 0x12, 0x24, 0x48, 0x50, 0xC0, 0x3F, 0x08, 0x20,
  0x82, 0x06, 0x04, 0x08, 0x10, 0x41, 0x0B, 0xC0, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x27, 0x80, 0x83, 0x06, 0x0A, 0x14,
  0x48, 0x91, 0x22, 0x28, 0x50, 0xA1, 0x41, 0x02, 0x00, 0x82, 0x18, 0x21,
  0x86, 0x14, 0x61, 0x45, 0x14, 0x51, 0x45, 0x24, 0x92, 0x29, 0x22, 0x8A,
  0x28, 0xC2, 0x8C, 0x30, 0xC1, 0x04, 0x45, 0x14, 0x4A, 0x28, 0xA1, 0x04,
  0x28, 0xA4, 0x91, 0x46, 0x10, 0x86, 0x14, 0x52, 0x48, 0xA3, 0x0C, 0x10,
  0x41, 0x04, 0x10, 0x40, 0xF8, 0x44, 0x21, 0x10, 0x84, 0x42, 0x21, 0x08,
  0x7C, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x81, 0x04, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92,
  0x49, 0xE0, 0x10, 0x30, 0x61, 0x22, 0x48, 0x70, 0x80, 0xFF, 0x91, 0x80,
  0xF0, 0x42, 0x17, 0xC6, 0x31, 0x8F, 0xC0, 0x82, 0x08, 0x20, 0xBB, 0x18,
  0x61, 0x86, 0x18, 0x61, 0xC6, 0xE0, 0x7C, 0x21, 0x08, 0x42, 0x10, 0x83,
  0xC0, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0,
  0x72, 0x28, 0x61, 0xFE, 0x08, 0x20, 0x81, 0xE0, 0x19, 0x10, 0x84, 0x79,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x8D, 0xD0, 0x41, 0x06, 0x27, 0x00, 0x82, 0x08, 0x20, 0xBB, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x10, 0xCF, 0xFC, 0x50, 0x55, 0x55, 0x55, 0x58,
  0x84, 0x21, 0x08, 0xCA, 0x54, 0xA6, 0xA5, 0x28, 0xC4, 0xFF, 0xFC, 0xBB,
  0xB3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x10,
  0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xE0, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC6, 0xE8,
  0x20, 0x82, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x8D, 0xD0, 0x41,
  0x04, 0x10, 0xBC, 0x88, 0x88, 0x88, 0x88, 0xF8, 0x88, 0x43, 0x11, 0x1F,
  0x44, 0xF4, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x8D, 0xD0, 0x86, 0x14, 0x92, 0x49, 0x25, 0x0C, 0x30, 0x80, 0x84, 0x63,
  0x14, 0xC9, 0x32, 0x4A, 0x94, 0xA5, 0x28, 0xCC, 0x31, 0x08, 0x40, 0xC5,
  0x22, 0x8C, 0x10, 0xC3, 0x12, 0x4A, 0x10, 0x85, 0x14, 0x52, 0x48, 0xA2,
  0x8C, 0x10, 0x41, 0x08, 0x20, 0x8C, 0x00, 0xF2, 0x22, 0x44, 0x88, 0x8F,
  0x19, 0x08, 0x42, 0x10, 0x84, 0xC2, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF,
  0xFF, 0xE0, 0x82, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08, 0x42, 0x10, 0x84,
  0xC0, 0x42, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 8, 14, 8, 0, -14 },
  { 22, 6, 15, 8, 1, -14 },
  { 34, 9, 14, 11, 1, -14 },
  { 50, 7, 14, 8, 1, -14 },
  { 63, 1, 5, 3, 1, -14 },
  { 64, 3, 17, 5, 1, -14 },
  { 71, 3, 17, 5, 1, -14 },
  { 78, 5, 5, 7, 1, -14 },
  { 82, 6, 9, 8, 1, -11 },
  { 89, 1, 4, 4, 1, -2 },
  { 90, 5, 1, 5, 0, -6 },
  { 91, 1, 1, 4, 1, -1 },
  { 92, 6, 14, 6, 0, -14 },
  { 103, 6, 14, 8, 1, -14 },
  { 114, 4, 14, 8, 1, -14 },
  { 121, 6, 14, 8, 1, -14 },
  { 132, 6, 14, 8, 1, -14 },
  { 143, 7, 14, 8, 0, -14 },
  { 156, 6, 14, 8, 1, -14 },
  { 167, 6, 14, 8, 1, -14 },
  { 178, 6, 14, 8, 1, -14 },
  { 189, 6, 14, 8, 1, -14 },
  { 200, 6, 14, 8, 1, -14 },
  { 211, 1, 10, 4, 1, -10 },
  { 213, 2, 12, 4, 1, -10 },
  { 216, 6, 8, 8, 1, -11 },
  { 222, 6, 5, 8, 1, -9 },
  { 226, 6, 8, 8, 1, -11 },
  { 232, 5, 14, 5, 0, -14 },
  { 241, 10, 16, 12, 1, -14 },
  { 261, 7, 14, 7, 0, -14 },
  { 274, 7, 14, 8, 1, -14 },
  { 287, 7, 14, 8, 1, -14 },
  { 300, 7, 14, 9, 1, -14 },
  { 313, 5, 14, 7, 1, -14 },
  { 322, 5, 14, 7, 1, -14 },
  { 331, 8, 14, 10, 1, -14 },
  { 345, 7, 14, 9, 1, -14 },
  { 358, 3, 14, 4, 1, -14 },
  { 364, 3, 17, 4, -1, -14 },
  { 371, 6, 14, 7, 1, -14 },
  { 382, 5, 14, 7, 1, -14 },
  { 391, 10, 14, 13, 1, -14 },
  { 409, 7, 14, 10, 1, -14 },
  { 422, 8, 14, 10, 1, -14 },
  { 436, 6, 14, 8, 1, -14 },
  { 447, 8, 17, 10, 1, -14 },
  { 464, 7, 14, 8, 1, -14 },
  { 477, 6, 14, 7, 1, -14 },
  { 488, 6, 14, 7, 0, -14 },
  { 499, 7, 14, 9, 1, -14 },
  { 512, 7, 14, 7, 0, -14 },
  { 525, 12, 14, 13, 0, -14 },
  { 546, 6, 14, 7, 0, -14 },
  { 557, 6, 14, 6, 0, -14 },
  { 568, 5, 14, 6, 1, -14 },
  { 577, 3, 17, 6, 2, -14 },
  { 584, 6, 14, 6, 0, -14 },
  { 595, 3, 17, 6, 1, -14 },
  { 602, 7, 7, 8, 0, -14 },
  { 609, 8, 1, 8, 0, 2 },
  { 610, 3, 3, 4, 1, -15 },
  { 612, 5, 10, 7, 1, -10 },
  { 619, 6, 14, 8, 1, -14 },
  { 630, 5, 10, 6, 1, -10 },
  { 637, 6, 14, 8, 1, -14 },
  { 648, 6, 10, 7, 1, -10 },
  { 656, 5, 15, 4, 0, -15 },
  { 666, 6, 15, 8, 1, -10 },
  { 678, 6, 14, 8, 1, -14 },
  { 689, 1, 14, 4, 1, -14 },
  { 691, 2, 19, 4, 0, -14 },
  { 696, 5, 14, 6, 1, -14 },
  { 705, 1, 14, 3, 1, -14 },
  { 707, 10, 10, 12, 1, -10 },
  { 720, 6, 10, 8, 1, -10 },
  { 728, 6, 10, 8, 1, -10 },
  { 736, 6, 14, 8, 1, -10 },
  { 747, 6, 14, 8, 1, -10 },
  { 758, 4, 10, 5, 1, -10 },
  { 763, 4, 10, 6, 1, -10 },
  { 768, 4, 12, 4, 0, -12 },
  { 774, 6, 10, 8, 1, -10 },
  { 782, 6, 10, 6, 0, -10 },
  { 790, 10, 10, 10, 0, -10 },
  { 803, 6, 10, 6, 0, -10 },
  { 811, 6, 15, 6, 0, -10 },
  { 823, 4, 10, 5, 1, -10 },
  { 828, 5, 17, 7, 1, -14 },
  { 839, 1, 19, 7, 3, -14 },
  { 842, 5, 17, 7, 1, -14 },
  { 853, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT19PT7B_H_
