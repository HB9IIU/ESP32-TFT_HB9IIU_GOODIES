#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xAA, 0xAA, 0xA8, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x88, 0x08, 0x80, 0x88, 0x7F, 0xF0, 0x88, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x0F, 0xFE, 0x11, 0x01, 0x10, 0x11,
  0x02, 0x10, 0x21, 0x02, 0x10, 0x08, 0x06, 0x1A, 0xE9, 0x08, 0x84, 0x42,
  0x21, 0x10, 0x48, 0x34, 0x06, 0x01, 0xC0, 0x90, 0x44, 0x22, 0x11, 0x08,
  0x84, 0x62, 0x5F, 0xC0, 0x80, 0x40, 0x20, 0x78, 0x21, 0x20, 0x84, 0x44,
  0x21, 0x10, 0x84, 0x42, 0x12, 0x08, 0x48, 0x21, 0x20, 0x85, 0x39, 0x15,
  0x14, 0x94, 0x5E, 0x91, 0x02, 0x44, 0x09, 0x10, 0x44, 0x41, 0x11, 0x04,
  0x44, 0x21, 0x10, 0x84, 0x46, 0x0E, 0x3C, 0x09, 0x04, 0x21, 0x08, 0x42,
  0x08, 0x82, 0x40, 0x90, 0x18, 0x04, 0x06, 0x81, 0x21, 0x84, 0x60, 0xA8,
  0x2A, 0x06, 0x81, 0x20, 0x64, 0x29, 0xF1, 0xFE, 0x08, 0x84, 0x42, 0x31,
  0x08, 0x42, 0x31, 0x88, 0x61, 0x08, 0x42, 0x10, 0x42, 0x08, 0x41, 0x82,
  0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22,
  0x11, 0x18, 0x10, 0x10, 0xD3, 0x3C, 0x18, 0x24, 0x46, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x69, 0x25, 0x20, 0xFC, 0xB0, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x1E, 0x11, 0x10, 0x48, 0x24, 0x1A, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x05, 0x02, 0x82, 0x41, 0x20, 0x88,
  0x83, 0xC0, 0x09, 0xDB, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x7E, 0x61, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x1F, 0xF0, 0x7E, 0x41, 0x80, 0x40, 0x30, 0x08, 0x0C, 0x04, 0x02, 0x02,
  0x1E, 0x01, 0x80, 0x20, 0x18, 0x04, 0x02, 0x01, 0x01, 0x80, 0xA0, 0xDF,
  0xC0, 0x01, 0x80, 0x20, 0x0E, 0x01, 0xC0, 0x58, 0x0B, 0x02, 0x60, 0x4C,
  0x11, 0x82, 0x30, 0x86, 0x10, 0xC4, 0x18, 0x83, 0x3F, 0xF8, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x7E, 0x21, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xA0, 0xDF, 0xC0, 0x0F, 0x08, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x9E, 0x50, 0xB0, 0x78, 0x1C, 0x0C, 0x07, 0x02, 0x81, 0x40, 0xA0,
  0x88, 0x47, 0xC0, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x00, 0x3E, 0x30, 0x90, 0x68, 0x1C, 0x0A, 0x05, 0x04, 0x46, 0x16,
  0x04, 0x0D, 0x8C, 0x24, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x50, 0x47,
  0xC0, 0x3E, 0x21, 0x10, 0x50, 0x28, 0x14, 0x06, 0x03, 0x01, 0x81, 0xA0,
  0xD0, 0xA7, 0xD0, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x01, 0x8F, 0x80,
  0xB0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0x92, 0x52, 0x00,
  0x00, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x18, 0x08, 0x0C, 0x0C,
  0x0C, 0x02, 0x00, 0x7D, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x07, 0xE0, 0x10,
  0x60, 0x40, 0x21, 0x00, 0x42, 0x00, 0x48, 0x00, 0x90, 0xF1, 0x22, 0x21,
  0x44, 0x42, 0x88, 0x87, 0x11, 0x0C, 0x22, 0x18, 0x44, 0x28, 0x88, 0x51,
  0x11, 0x22, 0x52, 0x43, 0x38, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0xDC, 0x00, 0x40, 0x00, 0x04, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x26, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x82, 0x1F, 0xC2, 0x08, 0x41,
  0x10, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x00, 0xC0, 0x10, 0xFE, 0x41, 0xA0,
  0x50, 0x18, 0x0C, 0x06, 0x07, 0x02, 0x83, 0x7E, 0x20, 0xD0, 0x38, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0xDF, 0xC0, 0x0F, 0xC4, 0x03, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x3F, 0xFC, 0x20, 0xC8,
  0x12, 0x02, 0x80, 0xA0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x02, 0x80, 0xA0, 0x48, 0x33, 0xF0, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x07, 0xE1,
  0x81, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC1, 0xF4, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x20, 0x13,
  0x01, 0x18, 0x10, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x7F, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x2F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xE0, 0x81, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x62, 0x21,
  0x20, 0x90, 0x58, 0x34, 0x19, 0x08, 0x84, 0x22, 0x11, 0x04, 0x82, 0x40,
  0xA0, 0x50, 0x10, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3D, 0x00, 0x7A, 0x00, 0xF4, 0x02, 0xE4, 0x05, 0xC8, 0x0B,
  0x90, 0x27, 0x10, 0x4E, 0x20, 0x9C, 0x43, 0x38, 0x84, 0x70, 0x88, 0xE1,
  0x11, 0xC2, 0x43, 0x82, 0x87, 0x05, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0xC0,
  0x70, 0x1E, 0x06, 0x81, 0xA0, 0x64, 0x19, 0x06, 0x21, 0x88, 0x61, 0x18,
  0x46, 0x11, 0x82, 0x60, 0x98, 0x16, 0x05, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x0F, 0x83, 0x04, 0x20, 0x66, 0x02, 0x40, 0x24, 0x01, 0x40, 0x14, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02,
  0x60, 0x22, 0x06, 0x10, 0x40, 0xF8, 0xFC, 0x86, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x8E, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x0F, 0x81, 0x04, 0x20, 0x66, 0x02, 0x40, 0x24, 0x01, 0x40,
  0x14, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x02, 0x60, 0x22, 0x06, 0x10, 0x40, 0xF8, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x60, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x81, 0x41, 0x3F, 0x11, 0x08, 0x44, 0x22, 0x19, 0x04, 0x83, 0x40,
  0xA0, 0x50, 0x10, 0x3F, 0xB0, 0x10, 0x18, 0x08, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x60, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0xA0,
  0xDF, 0xC0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x26,
  0x18, 0xFC, 0x80, 0x70, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81, 0x08, 0x21,
  0x04, 0x20, 0x84, 0x20, 0x84, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x30, 0x02, 0x00, 0x80, 0x40, 0x70, 0x30, 0x14, 0x0C,
  0x05, 0x03, 0x01, 0x40, 0xA0, 0x90, 0x28, 0x22, 0x12, 0x08, 0x84, 0x82,
  0x21, 0x21, 0x88, 0x44, 0x42, 0x11, 0x10, 0x48, 0x44, 0x12, 0x11, 0x04,
  0x84, 0x81, 0x20, 0xA0, 0x48, 0x28, 0x0C, 0x0A, 0x03, 0x02, 0x80, 0xC0,
  0xC0, 0x30, 0x10, 0x40, 0xB0, 0x48, 0x44, 0x21, 0x10, 0x90, 0x48, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x20, 0x90, 0xC8, 0x42, 0x21, 0x20, 0xD0,
  0x38, 0x10, 0x80, 0xE0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14,
  0x0A, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xFF, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0xFF, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x3F, 0x04, 0x00, 0xC0, 0x28, 0x04, 0x81, 0x10, 0x21, 0x08, 0x21,
  0x02, 0x40, 0x58, 0x04, 0xFF, 0xE0, 0xC6, 0x21, 0x3C, 0x42, 0x02, 0x01,
  0x01, 0x01, 0x07, 0x39, 0x41, 0x81, 0x83, 0x83, 0x83, 0x45, 0x7D, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x46, 0xC1, 0x40, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xB0, 0x58, 0x6B, 0xE0, 0x1E,
  0x41, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x03, 0x02, 0x04, 0x04, 0x0F,
  0x80, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x7A, 0x47, 0x41, 0xA0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xA0, 0x50, 0x6C, 0x33,
  0xE8, 0x1E, 0x11, 0x10, 0x48, 0x24, 0x14, 0x06, 0x03, 0xFE, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x01, 0x08, 0x7C, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x3E,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x00, 0x1E, 0x90, 0xD0, 0x68, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x28, 0x14, 0x1B, 0x0C, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x24,
  0x31, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xA2, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC7,
  0xFF, 0xF0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x2F,
  0x00, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC2, 0x8D, 0x12, 0x44, 0x8B,
  0x1A, 0x32, 0x44, 0x8D, 0x0A, 0x14, 0x18, 0x20, 0xFF, 0xFF, 0xF8, 0xBC,
  0x73, 0x1A, 0x2C, 0x30, 0xA0, 0xC2, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0,
  0x83, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x38,
  0x20, 0xC0, 0x9C, 0xA2, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x10, 0x90, 0x48, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x28, 0x14, 0x19, 0x08, 0xF8, 0x9E, 0x51,
  0xB0, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x2C,
  0x15, 0x1A, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1E,
  0x91, 0xD0, 0x68, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x28,
  0x14, 0x1B, 0x0C, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x9D, 0x31, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x00, 0x3E, 0x86,
  0x04, 0x08, 0x08, 0x18, 0x08, 0x0C, 0x0C, 0x08, 0x10, 0x30, 0xFF, 0x00,
  0x42, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x41, 0xC0,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x83, 0xC5, 0x79, 0x81, 0xE0, 0x90, 0x48, 0x24, 0x22, 0x10, 0x88, 0x44,
  0x26, 0x12, 0x05, 0x02, 0x81, 0x40, 0xC0, 0x20, 0x81, 0x06, 0x82, 0x09,
  0x0A, 0x12, 0x14, 0x24, 0x28, 0x48, 0x51, 0x08, 0xA2, 0x12, 0x24, 0x24,
  0x48, 0x48, 0x90, 0x51, 0x40, 0xC2, 0x81, 0x83, 0x03, 0x06, 0x06, 0x08,
  0x00, 0x41, 0xA0, 0x88, 0xC4, 0x41, 0x60, 0xA0, 0x30, 0x10, 0x1C, 0x0A,
  0x04, 0x84, 0x42, 0x32, 0x0B, 0x06, 0x40, 0xA0, 0x50, 0x48, 0x22, 0x11,
  0x08, 0x88, 0x44, 0x12, 0x09, 0x05, 0x02, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x02, 0x06, 0x00, 0xFC, 0x30, 0x82, 0x10, 0x41,
  0x08, 0x20, 0x84, 0x10, 0xC2, 0x0F, 0xC0, 0x06, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x8E, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x06, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40, 0xC0,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x61, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x04, 0x78, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 7, 9, 2, -20 },
  { 11, 12, 20, 12, 0, -20 },
  { 41, 9, 23, 11, 1, -21 },
  { 67, 14, 20, 17, 1, -20 },
  { 102, 10, 20, 11, 1, -20 },
  { 127, 1, 7, 5, 2, -20 },
  { 128, 5, 24, 8, 1, -20 },
  { 143, 5, 24, 8, 1, -20 },
  { 158, 8, 7, 10, 1, -21 },
  { 165, 10, 13, 11, 1, -16 },
  { 182, 3, 7, 5, 1, -3 },
  { 185, 6, 1, 7, 1, -8 },
  { 186, 2, 2, 5, 2, -2 },
  { 187, 8, 20, 9, 1, -20 },
  { 207, 9, 20, 11, 1, -20 },
  { 230, 5, 20, 11, 2, -20 },
  { 243, 9, 20, 11, 1, -20 },
  { 266, 9, 20, 11, 1, -20 },
  { 289, 11, 20, 11, 0, -20 },
  { 317, 9, 20, 11, 1, -20 },
  { 340, 9, 20, 11, 1, -20 },
  { 363, 9, 20, 11, 1, -20 },
  { 386, 9, 20, 11, 1, -20 },
  { 409, 9, 20, 11, 1, -20 },
  { 432, 2, 15, 5, 2, -15 },
  { 436, 3, 19, 5, 1, -15 },
  { 444, 10, 12, 11, 1, -16 },
  { 459, 10, 7, 11, 1, -13 },
  { 468, 10, 12, 11, 1, -16 },
  { 483, 7, 20, 8, 0, -20 },
  { 501, 15, 23, 17, 1, -20 },
  { 545, 11, 20, 11, 0, -20 },
  { 573, 9, 20, 12, 2, -20 },
  { 596, 10, 20, 12, 1, -20 },
  { 621, 10, 20, 13, 2, -20 },
  { 646, 7, 20, 11, 2, -20 },
  { 664, 7, 20, 10, 2, -20 },
  { 682, 12, 20, 15, 1, -20 },
  { 712, 10, 20, 14, 2, -20 },
  { 737, 4, 20, 7, 1, -20 },
  { 747, 4, 25, 5, -1, -20 },
  { 760, 9, 20, 11, 2, -20 },
  { 783, 7, 20, 10, 2, -20 },
  { 801, 15, 20, 19, 2, -20 },
  { 839, 10, 20, 14, 2, -20 },
  { 864, 12, 20, 15, 1, -20 },
  { 894, 8, 20, 11, 2, -20 },
  { 914, 12, 25, 15, 1, -20 },
  { 952, 9, 20, 12, 2, -20 },
  { 975, 9, 20, 11, 1, -20 },
  { 998, 9, 20, 10, 0, -20 },
  { 1021, 10, 20, 14, 2, -20 },
  { 1046, 11, 20, 11, 0, -20 },
  { 1074, 18, 20, 19, 0, -20 },
  { 1119, 9, 20, 10, 0, -20 },
  { 1142, 9, 20, 9, 0, -20 },
  { 1165, 8, 20, 9, 1, -20 },
  { 1185, 6, 24, 9, 2, -20 },
  { 1203, 8, 20, 9, 1, -20 },
  { 1223, 5, 24, 9, 1, -20 },
  { 1238, 11, 10, 11, 0, -20 },
  { 1252, 11, 1, 11, 0, 2 },
  { 1254, 4, 4, 7, 1, -21 },
  { 1256, 8, 15, 11, 1, -15 },
  { 1271, 9, 21, 12, 2, -21 },
  { 1295, 7, 15, 9, 1, -15 },
  { 1309, 9, 21, 12, 1, -21 },
  { 1333, 9, 15, 11, 1, -15 },
  { 1350, 7, 21, 6, 0, -21 },
  { 1369, 9, 22, 12, 1, -15 },
  { 1394, 8, 21, 12, 2, -21 },
  { 1415, 1, 20, 5, 2, -20 },
  { 1418, 3, 27, 5, 0, -20 },
  { 1429, 7, 21, 9, 2, -21 },
  { 1448, 1, 21, 5, 2, -21 },
  { 1451, 14, 15, 17, 2, -15 },
  { 1478, 8, 15, 12, 2, -15 },
  { 1493, 9, 15, 12, 1, -15 },
  { 1510, 9, 22, 12, 2, -15 },
  { 1535, 9, 22, 12, 1, -15 },
  { 1560, 5, 15, 8, 2, -15 },
  { 1570, 7, 15, 9, 1, -15 },
  { 1584, 5, 18, 6, 1, -18 },
  { 1596, 8, 15, 12, 2, -15 },
  { 1611, 9, 15, 9, 0, -15 },
  { 1628, 15, 15, 15, 0, -15 },
  { 1657, 9, 15, 9, 0, -15 },
  { 1674, 9, 22, 9, 0, -15 },
  { 1699, 6, 15, 7, 1, -15 },
  { 1711, 7, 24, 10, 1, -20 },
  { 1732, 1, 28, 11, 5, -21 },
  { 1736, 7, 24, 10, 1, -20 },
  { 1757, 10, 2, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT28PT7B_H_
