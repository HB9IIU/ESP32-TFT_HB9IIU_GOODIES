#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x6F, 0xAB, 0x40, 0x7B, 0x37, 0x80, 0x5E, 0xB7, 0x75,
  0x55, 0x3B, 0xC0, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0xD0, 0x4B, 0xA0, 0xC0,
  0xC0, 0x80, 0x29, 0x29, 0x00, 0x56, 0xDB, 0xC0, 0xFC, 0xC4, 0xA5, 0xC0,
  0xC4, 0xB3, 0xC0, 0x29, 0x5E, 0x40, 0x73, 0x13, 0xC0, 0x73, 0x5B, 0xC0,
  0xE4, 0xA4, 0x80, 0x57, 0xDB, 0xC0, 0x56, 0xF2, 0xC0, 0x10, 0x18, 0x2B,
  0x10, 0xFC, 0x89, 0xC0, 0xD6, 0xA0, 0x74, 0x7D, 0xBF, 0xC1, 0x80, 0x4A,
  0xFB, 0x40, 0xFF, 0xF0, 0x72, 0x48, 0xC0, 0xBF, 0xF0, 0xEB, 0xB0, 0xEB,
  0xA0, 0x78, 0x8B, 0x97, 0xFF, 0xF0, 0xEA, 0xB0, 0xFE, 0xEA, 0xB0, 0xAA,
  0xB0, 0x99, 0x9B, 0xBD, 0xB6, 0xDF, 0x40, 0x69, 0x99, 0x97, 0xBE, 0xA0,
  0x69, 0x99, 0x95, 0x20, 0xBE, 0xB0, 0x72, 0x33, 0xC0, 0xE9, 0x24, 0x80,
  0xFF, 0xF0, 0xB6, 0xD4, 0x80, 0xAD, 0x6B, 0xB5, 0x28, 0xB5, 0x2D, 0x40,
  0xB7, 0x24, 0x80, 0xD5, 0xB0, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x4A,
  0x80, 0xE0, 0xC0, 0x5F, 0xAF, 0xF0, 0xEB, 0x2E, 0xDB, 0xC0, 0xFE, 0x70,
  0xFA, 0xA0, 0xF6, 0xF3, 0xC0, 0xAF, 0xF0, 0xBC, 0xBF, 0xBA, 0xB0, 0xFC,
  0xFF, 0xF0, 0xFF, 0xF6, 0xF0, 0xFF, 0xA0, 0xF6, 0xF2, 0x40, 0xF0, 0xE7,
  0xEA, 0xC0, 0xFF, 0xF5, 0xDB, 0x56, 0xD7, 0xBB, 0x25, 0x00, 0xDB, 0x57,
  0x54, 0xFF, 0x95, 0x5C, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 3, 6, 3, 0, -6 },
  { 6, 3, 6, 3, 0, -6 },
  { 9, 4, 6, 5, 0, -6 },
  { 12, 3, 6, 3, 0, -6 },
  { 15, 1, 2, 1, 0, -6 },
  { 16, 2, 7, 2, 0, -6 },
  { 18, 2, 7, 2, 0, -6 },
  { 20, 2, 2, 3, 0, -6 },
  { 21, 3, 4, 3, 0, -5 },
  { 23, 1, 2, 1, 0, -1 },
  { 24, 2, 1, 2, 0, -3 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 3, 6, 3, 0, -6 },
  { 29, 3, 6, 3, 0, -6 },
  { 32, 1, 6, 3, 1, -6 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 3, 6, 3, 0, -6 },
  { 42, 3, 6, 3, 0, -6 },
  { 45, 3, 6, 3, 0, -6 },
  { 48, 3, 6, 3, 0, -6 },
  { 51, 3, 6, 3, 0, -6 },
  { 54, 3, 6, 3, 0, -6 },
  { 57, 1, 4, 2, 0, -4 },
  { 58, 1, 5, 2, 0, -4 },
  { 59, 3, 4, 3, 0, -5 },
  { 61, 3, 2, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -5 },
  { 64, 2, 6, 2, 0, -6 },
  { 66, 5, 7, 5, 0, -6 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 2, 6, 4, 1, -6 },
  { 76, 3, 6, 3, 0, -6 },
  { 79, 2, 6, 4, 1, -6 },
  { 81, 2, 6, 3, 1, -6 },
  { 83, 2, 6, 3, 1, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 2, 6, 4, 1, -6 },
  { 90, 2, 6, 2, 0, -6 },
  { 92, 1, 7, 2, 0, -6 },
  { 93, 2, 6, 3, 1, -6 },
  { 95, 2, 6, 3, 1, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 3, 6, 4, 1, -6 },
  { 103, 4, 6, 4, 0, -6 },
  { 106, 2, 6, 3, 1, -6 },
  { 108, 4, 7, 4, 0, -6 },
  { 112, 2, 6, 3, 1, -6 },
  { 114, 3, 6, 3, 0, -6 },
  { 117, 3, 6, 3, 0, -6 },
  { 120, 2, 6, 4, 1, -6 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 3, 6, 3, 0, -6 },
  { 132, 3, 6, 3, 0, -6 },
  { 135, 2, 6, 3, 0, -6 },
  { 137, 1, 7, 2, 1, -6 },
  { 138, 3, 6, 3, 0, -6 },
  { 141, 2, 7, 2, 0, -6 },
  { 143, 3, 3, 3, 0, -6 },
  { 145, 3, 1, 3, 0, 0 },
  { 146, 2, 1, 2, 0, -6 },
  { 147, 2, 4, 3, 0, -4 },
  { 148, 2, 6, 3, 1, -6 },
  { 150, 2, 4, 3, 0, -4 },
  { 151, 3, 6, 3, 0, -6 },
  { 154, 3, 4, 3, 0, -4 },
  { 156, 2, 6, 2, 0, -6 },
  { 158, 3, 6, 3, 0, -4 },
  { 161, 2, 6, 3, 1, -6 },
  { 163, 1, 6, 1, 0, -6 },
  { 164, 1, 8, 1, 0, -6 },
  { 165, 2, 6, 3, 1, -6 },
  { 167, 1, 6, 1, 0, -6 },
  { 168, 3, 4, 5, 1, -4 },
  { 170, 2, 4, 3, 1, -4 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 2, 6, 3, 1, -4 },
  { 175, 3, 6, 3, 0, -4 },
  { 178, 1, 4, 2, 1, -4 },
  { 179, 2, 4, 3, 0, -4 },
  { 180, 2, 5, 2, 0, -5 },
  { 182, 2, 4, 3, 1, -4 },
  { 183, 2, 4, 2, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 2, 4, 3, 0, -4 },
  { 187, 3, 6, 3, 0, -4 },
  { 190, 2, 4, 2, 0, -4 },
  { 191, 2, 7, 3, 0, -6 },
  { 193, 1, 8, 3, 1, -6 },
  { 194, 2, 7, 3, 0, -6 },
  { 196, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT8PT7B_H_
