#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C,
  0x00, 0x03, 0xFF, 0xC0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x60, 0xD8, 0x36,
  0x0D, 0x83, 0x60, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xD0, 0x30, 0x01, 0x80,
  0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80, 0x18, 0x08,
  0x00, 0xC0, 0x40, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0x80,
  0x0C, 0x04, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0x01, 0x80, 0x18, 0x08, 0x00,
  0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0x40, 0x60, 0x02, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x80, 0x0C,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x1F,
  0xFF, 0x0E, 0x21, 0xC7, 0x08, 0x01, 0x82, 0x00, 0xC0, 0x80, 0x30, 0x20,
  0x0C, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x03,
  0x82, 0x00, 0x60, 0x80, 0x0C, 0x20, 0x01, 0xC8, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0B, 0x80, 0x02, 0x38, 0x00, 0x87, 0x00, 0x20,
  0xC0, 0x08, 0x18, 0x02, 0x06, 0x00, 0x80, 0x80, 0x20, 0x30, 0x08, 0x08,
  0x02, 0x06, 0x00, 0x81, 0x80, 0x20, 0x60, 0x08, 0x33, 0x02, 0x18, 0xF8,
  0xBC, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x1F, 0x00, 0x18, 0x07, 0x30, 0x02, 0x00, 0xC3, 0x00,
  0xC0, 0x30, 0x60, 0x18, 0x06, 0x04, 0x02, 0x00, 0xC0, 0xC0, 0xC0, 0x10,
  0x18, 0x18, 0x02, 0x03, 0x02, 0x00, 0xC0, 0x60, 0xC0, 0x18, 0x0C, 0x18,
  0x03, 0x01, 0x82, 0x00, 0x60, 0x30, 0xC0, 0x0C, 0x06, 0x18, 0x01, 0x80,
  0xC2, 0x00, 0x30, 0x18, 0xC0, 0x02, 0x03, 0x18, 0xF8, 0x40, 0x62, 0x39,
  0x8C, 0x0C, 0xC6, 0x19, 0x83, 0x19, 0x83, 0x30, 0x62, 0x30, 0x63, 0x0C,
  0xC6, 0x04, 0x73, 0x18, 0x80, 0xC7, 0xC2, 0x10, 0x18, 0x00, 0xC6, 0x03,
  0x00, 0x18, 0xC0, 0x60, 0x02, 0x18, 0x0C, 0x00, 0xC3, 0x01, 0x80, 0x18,
  0x60, 0x30, 0x02, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0xC0, 0x18, 0x10, 0x18,
  0x02, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x0C, 0x18, 0x02, 0x01,
  0x83, 0x00, 0xC0, 0x18, 0x60, 0x18, 0x03, 0x98, 0x06, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xDC, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x04, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00,
  0x36, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0xC0, 0x03,
  0x98, 0x00, 0x61, 0x81, 0x98, 0x18, 0x33, 0x03, 0x06, 0xC0, 0x30, 0xD8,
  0x06, 0x1B, 0x00, 0x63, 0x60, 0x0C, 0x4C, 0x00, 0xD9, 0x80, 0x1B, 0x30,
  0x01, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x01, 0xF1, 0x80, 0x36, 0x38,
  0x1C, 0x63, 0xCF, 0x0E, 0x3F, 0xC0, 0xC0, 0x80, 0x00, 0xFF, 0xF6, 0xDB,
  0x6D, 0x24, 0x80, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x00, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x41, 0x07, 0xC4, 0xF3, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x1B, 0x00, 0xC6,
  0x06, 0x08, 0x30, 0x30, 0xC0, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x19, 0x8C, 0x00,
  0xFF, 0xFF, 0xFF, 0x6F, 0xF6, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xFC, 0x03, 0x07, 0x03, 0x01, 0x83, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x1C,
  0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x19, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x1C, 0x03, 0x06, 0x03, 0x01,
  0x83, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0x81, 0xC1, 0xE1, 0xF1, 0xD9,
  0x8D, 0x87, 0x83, 0x41, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x1F, 0xF0, 0x1F, 0xFC, 0x1C, 0x07, 0x08, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x1F, 0xFC, 0x38, 0x07, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x90, 0x03, 0x8F, 0x87, 0x83, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x16, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x60, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x7F, 0xFC, 0x7F, 0xFC,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC7, 0x80, 0xFF, 0xF0, 0xE0, 0x78, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x80, 0x38, 0xF1, 0xF0, 0x7F, 0xE0,
  0x01, 0xFC, 0x07, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCF, 0xF8, 0xD8, 0x1C,
  0xF0, 0x0C, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x38, 0x1C,
  0x1C, 0x38, 0x0F, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x06, 0x03, 0x86, 0x00, 0xC7,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xB0, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x71, 0xC0, 0x30, 0x60, 0x30, 0x1C,
  0x30, 0x07, 0x70, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0xC1, 0x80,
  0xC0, 0x60, 0xC0, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xB0, 0x01, 0x9C, 0x00, 0xC7, 0x00, 0xC1, 0xE3, 0xC0, 0x7F, 0xC0,
  0x03, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0E, 0x07, 0x06, 0x01, 0x86, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x09, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06,
  0xE0, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xE3, 0x00, 0xB0, 0xE1,
  0xD8, 0x3F, 0xCC, 0x06, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0x1E, 0x01, 0xFE, 0x00, 0x18,
  0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x6F, 0xF6, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x67, 0x39, 0xCC, 0x63, 0x31, 0x8C, 0x46,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0x8F, 0xFC, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x30, 0x07, 0xE0,
  0x66, 0x03, 0xCC, 0x0C, 0xC0, 0x60, 0x80, 0xB0, 0x18, 0x30, 0x1E, 0x02,
  0x06, 0x03, 0xC0, 0xC0, 0xC0, 0x78, 0x18, 0x18, 0x0F, 0x03, 0x03, 0x01,
  0xE0, 0x40, 0x60, 0x3C, 0x08, 0x0C, 0x07, 0x83, 0x01, 0x80, 0xF0, 0x60,
  0x30, 0x1E, 0x0C, 0x06, 0x03, 0xC0, 0x80, 0xC0, 0x78, 0x10, 0x18, 0x0B,
  0x03, 0x07, 0x03, 0x60, 0x60, 0xA0, 0x6C, 0x0C, 0x14, 0x0D, 0x80, 0xC6,
  0xC3, 0x30, 0x1F, 0x8F, 0xC3, 0x01, 0xE0, 0xF0, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x01, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x02, 0x60, 0x00, 0x31, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x43, 0x00, 0x06, 0x08, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x18, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x0E, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00,
  0x63, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x0C, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x07, 0x18, 0x01, 0xCC, 0x00,
  0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x1C,
  0xC0, 0x1C, 0x7F, 0xF8, 0x3F, 0xFC, 0x18, 0x03, 0x8C, 0x00, 0x66, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x01, 0x98, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x70, 0x08, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x03, 0xE3, 0xC0, 0x3F,
  0xE0, 0x00, 0x80, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0x00, 0xF0, 0x60, 0x07,
  0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0xC3,
  0x00, 0x38, 0x60, 0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0xB0, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x78, 0x03, 0x83, 0x80, 0x02, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0xC1, 0xC0, 0x03, 0x03, 0xE1, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x3E, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0xDE, 0xFC, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x30, 0x18, 0x38, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x8C,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x37, 0x80, 0x1B, 0x60, 0x0F, 0x30, 0x07,
  0x0C, 0x03, 0x86, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1C,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x03, 0xF6, 0x00,
  0x00, 0xDE, 0xC0, 0x00, 0x1B, 0xC8, 0x00, 0x03, 0x79, 0x80, 0x00, 0xCF,
  0x30, 0x00, 0x19, 0xE6, 0x00, 0x03, 0x3C, 0x60, 0x00, 0x47, 0x8C, 0x00,
  0x18, 0xF1, 0x80, 0x03, 0x1E, 0x18, 0x00, 0x63, 0xC3, 0x00, 0x18, 0x78,
  0x60, 0x03, 0x0F, 0x04, 0x00, 0x61, 0xE0, 0xC0, 0x18, 0x3C, 0x18, 0x03,
  0x07, 0x83, 0x00, 0x60, 0xF0, 0x30, 0x08, 0x1E, 0x06, 0x03, 0x03, 0xC0,
  0xC0, 0x60, 0x78, 0x0C, 0x0C, 0x0F, 0x01, 0x83, 0x01, 0xE0, 0x30, 0x60,
  0x3C, 0x03, 0x0C, 0x07, 0x80, 0x63, 0x00, 0xF0, 0x0C, 0x60, 0x1E, 0x01,
  0x8C, 0x03, 0xC0, 0x19, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00, 0x6C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xB0,
  0x00, 0xF6, 0x00, 0x1E, 0x60, 0x03, 0xCC, 0x00, 0x78, 0xC0, 0x0F, 0x18,
  0x01, 0xE3, 0x00, 0x3C, 0x30, 0x07, 0x86, 0x00, 0xF0, 0x60, 0x1E, 0x0C,
  0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F, 0x01, 0x81, 0xE0, 0x30, 0x3C, 0x06,
  0x07, 0x80, 0x60, 0xF0, 0x0C, 0x1E, 0x00, 0xC3, 0xC0, 0x18, 0x78, 0x01,
  0x8F, 0x00, 0x31, 0xE0, 0x06, 0x3C, 0x00, 0x67, 0x80, 0x0C, 0xF0, 0x00,
  0xDE, 0x00, 0x1B, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0x60, 0x01, 0x81, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x07, 0xCF, 0x80,
  0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x78,
  0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xFF, 0xF0,
  0xFF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x30, 0x18, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x39, 0x80,
  0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x0C, 0x03, 0x80,
  0x70, 0x07, 0xCF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x30, 0x1E, 0x18, 0x03, 0x8C, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x3B, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0E, 0x60, 0x0E, 0x30, 0x0E,
  0x1F, 0xFE, 0x0F, 0xFC, 0x06, 0x0E, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x86, 0x00, 0xC3,
  0x00, 0x71, 0x80, 0x18, 0xC0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x0C, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x00, 0xC6,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x90, 0x03, 0x8F, 0xEF, 0x83,
  0xFF, 0x80, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x01, 0xD8, 0x00, 0x67, 0x00,
  0x38, 0xE0, 0x1C, 0x1F, 0x3E, 0x03, 0xFF, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x30,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x19,
  0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1D, 0x80, 0x03, 0x80, 0x03, 0x30, 0x00,
  0x70, 0x00, 0x66, 0x00, 0x0A, 0x00, 0x0C, 0xC0, 0x03, 0x40, 0x01, 0x8C,
  0x00, 0x6C, 0x00, 0x61, 0x80, 0x0D, 0x80, 0x0C, 0x30, 0x01, 0xB0, 0x01,
  0x86, 0x00, 0x36, 0x00, 0x30, 0xE0, 0x0C, 0x40, 0x0E, 0x0C, 0x01, 0x8C,
  0x01, 0x81, 0x80, 0x31, 0x80, 0x30, 0x30, 0x06, 0x30, 0x06, 0x06, 0x00,
  0xC6, 0x00, 0xC0, 0x60, 0x30, 0x40, 0x38, 0x0C, 0x06, 0x0C, 0x06, 0x01,
  0x80, 0xC1, 0x80, 0xC0, 0x30, 0x18, 0x30, 0x18, 0x06, 0x03, 0x06, 0x03,
  0x00, 0x60, 0xC0, 0x40, 0xC0, 0x0C, 0x18, 0x0C, 0x18, 0x01, 0x83, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x30, 0x60, 0x06, 0x0C, 0x06, 0x1C, 0x00, 0x63,
  0x00, 0x43, 0x00, 0x0C, 0x60, 0x0C, 0x60, 0x01, 0x8C, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x31, 0x80, 0x07, 0x30, 0x06, 0x60, 0x00, 0x64, 0x00, 0x4C,
  0x00, 0x0D, 0x80, 0x0D, 0x80, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x36, 0x00, 0x02, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x01, 0xCC, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0C, 0x60, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x03, 0x01, 0x81, 0xC0, 0x60, 0x60, 0x18, 0x18, 0x03, 0x0C, 0x00,
  0xC3, 0x00, 0x39, 0xC0, 0x06, 0x60, 0x01, 0xB8, 0x00, 0x70, 0xC0, 0x01,
  0xF8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x60, 0xC0, 0x18, 0x18, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x30, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x02, 0x30,
  0x00, 0xCC, 0x00, 0x36, 0x00, 0x05, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xF0, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x06, 0xC0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0x7F, 0xC3, 0xC7, 0x88, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xF0, 0xFC, 0xC7, 0x03, 0x30, 0x0D, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x15, 0x80, 0x56,
  0x03, 0x4E, 0x19, 0x1F, 0xC4, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x18, 0x0C, 0x7F, 0x06, 0x71,
  0xC3, 0x60, 0x31, 0xE0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB8, 0x01, 0x9C, 0x00, 0xCF,
  0x00, 0xE4, 0xC0, 0xE2, 0x39, 0xE1, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x0F, 0xF0, 0xF9, 0x87, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC7,
  0x07, 0xFC, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x30, 0x7F, 0x18, 0x71, 0xCC, 0x70, 0x36,
  0x70, 0x0F, 0x30, 0x03, 0xB8, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xDC, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x78, 0xC0,
  0x64, 0x38, 0xE2, 0x0F, 0xE1, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0xF0,
  0x0E, 0x38, 0x18, 0x0C, 0x38, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x02, 0x0F, 0x1E, 0x07, 0xFC, 0x00, 0xE0, 0x00, 0xC0, 0x7F, 0x0F,
  0x20, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x0F, 0xF8, 0xFF, 0x81, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x80,
  0x03, 0xFC, 0x43, 0xCF, 0x63, 0x01, 0xB3, 0x80, 0x79, 0x80, 0x1D, 0xC0,
  0x0E, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0E, 0xC0,
  0x07, 0x30, 0x03, 0x98, 0x02, 0xC6, 0x03, 0x61, 0xC7, 0x30, 0x7F, 0x18,
  0x0C, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x39, 0x00, 0x38, 0xE0, 0x38, 0x3F,
  0xF8, 0x03, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x0C, 0x0C, 0x7F, 0x19, 0xCF, 0x36, 0x06, 0x78, 0x06, 0xE0, 0x0D,
  0xC0, 0x1B, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x46, 0xF6, 0x40, 0x00, 0x00,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x08, 0x38, 0x78, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x33, 0xC7,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1B,
  0x00, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x07, 0x0C, 0x18, 0x30, 0xC0,
  0xC3, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0x80, 0xDE, 0x03, 0x4C, 0x0F, 0x30,
  0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x01,
  0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x10,
  0x47, 0xF0, 0x7F, 0x27, 0x1C, 0x73, 0xD2, 0x06, 0x60, 0x6A, 0x01, 0xA0,
  0x1D, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x0C,
  0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80, 0x3C, 0x00,
  0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03, 0xC0,
  0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80, 0x3C,
  0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03,
  0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80,
  0x3C, 0x00, 0xC0, 0x18, 0x01, 0x81, 0x0F, 0xE2, 0x39, 0xE4, 0xC0, 0xEB,
  0x00, 0xD4, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0x80, 0x03, 0xFC, 0x03, 0x8F, 0x03, 0x01, 0xC3, 0x00, 0x71, 0x80, 0x19,
  0xC0, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06,
  0x60, 0x06, 0x30, 0x03, 0x1C, 0x03, 0x86, 0x03, 0x81, 0xE7, 0x80, 0x7F,
  0x80, 0x04, 0x00, 0x01, 0x80, 0x43, 0xF8, 0x23, 0x8E, 0x13, 0x01, 0x8B,
  0x00, 0xE5, 0x00, 0x32, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0xC0, 0x0C, 0xE0, 0x06, 0x78, 0x07, 0x36, 0x07,
  0x19, 0xCF, 0x0C, 0x7F, 0x06, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x03, 0xF8, 0x43,
  0x8E, 0x63, 0x81, 0xB3, 0x80, 0x79, 0x80, 0x1C, 0xC0, 0x0E, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0E, 0xE0, 0x07, 0x30, 0x03,
  0x9C, 0x02, 0xC7, 0x03, 0x61, 0xC7, 0x30, 0x7F, 0x18, 0x04, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x87,
  0xE3, 0xF9, 0x82, 0x40, 0xB0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0xFF, 0x8F, 0x1E, 0xE0, 0x26, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xA0, 0x1D, 0xE3, 0xC7, 0xFC, 0x02, 0x00, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xC6, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x10, 0xFC, 0x04, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x05, 0xE0, 0x35, 0x81, 0x97, 0x9E, 0x4F, 0xE1, 0x04, 0x00, 0xC0,
  0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x78, 0x01,
  0xC0, 0x1B, 0x00, 0x38, 0x03, 0x60, 0x0F, 0x00, 0x64, 0x01, 0xA0, 0x0C,
  0xC0, 0x34, 0x03, 0x18, 0x06, 0xC0, 0x63, 0x01, 0x98, 0x0C, 0x60, 0x33,
  0x01, 0x86, 0x06, 0x20, 0x30, 0xC0, 0xC6, 0x0C, 0x18, 0x18, 0xC1, 0x83,
  0x06, 0x18, 0x30, 0x20, 0xC3, 0x06, 0x06, 0x18, 0x20, 0x80, 0xC3, 0x06,
  0x30, 0x18, 0x40, 0xC6, 0x03, 0x18, 0x18, 0xC0, 0x33, 0x03, 0x18, 0x06,
  0x60, 0x26, 0x00, 0xCC, 0x06, 0xC0, 0x19, 0x00, 0xD8, 0x01, 0x60, 0x1B,
  0x00, 0x3C, 0x03, 0x40, 0x07, 0x80, 0x28, 0x00, 0xF0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0xC0, 0x1C, 0xC0, 0x31,
  0x80, 0xE3, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x06, 0x18, 0x0C, 0x60, 0x0C,
  0xC0, 0x1B, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0,
  0x06, 0xC0, 0x0C, 0xC0, 0x31, 0x80, 0x61, 0x81, 0x83, 0x03, 0x06, 0x0C,
  0x06, 0x18, 0x0C, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x1E, 0x00, 0x30, 0xC0,
  0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x9C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x0F, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0E, 0x03, 0xE0, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xE0, 0x0F, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x07, 0xC0, 0x78, 0x00, 0x3E,
  0x00, 0x7F, 0xE0, 0x1C, 0x1E, 0x1E, 0x01, 0xFE, 0x80, 0x0C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 38, 11, 4, -38 },
  { 16, 10, 14, 16, 3, -38 },
  { 34, 21, 38, 23, 1, -38 },
  { 134, 18, 43, 21, 2, -40 },
  { 231, 27, 38, 31, 2, -38 },
  { 360, 19, 39, 21, 2, -38 },
  { 453, 3, 14, 9, 3, -38 },
  { 459, 9, 46, 14, 3, -38 },
  { 511, 10, 46, 14, 2, -38 },
  { 569, 14, 14, 19, 2, -40 },
  { 594, 18, 25, 21, 2, -31 },
  { 651, 5, 13, 10, 2, -6 },
  { 660, 12, 2, 14, 1, -15 },
  { 663, 4, 4, 10, 3, -4 },
  { 665, 16, 38, 18, 1, -38 },
  { 741, 17, 38, 21, 2, -38 },
  { 822, 9, 38, 21, 4, -38 },
  { 865, 17, 38, 21, 2, -38 },
  { 946, 17, 39, 21, 2, -38 },
  { 1029, 20, 38, 21, 1, -38 },
  { 1124, 16, 38, 21, 3, -38 },
  { 1200, 16, 39, 21, 3, -38 },
  { 1278, 17, 38, 21, 2, -38 },
  { 1359, 17, 39, 21, 2, -38 },
  { 1442, 17, 39, 21, 2, -38 },
  { 1525, 4, 28, 10, 3, -28 },
  { 1539, 5, 35, 10, 2, -28 },
  { 1561, 18, 22, 21, 2, -30 },
  { 1611, 18, 13, 21, 2, -25 },
  { 1641, 18, 22, 21, 2, -30 },
  { 1691, 12, 38, 15, 1, -38 },
  { 1748, 27, 43, 32, 3, -38 },
  { 1894, 21, 38, 21, 0, -38 },
  { 1994, 17, 38, 23, 4, -38 },
  { 2075, 18, 39, 22, 3, -38 },
  { 2163, 19, 38, 26, 4, -38 },
  { 2254, 14, 38, 20, 4, -38 },
  { 2321, 14, 38, 19, 4, -38 },
  { 2388, 22, 39, 28, 3, -38 },
  { 2496, 18, 38, 26, 4, -38 },
  { 2582, 8, 38, 12, 2, -38 },
  { 2620, 8, 47, 10, -2, -38 },
  { 2667, 17, 38, 21, 4, -38 },
  { 2748, 13, 38, 18, 4, -38 },
  { 2810, 27, 38, 35, 4, -38 },
  { 2939, 19, 38, 27, 4, -38 },
  { 3030, 22, 39, 28, 3, -38 },
  { 3138, 16, 38, 21, 4, -38 },
  { 3214, 22, 47, 28, 3, -38 },
  { 3344, 17, 38, 22, 4, -38 },
  { 3425, 17, 39, 21, 2, -38 },
  { 3508, 18, 38, 18, 0, -38 },
  { 3594, 18, 39, 26, 4, -38 },
  { 3682, 20, 38, 20, 0, -38 },
  { 3777, 35, 38, 35, 0, -38 },
  { 3944, 18, 38, 18, 0, -38 },
  { 4030, 18, 38, 18, 0, -38 },
  { 4116, 15, 38, 18, 1, -38 },
  { 4188, 10, 46, 16, 4, -38 },
  { 4246, 16, 38, 18, 1, -38 },
  { 4322, 10, 46, 16, 2, -38 },
  { 4380, 20, 19, 21, 1, -38 },
  { 4428, 21, 2, 21, 0, 5 },
  { 4434, 8, 8, 12, 2, -40 },
  { 4442, 14, 30, 20, 2, -29 },
  { 4495, 17, 41, 23, 4, -40 },
  { 4583, 14, 30, 17, 2, -29 },
  { 4636, 17, 41, 23, 2, -40 },
  { 4724, 16, 30, 21, 2, -29 },
  { 4784, 12, 41, 12, 1, -41 },
  { 4846, 17, 42, 23, 2, -29 },
  { 4936, 15, 40, 22, 4, -40 },
  { 5011, 4, 39, 10, 3, -39 },
  { 5031, 7, 52, 10, 0, -39 },
  { 5077, 14, 40, 18, 4, -40 },
  { 5147, 2, 40, 9, 4, -40 },
  { 5157, 25, 29, 33, 4, -29 },
  { 5248, 15, 29, 22, 4, -29 },
  { 5303, 17, 30, 22, 2, -29 },
  { 5367, 17, 41, 23, 4, -29 },
  { 5455, 17, 41, 23, 2, -29 },
  { 5543, 10, 28, 14, 4, -28 },
  { 5578, 13, 30, 17, 2, -29 },
  { 5627, 10, 36, 12, 1, -35 },
  { 5672, 14, 29, 22, 4, -28 },
  { 5723, 16, 28, 16, 0, -28 },
  { 5779, 27, 28, 28, 1, -28 },
  { 5874, 15, 28, 17, 1, -28 },
  { 5927, 16, 41, 17, 1, -28 },
  { 6009, 12, 28, 14, 1, -28 },
  { 6051, 13, 46, 19, 3, -38 },
  { 6126, 2, 53, 20, 9, -40 },
  { 6140, 13, 46, 19, 3, -38 },
  { 6215, 18, 5, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT53PT7B_H_
