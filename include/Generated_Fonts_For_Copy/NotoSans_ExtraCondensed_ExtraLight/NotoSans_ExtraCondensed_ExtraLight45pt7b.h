#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x01,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x03, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFC, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x20,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x60, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0x81, 0x00, 0x20, 0x40, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x0F, 0xF8, 0x19, 0x1C, 0x31, 0x04,
  0x61, 0x00, 0x61, 0x00, 0x41, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0x41, 0x00,
  0x61, 0x00, 0x61, 0x00, 0x31, 0x00, 0x19, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x01, 0x38, 0x01, 0x1C, 0x01, 0x06, 0x01, 0x06, 0x01, 0x02,
  0x01, 0x03, 0x01, 0x03, 0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x01, 0x0C,
  0x61, 0x1C, 0x7F, 0xF0, 0x0F, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x01, 0x01, 0x8C, 0x06, 0x02, 0x08,
  0x08, 0x04, 0x10, 0x10, 0x18, 0x30, 0x60, 0x30, 0x60, 0xC0, 0x60, 0xC1,
  0x00, 0xC1, 0x86, 0x01, 0x81, 0x0C, 0x03, 0x02, 0x10, 0x06, 0x04, 0x60,
  0x0C, 0x18, 0xC0, 0x18, 0x31, 0x0C, 0x30, 0x66, 0x7E, 0x60, 0xCC, 0x84,
  0x41, 0x13, 0x0C, 0x82, 0x66, 0x09, 0x8C, 0xC8, 0x11, 0xF1, 0x10, 0x20,
  0x86, 0x20, 0x40, 0x0C, 0x40, 0xC0, 0x10, 0x81, 0x80, 0x61, 0x03, 0x00,
  0xC2, 0x06, 0x01, 0x04, 0x0C, 0x06, 0x08, 0x10, 0x0C, 0x10, 0x20, 0x10,
  0x20, 0x40, 0x60, 0x61, 0x80, 0xC0, 0x43, 0x01, 0x00, 0xCC, 0x06, 0x00,
  0xF0, 0x01, 0x00, 0x03, 0xE0, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x82, 0x00,
  0x81, 0x00, 0x40, 0xC0, 0x20, 0x60, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x08,
  0x01, 0x0C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0C, 0x80, 0x0C, 0x60, 0x06, 0x10, 0x26, 0x0C, 0x13, 0x03, 0x19,
  0x01, 0x8D, 0x80, 0x66, 0xC0, 0x12, 0x60, 0x0F, 0x30, 0x03, 0x88, 0x01,
  0x86, 0x00, 0xE3, 0x00, 0xF0, 0xC0, 0xCC, 0x71, 0xC2, 0x1F, 0xC1, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18,
  0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xE6, 0x73, 0xFC, 0x06, 0x00, 0xF0, 0x19, 0x01, 0x08,
  0x30, 0xC6, 0x06, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x36, 0x66,
  0x64, 0xCC, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x3F, 0x01, 0x86, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x09, 0x00, 0x26, 0x01, 0x98,
  0x06, 0x20, 0x18, 0xC0, 0xC3, 0x83, 0x07, 0x38, 0x0F, 0xC0, 0x03, 0x07,
  0x0D, 0x19, 0x31, 0xE1, 0x41, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x00, 0xFF, 0x0F, 0x06, 0x10,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0xFF, 0x0E, 0x06, 0x30, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x1F, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x68, 0x03, 0x38, 0x38,
  0x7F, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00,
  0x86, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x86, 0x00,
  0xC2, 0x00, 0x61, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x7F, 0xF1,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0x0F, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x3A, 0x00, 0xCE, 0x0E, 0x1F, 0xF0, 0x03, 0xF8, 0x38, 0x21, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC3, 0x83, 0x3F, 0x8D, 0x83, 0x3C, 0x06, 0xE0, 0x1B,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x40, 0x0D, 0x00, 0x36, 0x00, 0xD8, 0x02, 0x20, 0x18, 0xC0, 0x61, 0x87,
  0x03, 0xF8, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x03, 0x00, 0x7F, 0x83, 0x87, 0x18, 0x06, 0x60, 0x19, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0x98, 0x06, 0x30, 0x30, 0x61,
  0xC0, 0xCC, 0x01, 0xE0, 0x07, 0x80, 0x73, 0x03, 0x86, 0x18, 0x0C, 0x60,
  0x1B, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x36, 0x01, 0x8E, 0x1C, 0x1F, 0xE0, 0x02, 0x00,
  0x7F, 0x03, 0x86, 0x18, 0x0C, 0x60, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x40, 0x1D, 0x80, 0xB3, 0x06, 0xC7, 0xF3, 0x07, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x10, 0xF0, 0x7F, 0x00, 0xDF, 0xA0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x77, 0x72, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x18, 0x3F, 0xCC, 0x38, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x01, 0x80, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x04, 0x40, 0x7E, 0x0D, 0x81, 0xC4, 0x1B, 0x06, 0x08, 0x34, 0x0C,
  0x30, 0x28, 0x10, 0x60, 0x50, 0x60, 0xC0, 0xE0, 0xC1, 0x81, 0xC1, 0x83,
  0x03, 0x82, 0x06, 0x07, 0x04, 0x0C, 0x0E, 0x08, 0x18, 0x1C, 0x10, 0x30,
  0x38, 0x30, 0x60, 0xD0, 0x60, 0xC1, 0xA0, 0xC2, 0x82, 0x40, 0xC5, 0x8C,
  0xC1, 0xF9, 0xF1, 0x81, 0xE1, 0xC3, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x05, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x33, 0x00,
  0x08, 0xC0, 0x02, 0x30, 0x01, 0x84, 0x00, 0x61, 0x00, 0x18, 0x60, 0x04,
  0x18, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x30, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x20,
  0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x11, 0x80, 0x06, 0x60,
  0x01, 0x90, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xFF, 0xE1, 0x83, 0xE3,
  0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x02, 0xC0,
  0x05, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x06, 0x3F, 0xF8,
  0x7F, 0xF0, 0xC0, 0x39, 0x80, 0x3B, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x6C, 0x00, 0xD8, 0x03, 0x3F, 0xFC, 0x7F, 0xE0, 0x00, 0x20, 0x03, 0xFE,
  0x07, 0x03, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x87,
  0x01, 0xFE, 0xFF, 0xC0, 0xC3, 0xF0, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18,
  0xC0, 0x30, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x0E,
  0x07, 0x83, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x31, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x80, 0x18, 0x1C, 0x0F, 0x01, 0xFF,
  0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x7F, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x18, 0x30, 0x60, 0xFF, 0x7C, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x60, 0xC1,
  0x81, 0x83, 0x03, 0x0C, 0x06, 0x10, 0x0C, 0x60, 0x19, 0x80, 0x33, 0x00,
  0x6F, 0x00, 0xD6, 0x01, 0xC6, 0x03, 0x8C, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x00,
  0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xD0, 0x00, 0x0B, 0xD8,
  0x00, 0x1B, 0xD8, 0x00, 0x1B, 0xC8, 0x00, 0x13, 0xCC, 0x00, 0x33, 0xCC,
  0x00, 0x33, 0xCC, 0x00, 0x23, 0xC4, 0x00, 0x63, 0xC6, 0x00, 0x63, 0xC6,
  0x00, 0x63, 0xC2, 0x00, 0x43, 0xC3, 0x00, 0xC3, 0xC3, 0x00, 0xC3, 0xC1,
  0x00, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x81, 0x03, 0xC0,
  0x83, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0x42, 0x03, 0xC0,
  0x66, 0x03, 0xC0, 0x66, 0x03, 0xC0, 0x24, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x18, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0xC0, 0x0F, 0x20, 0x07, 0x98,
  0x03, 0xC4, 0x01, 0xE3, 0x00, 0xF1, 0x80, 0x78, 0x60, 0x3C, 0x30, 0x1E,
  0x08, 0x0F, 0x06, 0x07, 0x81, 0x03, 0xC0, 0xC1, 0xE0, 0x20, 0xF0, 0x18,
  0x78, 0x0C, 0x3C, 0x03, 0x1E, 0x01, 0x8F, 0x00, 0x47, 0x80, 0x33, 0xC0,
  0x09, 0xE0, 0x06, 0xF0, 0x03, 0x78, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x38, 0x38, 0x0E,
  0x01, 0x81, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x34, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x02, 0x60, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0x43, 0x00,
  0x18, 0x30, 0x07, 0x03, 0x00, 0xC0, 0x38, 0x70, 0x03, 0xFC, 0x00, 0xFF,
  0x83, 0x1F, 0x8C, 0x07, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x6C,
  0x01, 0xB0, 0x0C, 0xC0, 0xE3, 0xFF, 0x0F, 0xC0, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80,
  0x38, 0x38, 0x0E, 0x01, 0x81, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x21,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0xA0, 0x00, 0x34,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD0,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x03, 0x18,
  0x00, 0x43, 0x00, 0x18, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x38, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0xFF, 0x81, 0x87,
  0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0x30, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x30,
  0x0C, 0x60, 0x30, 0xFF, 0xC1, 0xFE, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x21, 0x80, 0x63, 0x00, 0xC6,
  0x00, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x03, 0x01, 0x80, 0x3F,
  0xE3, 0x81, 0x9C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x68, 0x03, 0x3C, 0x38, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1C, 0x3C, 0x0F, 0xF0, 0xC0,
  0x01, 0xE0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x26, 0x00, 0x33, 0x00, 0x18,
  0x80, 0x0C, 0x40, 0x04, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x82, 0x00,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x10, 0x0C, 0x08, 0x06,
  0x0C, 0x03, 0x06, 0x00, 0x83, 0x00, 0x41, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x02, 0x20, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x0D, 0x00,
  0x0C, 0x00, 0x66, 0x00, 0x70, 0x01, 0x98, 0x01, 0xC0, 0x06, 0x60, 0x07,
  0x80, 0x19, 0x80, 0x16, 0x00, 0x42, 0x00, 0x58, 0x03, 0x0C, 0x03, 0x20,
  0x0C, 0x30, 0x0C, 0x80, 0x30, 0xC0, 0x33, 0x00, 0x83, 0x00, 0xCC, 0x06,
  0x04, 0x02, 0x30, 0x18, 0x18, 0x18, 0x40, 0x60, 0x60, 0x61, 0x01, 0x81,
  0x81, 0x86, 0x04, 0x02, 0x06, 0x18, 0x30, 0x08, 0x10, 0x60, 0xC0, 0x30,
  0xC1, 0x83, 0x00, 0xC3, 0x02, 0x0C, 0x03, 0x0C, 0x0C, 0x20, 0x04, 0x30,
  0x31, 0x80, 0x18, 0x80, 0xC6, 0x00, 0x62, 0x01, 0x18, 0x01, 0x98, 0x04,
  0x40, 0x06, 0x60, 0x1B, 0x00, 0x09, 0x80, 0x6C, 0x00, 0x34, 0x01, 0xB0,
  0x00, 0xD0, 0x02, 0xC0, 0x03, 0xC0, 0x0A, 0x00, 0x0F, 0x00, 0x28, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x60, 0x06, 0x60, 0x08, 0xC0,
  0x30, 0xC0, 0x61, 0x81, 0x81, 0x03, 0x03, 0x06, 0x06, 0x18, 0x04, 0x30,
  0x0C, 0x40, 0x19, 0x80, 0x13, 0x00, 0x34, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x33, 0x00, 0x66, 0x00, 0x84,
  0x03, 0x0C, 0x06, 0x18, 0x18, 0x10, 0x30, 0x30, 0x40, 0x61, 0x80, 0x63,
  0x00, 0xCC, 0x01, 0x98, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x80, 0x09, 0x80,
  0x33, 0x00, 0x62, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x08, 0x08, 0x18, 0x30,
  0x30, 0x60, 0x20, 0x80, 0x63, 0x00, 0xC6, 0x00, 0x88, 0x01, 0xB0, 0x03,
  0x60, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x01, 0x80, 0x01,
  0xC0, 0x03, 0x40, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x60,
  0x02, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0,
  0xC0, 0x81, 0x81, 0x81, 0x80, 0x1F, 0x87, 0x1C, 0x40, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x01, 0xF1, 0xFF, 0x38,
  0x36, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0xC0,
  0x7C, 0x07, 0x61, 0x93, 0xF1, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x7E,
  0x33, 0x1C, 0xD0, 0x3B, 0x80, 0x6E, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x2E, 0x01, 0xB4,
  0x0E, 0xDC, 0x73, 0x3F, 0x80, 0x07, 0xF1, 0xE6, 0x38, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x20, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0xFC,
  0x47, 0x39, 0x30, 0x34, 0x80, 0x56, 0x00, 0xD8, 0x03, 0x40, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80, 0x36, 0x01, 0x4C,
  0x0D, 0x38, 0x64, 0x3F, 0x10, 0x0F, 0xC0, 0xE7, 0x0C, 0x0C, 0x40, 0x66,
  0x01, 0xB0, 0x0D, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x04, 0x70, 0xE1, 0xFE, 0x07, 0xE1, 0xC4, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x01, 0xFE, 0x7F,
  0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x0F, 0xC4, 0x73, 0x93, 0x03,
  0x58, 0x05, 0x60, 0x0D, 0x00, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x60, 0x14, 0xC0, 0xD1, 0x86, 0x43,
  0xF1, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x40, 0x31, 0xFF, 0x81, 0xF8, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x31, 0xF1, 0xB9, 0xCD, 0x03, 0x70, 0x1B, 0x80, 0x5C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x5F, 0xA0, 0x00, 0x1B, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x18, 0x71, 0x82, 0x00, 0x00, 0x00,
  0x00, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x4F, 0x38, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x08,
  0xC1, 0x8C, 0x30, 0xC3, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xDC, 0x0D, 0x60,
  0xF2, 0x0E, 0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x08, 0xC0, 0xCC, 0x0C,
  0xC0, 0x6C, 0x06, 0xC0, 0x2C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x8F, 0xC3, 0xF2, 0x63, 0x18, 0xED, 0x06, 0xC1, 0xB8,
  0x0A, 0x03, 0xE0, 0x38, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30,
  0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0x87, 0xC4, 0xE7,
  0x34, 0x0D, 0xC0, 0x6E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x0F, 0xC0, 0x73, 0xC3, 0x03, 0x18, 0x06, 0x60, 0x09, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x60,
  0x18, 0xC0, 0x61, 0x87, 0x03, 0xF8, 0x87, 0xE2, 0x31, 0xC9, 0x03, 0xBC,
  0x06, 0xE0, 0x0B, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x02, 0xE0, 0x1B, 0x40, 0xCD, 0xC7, 0x33, 0xF8,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC4, 0x73, 0x93,
  0x03, 0x4C, 0x05, 0x60, 0x0D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x60, 0x14, 0xC0, 0xD1, 0x86,
  0x43, 0xF1, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x87, 0xE7,
  0xB6, 0x1E, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x3F, 0xCE, 0x3F, 0x80, 0x60, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0xB8, 0x67, 0xF8, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x19, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xB0, 0x2D, 0xC7, 0x67, 0xF3, 0xC0, 0x0D, 0x00, 0x24, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0x42, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0,
  0x81, 0x02, 0x06, 0x18, 0x18, 0x60, 0x61, 0x00, 0x84, 0x02, 0x30, 0x0C,
  0xC0, 0x32, 0x00, 0x48, 0x01, 0x60, 0x07, 0x80, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0xC0, 0x18, 0x02, 0x80, 0x30, 0x05, 0x80, 0x60, 0x1B, 0x01, 0xE0,
  0x36, 0x03, 0xC0, 0x64, 0x06, 0x80, 0x88, 0x09, 0x03, 0x18, 0x13, 0x06,
  0x30, 0x66, 0x0C, 0x20, 0xCC, 0x10, 0x41, 0x88, 0x20, 0xC2, 0x10, 0xC1,
  0x8C, 0x31, 0x83, 0x18, 0x63, 0x02, 0x30, 0xC4, 0x04, 0x40, 0x98, 0x0C,
  0x81, 0x30, 0x1B, 0x03, 0x60, 0x36, 0x06, 0x80, 0x2C, 0x0D, 0x00, 0x50,
  0x0A, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x60, 0xC0, 0x1B,
  0x01, 0x98, 0x0C, 0x40, 0xC3, 0x06, 0x08, 0x20, 0x63, 0x01, 0x10, 0x0D,
  0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x36, 0x01, 0x30,
  0x18, 0xC0, 0x86, 0x0C, 0x10, 0x60, 0xC6, 0x02, 0x30, 0x1B, 0x00, 0xD8,
  0x03, 0x60, 0x05, 0x80, 0x36, 0x00, 0xC8, 0x02, 0x30, 0x08, 0xC0, 0x63,
  0x01, 0x84, 0x04, 0x18, 0x10, 0x60, 0xC1, 0x83, 0x02, 0x08, 0x0C, 0x20,
  0x31, 0x80, 0xC6, 0x01, 0x10, 0x06, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xA0,
  0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x3E,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x38, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x0F, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x07, 0x00, 0x30, 0x1C, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0xF0, 0x3C, 0x00, 0x3E, 0x01, 0x7F, 0x81,
  0xC1, 0xE7, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 32, 9, 3, -32 },
  { 13, 8, 11, 14, 3, -32 },
  { 24, 18, 32, 19, 1, -32 },
  { 96, 16, 37, 18, 1, -34 },
  { 170, 23, 33, 27, 2, -33 },
  { 265, 17, 33, 18, 1, -33 },
  { 336, 2, 11, 8, 3, -32 },
  { 339, 8, 39, 12, 2, -32 },
  { 378, 8, 39, 12, 2, -32 },
  { 417, 12, 12, 16, 2, -34 },
  { 435, 16, 21, 18, 1, -26 },
  { 477, 4, 11, 8, 2, -5 },
  { 483, 10, 2, 12, 1, -13 },
  { 486, 3, 3, 9, 3, -3 },
  { 488, 13, 32, 15, 1, -32 },
  { 540, 14, 33, 18, 2, -33 },
  { 598, 8, 32, 18, 3, -32 },
  { 630, 14, 33, 18, 2, -33 },
  { 688, 14, 33, 18, 2, -33 },
  { 746, 17, 32, 18, 1, -32 },
  { 814, 14, 32, 18, 2, -32 },
  { 870, 14, 33, 18, 2, -32 },
  { 928, 14, 32, 18, 2, -32 },
  { 984, 14, 33, 18, 2, -33 },
  { 1042, 14, 33, 18, 2, -33 },
  { 1100, 3, 24, 9, 3, -24 },
  { 1109, 4, 30, 8, 2, -24 },
  { 1124, 16, 18, 18, 1, -25 },
  { 1160, 16, 11, 18, 1, -21 },
  { 1182, 16, 18, 18, 1, -25 },
  { 1218, 10, 33, 12, 1, -33 },
  { 1260, 23, 36, 28, 2, -32 },
  { 1364, 18, 32, 18, 0, -32 },
  { 1436, 15, 32, 20, 3, -32 },
  { 1496, 16, 33, 19, 2, -33 },
  { 1562, 16, 32, 22, 3, -32 },
  { 1626, 12, 32, 17, 3, -32 },
  { 1674, 12, 32, 16, 3, -32 },
  { 1722, 19, 33, 24, 2, -33 },
  { 1801, 16, 32, 22, 3, -32 },
  { 1865, 7, 32, 10, 2, -32 },
  { 1893, 7, 40, 9, -2, -32 },
  { 1928, 15, 32, 18, 3, -32 },
  { 1988, 12, 32, 16, 3, -32 },
  { 2036, 24, 32, 30, 3, -32 },
  { 2132, 17, 32, 23, 3, -32 },
  { 2200, 19, 33, 23, 2, -33 },
  { 2279, 14, 32, 18, 3, -32 },
  { 2335, 19, 41, 23, 2, -33 },
  { 2433, 15, 32, 19, 3, -32 },
  { 2493, 14, 33, 18, 2, -33 },
  { 2551, 15, 32, 16, 0, -32 },
  { 2611, 16, 32, 22, 3, -32 },
  { 2675, 17, 32, 17, 0, -32 },
  { 2743, 30, 32, 30, 0, -32 },
  { 2863, 15, 32, 16, 0, -32 },
  { 2923, 15, 32, 15, 0, -32 },
  { 2983, 13, 32, 15, 1, -32 },
  { 3035, 8, 39, 14, 4, -32 },
  { 3074, 13, 32, 15, 1, -32 },
  { 3126, 8, 39, 14, 2, -32 },
  { 3165, 16, 16, 18, 1, -32 },
  { 3197, 18, 2, 18, 0, 4 },
  { 3202, 7, 7, 10, 2, -34 },
  { 3209, 12, 24, 17, 2, -24 },
  { 3245, 14, 34, 19, 3, -34 },
  { 3305, 12, 24, 14, 2, -24 },
  { 3341, 14, 34, 19, 2, -34 },
  { 3401, 13, 24, 17, 2, -24 },
  { 3440, 11, 34, 10, 0, -34 },
  { 3487, 14, 35, 19, 2, -24 },
  { 3549, 13, 34, 19, 3, -34 },
  { 3605, 3, 33, 8, 3, -33 },
  { 3618, 6, 44, 8, 0, -33 },
  { 3651, 12, 34, 15, 3, -34 },
  { 3702, 2, 34, 8, 3, -34 },
  { 3711, 22, 24, 28, 3, -24 },
  { 3777, 13, 24, 19, 3, -24 },
  { 3816, 14, 24, 19, 2, -24 },
  { 3858, 14, 35, 19, 3, -24 },
  { 3920, 14, 35, 19, 2, -24 },
  { 3982, 9, 24, 12, 3, -24 },
  { 4009, 11, 24, 14, 2, -24 },
  { 4042, 8, 30, 10, 1, -30 },
  { 4072, 13, 24, 19, 3, -24 },
  { 4111, 14, 24, 14, 0, -24 },
  { 4153, 23, 24, 24, 0, -24 },
  { 4222, 13, 24, 15, 1, -24 },
  { 4261, 14, 35, 15, 0, -24 },
  { 4323, 10, 24, 12, 1, -24 },
  { 4353, 12, 39, 16, 2, -32 },
  { 4412, 1, 45, 17, 8, -34 },
  { 4418, 11, 39, 16, 2, -32 },
  { 4472, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT45PT7B_H_
