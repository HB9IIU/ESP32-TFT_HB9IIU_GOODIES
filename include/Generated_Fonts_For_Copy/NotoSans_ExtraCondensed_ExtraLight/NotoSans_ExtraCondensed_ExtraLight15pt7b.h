#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x28, 0xA2, 0x9F, 0x28, 0xA4, 0xBF, 0x49,
  0x45, 0x00, 0x11, 0xAA, 0x28, 0x60, 0xC2, 0x89, 0x24, 0xA7, 0x08, 0xC5,
  0x52, 0xA5, 0x4B, 0x57, 0x76, 0x95, 0x2A, 0x55, 0x38, 0x31, 0x45, 0x14,
  0x30, 0x85, 0x65, 0x8A, 0x27, 0x40, 0xF0, 0x5A, 0xAA, 0xA9, 0x40, 0xA5,
  0x55, 0x56, 0x80, 0x4F, 0x4A, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0xF0,
  0xF0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x69, 0x99, 0x99,
  0x99, 0x99, 0x60, 0x2E, 0x92, 0x49, 0x24, 0x80, 0xE1, 0x11, 0x11, 0x24,
  0x48, 0xF0, 0xE1, 0x11, 0x16, 0x11, 0x11, 0xE0, 0x08, 0x61, 0x8A, 0x29,
  0x24, 0xA2, 0x7C, 0x20, 0x80, 0xF8, 0x88, 0xE1, 0x11, 0x11, 0xE0, 0x78,
  0x88, 0xE9, 0x99, 0x99, 0xF0, 0xF1, 0x11, 0x22, 0x24, 0x44, 0x80, 0x69,
  0x99, 0x96, 0x99, 0x99, 0xF0, 0x69, 0x99, 0x99, 0x71, 0x11, 0xE0, 0x81,
  0x83, 0xC0, 0x1C, 0x8C, 0x18, 0x18, 0x10, 0xFC, 0x00, 0x3F, 0xE0, 0x40,
  0xC6, 0x62, 0x00, 0xE1, 0x11, 0x22, 0x44, 0x00, 0x40, 0x38, 0x8A, 0x0C,
  0xDA, 0xB5, 0x6A, 0xD5, 0xAB, 0x2A, 0x03, 0xE0, 0x20, 0xC3, 0x0C, 0x49,
  0x27, 0x92, 0x8A, 0x18, 0x40, 0xF4, 0x63, 0x18, 0xFA, 0x31, 0x8C, 0x7C,
  0x3A, 0x21, 0x08, 0x42, 0x10, 0x84, 0x1E, 0xF4, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x7C, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0xF0, 0xF8, 0x88, 0x8F, 0x88,
  0x88, 0x80, 0x3D, 0x08, 0x20, 0x82, 0x68, 0x61, 0x86, 0x17, 0xC0, 0x8C,
  0x63, 0x18, 0xFE, 0x31, 0x8C, 0x62, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49,
  0x24, 0x93, 0x80, 0x8C, 0xA5, 0x4C, 0x62, 0x94, 0x94, 0xA2, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0x81, 0x81, 0xC3, 0xC3, 0xC5, 0xA5, 0xA5, 0xA5,
  0x99, 0x99, 0x91, 0x86, 0x1C, 0x71, 0xA6, 0x99, 0x65, 0x8E, 0x38, 0x40,
  0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0xE4, 0xA3, 0x18,
  0xCB, 0x90, 0x84, 0x20, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x16,
  0x84, 0x08, 0x20, 0xE4, 0xA3, 0x18, 0xEA, 0x92, 0x94, 0xA2, 0x78, 0x88,
  0x86, 0x11, 0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x5C, 0x86, 0x18, 0x92, 0x49, 0x25, 0x14,
  0x30, 0xC2, 0x00, 0x88, 0x62, 0x18, 0xC5, 0x32, 0x4C, 0x95, 0x25, 0x29,
  0x4C, 0x33, 0x08, 0xC2, 0x10, 0x8A, 0x54, 0xA2, 0x10, 0x8A, 0x52, 0x62,
  0x8C, 0x54, 0xA5, 0x10, 0x84, 0x21, 0x08, 0x78, 0x84, 0x22, 0x10, 0x88,
  0x42, 0x3E, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x10, 0x82, 0x10, 0x82,
  0x10, 0x82, 0xD5, 0x55, 0x55, 0xC0, 0x10, 0xC2, 0x92, 0x46, 0x10, 0xFC,
  0x90, 0xE1, 0x17, 0x99, 0x9F, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x7C,
  0x78, 0x88, 0x88, 0x87, 0x11, 0x17, 0x99, 0x99, 0x99, 0xF0, 0x69, 0x9F,
  0x88, 0x87, 0x74, 0x4E, 0x44, 0x44, 0x44, 0x40, 0x79, 0x99, 0x99, 0x9F,
  0x11, 0x1E, 0x88, 0x8F, 0x99, 0x99, 0x99, 0x90, 0x9F, 0xE0, 0x41, 0x55,
  0x55, 0x58, 0x88, 0x89, 0xAA, 0xCA, 0xA9, 0x90, 0xFF, 0xE0, 0xFF, 0x26,
  0x4C, 0x99, 0x32, 0x64, 0xC9, 0xF9, 0x99, 0x99, 0x99, 0x79, 0x99, 0x99,
  0x97, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x21, 0x00, 0x79, 0x99, 0x99,
  0x9F, 0x11, 0x11, 0xF2, 0x49, 0x24, 0xF2, 0x46, 0x4F, 0x4B, 0xA4, 0x92,
  0x4C, 0x99, 0x99, 0x99, 0x9F, 0x8C, 0xA4, 0xA5, 0x30, 0x84, 0x89, 0x99,
  0x99, 0x5A, 0x56, 0x66, 0x24, 0x24, 0x8A, 0x94, 0x42, 0x29, 0x51, 0x8C,
  0x54, 0xA5, 0x28, 0x84, 0x21, 0x11, 0x00, 0x72, 0x22, 0x44, 0x4F, 0x34,
  0x44, 0x44, 0x84, 0x44, 0x44, 0x70, 0xFF, 0xFE, 0x89, 0x24, 0x8A, 0x49,
  0x2C, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 6, 11, 6, 0, -11 },
  { 14, 6, 12, 6, 0, -11 },
  { 23, 7, 11, 9, 1, -11 },
  { 33, 6, 11, 6, 0, -11 },
  { 42, 1, 4, 3, 1, -11 },
  { 43, 2, 13, 4, 1, -11 },
  { 47, 2, 13, 4, 1, -11 },
  { 51, 4, 4, 5, 1, -11 },
  { 53, 6, 7, 6, 0, -9 },
  { 59, 1, 4, 3, 1, -2 },
  { 60, 4, 1, 4, 0, -5 },
  { 61, 1, 1, 3, 1, -1 },
  { 62, 5, 11, 5, 0, -11 },
  { 69, 4, 11, 6, 1, -11 },
  { 75, 3, 11, 6, 1, -11 },
  { 80, 4, 11, 6, 1, -11 },
  { 86, 4, 11, 6, 1, -11 },
  { 92, 6, 11, 6, 0, -11 },
  { 101, 4, 11, 6, 1, -11 },
  { 107, 4, 11, 6, 1, -11 },
  { 113, 4, 11, 6, 1, -11 },
  { 119, 4, 11, 6, 1, -11 },
  { 125, 4, 11, 6, 1, -11 },
  { 131, 1, 8, 3, 1, -8 },
  { 132, 1, 10, 3, 1, -8 },
  { 134, 6, 6, 6, 0, -8 },
  { 139, 6, 4, 6, 0, -7 },
  { 142, 6, 6, 6, 0, -8 },
  { 147, 4, 11, 4, 0, -11 },
  { 153, 7, 12, 9, 1, -11 },
  { 164, 6, 11, 6, 0, -11 },
  { 173, 5, 11, 7, 1, -11 },
  { 180, 5, 11, 6, 1, -11 },
  { 187, 5, 11, 7, 1, -11 },
  { 194, 4, 11, 6, 1, -11 },
  { 200, 4, 11, 5, 1, -11 },
  { 206, 6, 11, 8, 1, -11 },
  { 215, 5, 11, 7, 1, -11 },
  { 222, 2, 11, 3, 1, -11 },
  { 225, 3, 14, 3, -1, -11 },
  { 231, 5, 11, 6, 1, -11 },
  { 238, 4, 11, 5, 1, -11 },
  { 244, 8, 11, 10, 1, -11 },
  { 255, 6, 11, 8, 1, -11 },
  { 264, 6, 11, 8, 1, -11 },
  { 273, 5, 11, 6, 1, -11 },
  { 280, 6, 14, 8, 1, -11 },
  { 291, 5, 11, 6, 1, -11 },
  { 298, 4, 11, 6, 1, -11 },
  { 304, 5, 11, 5, 0, -11 },
  { 311, 5, 11, 7, 1, -11 },
  { 318, 6, 11, 6, 0, -11 },
  { 327, 10, 11, 10, 0, -11 },
  { 341, 5, 11, 5, 0, -11 },
  { 348, 5, 11, 5, 0, -11 },
  { 355, 5, 11, 5, 0, -11 },
  { 362, 3, 13, 5, 1, -11 },
  { 367, 5, 11, 5, 0, -11 },
  { 374, 2, 13, 5, 1, -11 },
  { 378, 6, 6, 6, 0, -11 },
  { 383, 6, 1, 6, 0, 1 },
  { 384, 2, 2, 4, 1, -11 },
  { 385, 4, 8, 6, 1, -8 },
  { 389, 5, 11, 6, 1, -11 },
  { 396, 4, 8, 5, 1, -8 },
  { 400, 4, 11, 6, 1, -11 },
  { 406, 4, 8, 6, 1, -8 },
  { 410, 4, 11, 3, 0, -11 },
  { 416, 4, 12, 6, 1, -8 },
  { 422, 4, 11, 6, 1, -11 },
  { 428, 1, 11, 3, 1, -11 },
  { 430, 2, 15, 3, 0, -11 },
  { 434, 4, 11, 5, 1, -11 },
  { 440, 1, 11, 3, 1, -11 },
  { 442, 7, 8, 9, 1, -8 },
  { 449, 4, 8, 6, 1, -8 },
  { 453, 4, 8, 6, 1, -8 },
  { 457, 5, 12, 6, 1, -8 },
  { 465, 4, 12, 6, 1, -8 },
  { 471, 3, 8, 4, 1, -8 },
  { 474, 3, 8, 5, 1, -8 },
  { 477, 3, 10, 3, 0, -10 },
  { 481, 4, 8, 6, 1, -8 },
  { 485, 5, 8, 5, 0, -8 },
  { 490, 8, 8, 8, 0, -8 },
  { 498, 5, 8, 5, 0, -8 },
  { 503, 5, 12, 5, 0, -8 },
  { 511, 4, 8, 4, 0, -8 },
  { 515, 4, 13, 5, 1, -11 },
  { 522, 1, 15, 6, 2, -11 },
  { 524, 3, 13, 5, 1, -11 },
  { 529, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT15PT7B_H_
