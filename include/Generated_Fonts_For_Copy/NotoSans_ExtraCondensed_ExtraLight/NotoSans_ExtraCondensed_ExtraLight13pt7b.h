#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x29, 0x5E, 0xA5, 0x7D, 0x4A, 0x50, 0x23, 0xA9,
  0x46, 0x18, 0xA5, 0xAB, 0x88, 0xCB, 0x4D, 0x36, 0xF4, 0xD3, 0x55, 0x4C,
  0x72, 0x94, 0x46, 0x56, 0x71, 0x78, 0xE0, 0x6A, 0xAA, 0xA4, 0xC8, 0x92,
  0x49, 0x2B, 0x00, 0x55, 0x50, 0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80,
  0x11, 0x22, 0x24, 0x44, 0x80, 0xE9, 0x99, 0x99, 0x99, 0xE0, 0x75, 0x55,
  0x40, 0xF0, 0x42, 0x21, 0x10, 0x88, 0xF8, 0xF0, 0x42, 0x27, 0x04, 0x21,
  0xF0, 0x10, 0x8C, 0xA5, 0x4B, 0xE2, 0x10, 0xE8, 0x8E, 0x11, 0x11, 0xE0,
  0xE8, 0x8E, 0x99, 0x99, 0xE0, 0xF2, 0x22, 0x44, 0x44, 0x80, 0x74, 0x52,
  0xA7, 0x26, 0x31, 0x70, 0x74, 0x63, 0x15, 0x94, 0x22, 0xE0, 0x82, 0x40,
  0x05, 0x80, 0x1B, 0x30, 0x41, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00,
  0xE4, 0x94, 0x90, 0x40, 0x7A, 0x19, 0x6D, 0xD7, 0x5D, 0x6A, 0x81, 0xE0,
  0x21, 0x14, 0xA5, 0x3A, 0x31, 0x88, 0xF9, 0x99, 0xF9, 0x99, 0xE0, 0x78,
  0x88, 0x88, 0x88, 0x70, 0xF4, 0xA3, 0x18, 0xC6, 0x32, 0xE0, 0xF2, 0x4F,
  0x24, 0xE0, 0xF2, 0x4F, 0x24, 0x80, 0x7C, 0x21, 0x09, 0xC6, 0x31, 0x78,
  0x99, 0x99, 0xF9, 0x99, 0x90, 0xE9, 0x24, 0x92, 0xE0, 0x24, 0x92, 0x49,
  0x27, 0x80, 0x9A, 0xAC, 0xCA, 0xA9, 0x90, 0x92, 0x49, 0x24, 0xE0, 0x83,
  0x0F, 0x1E, 0x3C, 0xB5, 0x6A, 0xD9, 0x92, 0x8C, 0x73, 0x9A, 0xD6, 0x71,
  0x88, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF9, 0x99, 0xE8, 0x88, 0x80,
  0xF4, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x84, 0xF9, 0x99, 0xEA, 0xA9, 0x90,
  0xE8, 0x88, 0x61, 0x11, 0xE0, 0xF2, 0x22, 0x22, 0x22, 0x20, 0x99, 0x99,
  0x99, 0x99, 0x70, 0x8C, 0x62, 0xA5, 0x29, 0x44, 0x20, 0x88, 0xC4, 0xA6,
  0x4A, 0xA5, 0x52, 0xA9, 0x98, 0xC4, 0x22, 0x00, 0x95, 0x52, 0x26, 0x59,
  0x90, 0x99, 0x56, 0x22, 0x22, 0x20, 0xF1, 0x22, 0x24, 0x44, 0xF0, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49,
  0x27, 0x80, 0x22, 0x95, 0x10, 0xF8, 0xB0, 0x71, 0x17, 0x99, 0x70, 0x88,
  0x8E, 0x99, 0x99, 0x9E, 0x72, 0x49, 0x38, 0x11, 0x1F, 0x99, 0x99, 0x9F,
  0xF6, 0xF9, 0x38, 0x69, 0x74, 0x92, 0x48, 0xF9, 0x99, 0x99, 0xF1, 0x1E,
  0x88, 0x8E, 0x99, 0x99, 0x99, 0xBF, 0x80, 0x45, 0x55, 0x56, 0x92, 0x5B,
  0xB5, 0xB4, 0xFF, 0xC0, 0xFE, 0x59, 0x65, 0x96, 0x59, 0x40, 0xE9, 0x99,
  0x99, 0x90, 0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x99, 0x99, 0xE8, 0x88, 0xF9,
  0x99, 0x99, 0xF1, 0x11, 0xEA, 0xA8, 0x78, 0x86, 0x11, 0xE0, 0x4B, 0xA4,
  0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x99, 0x96, 0x66, 0x40, 0x93, 0x26,
  0xAB, 0x66, 0xCD, 0x91, 0x00, 0x95, 0x62, 0x65, 0x90, 0x99, 0x55, 0x62,
  0x22, 0x4C, 0x64, 0xA4, 0xB8, 0x69, 0x25, 0x12, 0x49, 0x80, 0xFF, 0xF8,
  0xC9, 0x24, 0x52, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 5, 9, 6, 0, -9 },
  { 10, 5, 11, 5, 0, -10 },
  { 17, 6, 9, 8, 1, -9 },
  { 24, 5, 9, 5, 0, -9 },
  { 30, 1, 3, 2, 1, -9 },
  { 31, 2, 11, 4, 1, -9 },
  { 34, 3, 11, 4, 0, -9 },
  { 39, 3, 4, 5, 1, -10 },
  { 41, 5, 6, 5, 0, -8 },
  { 45, 2, 3, 2, 0, -1 },
  { 46, 3, 1, 3, 0, -4 },
  { 47, 1, 1, 2, 1, -1 },
  { 48, 4, 9, 4, 0, -9 },
  { 53, 4, 9, 5, 1, -9 },
  { 58, 2, 9, 5, 1, -9 },
  { 61, 5, 9, 5, 0, -9 },
  { 67, 5, 9, 5, 0, -9 },
  { 73, 5, 9, 5, 0, -9 },
  { 79, 4, 9, 5, 1, -9 },
  { 84, 4, 9, 5, 1, -9 },
  { 89, 4, 9, 5, 1, -9 },
  { 94, 5, 9, 5, 0, -9 },
  { 100, 5, 9, 5, 0, -9 },
  { 106, 1, 7, 2, 1, -7 },
  { 107, 2, 9, 2, 0, -7 },
  { 110, 5, 5, 5, 0, -7 },
  { 114, 5, 3, 5, 0, -6 },
  { 116, 5, 5, 5, 0, -7 },
  { 120, 3, 9, 4, 0, -9 },
  { 124, 6, 10, 8, 1, -9 },
  { 132, 5, 9, 5, 0, -9 },
  { 138, 4, 9, 6, 1, -9 },
  { 143, 4, 9, 5, 1, -9 },
  { 148, 5, 9, 6, 1, -9 },
  { 154, 3, 9, 5, 1, -9 },
  { 158, 3, 9, 5, 1, -9 },
  { 162, 5, 9, 7, 1, -9 },
  { 168, 4, 9, 6, 1, -9 },
  { 173, 3, 9, 3, 0, -9 },
  { 177, 3, 11, 3, -1, -9 },
  { 182, 4, 9, 5, 1, -9 },
  { 187, 3, 9, 5, 1, -9 },
  { 191, 7, 9, 9, 1, -9 },
  { 199, 5, 9, 7, 1, -9 },
  { 205, 5, 9, 7, 1, -9 },
  { 211, 4, 9, 5, 1, -9 },
  { 216, 5, 11, 7, 1, -9 },
  { 223, 4, 9, 5, 1, -9 },
  { 228, 4, 9, 5, 1, -9 },
  { 233, 4, 9, 4, 0, -9 },
  { 238, 4, 9, 6, 1, -9 },
  { 243, 5, 9, 5, 0, -9 },
  { 249, 9, 9, 9, 0, -9 },
  { 260, 4, 9, 4, 0, -9 },
  { 265, 4, 9, 4, 0, -9 },
  { 270, 4, 9, 4, 0, -9 },
  { 275, 3, 11, 4, 1, -9 },
  { 280, 4, 9, 4, 0, -9 },
  { 285, 3, 11, 4, 0, -9 },
  { 290, 5, 4, 5, 0, -9 },
  { 293, 5, 1, 5, 0, 1 },
  { 294, 2, 2, 3, 1, -10 },
  { 295, 4, 7, 5, 0, -7 },
  { 299, 4, 10, 6, 1, -10 },
  { 304, 3, 7, 4, 1, -7 },
  { 307, 4, 10, 6, 1, -10 },
  { 312, 3, 7, 5, 1, -7 },
  { 315, 3, 10, 3, 0, -10 },
  { 319, 4, 10, 6, 1, -7 },
  { 324, 4, 10, 5, 1, -10 },
  { 329, 1, 9, 2, 1, -9 },
  { 331, 2, 12, 2, 0, -9 },
  { 334, 3, 10, 4, 1, -10 },
  { 338, 1, 10, 2, 1, -10 },
  { 340, 6, 7, 8, 1, -7 },
  { 346, 4, 7, 5, 1, -7 },
  { 350, 4, 7, 5, 1, -7 },
  { 354, 4, 10, 6, 1, -7 },
  { 359, 4, 10, 6, 1, -7 },
  { 364, 2, 7, 4, 1, -7 },
  { 366, 4, 7, 4, 0, -7 },
  { 370, 3, 9, 3, 0, -9 },
  { 374, 4, 7, 5, 1, -7 },
  { 378, 4, 7, 4, 0, -7 },
  { 382, 7, 7, 7, 0, -7 },
  { 389, 4, 7, 4, 0, -7 },
  { 393, 4, 10, 4, 0, -7 },
  { 398, 3, 7, 3, 0, -7 },
  { 401, 3, 11, 5, 1, -9 },
  { 406, 1, 13, 5, 2, -10 },
  { 408, 3, 11, 5, 1, -9 },
  { 413, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT13PT7B_H_
