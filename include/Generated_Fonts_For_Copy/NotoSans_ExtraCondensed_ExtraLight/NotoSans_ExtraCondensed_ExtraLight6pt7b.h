#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0xFF, 0x69, 0xC0, 0xB5, 0xB0, 0x6F, 0x80, 0xF8, 0xF8,
  0x70, 0x74, 0xC0, 0x80, 0x80, 0x5A, 0xFF, 0xD5, 0xD7, 0xD7, 0x7D, 0xF7,
  0xFF, 0xD6, 0xDF, 0xF7, 0xA0, 0xB0, 0xD0, 0xF0, 0xF0, 0xDA, 0xFE, 0xE4,
  0x7F, 0xFF, 0xEB, 0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xF0, 0xBE, 0xD0, 0xF0,
  0xF8, 0xEF, 0xAB, 0x99, 0xFD, 0xBE, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xF2,
  0xFF, 0xE7, 0xD5, 0xB6, 0xF0, 0xF6, 0xDD, 0x6A, 0xEB, 0xEA, 0xDB, 0xEA,
  0xC0, 0xA5, 0xF8, 0x70, 0xC0, 0x80, 0xFC, 0xAF, 0xC0, 0xEC, 0x5F, 0xC0,
  0xEC, 0xF8, 0xFF, 0xAF, 0xC0, 0xF0, 0xF8, 0xAE, 0xC0, 0xF8, 0xFF, 0x80,
  0xFC, 0xFC, 0xFE, 0xFD, 0xE8, 0xDC, 0xF0, 0xFC, 0xE8, 0xFE, 0x80, 0xEC,
  0xEA, 0xE0, 0x59, 0x40, 0xFC, 0xD5, 0xC0, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 0, -4 },
  { 3, 2, 4, 3, 0, -4 },
  { 4, 2, 5, 2, 0, -5 },
  { 6, 3, 4, 4, 0, -4 },
  { 8, 2, 4, 2, 0, -4 },
  { 9, 1, 1, 1, 0, -4 },
  { 10, 1, 5, 2, 0, -4 },
  { 11, 1, 5, 2, 0, -4 },
  { 12, 2, 2, 2, 0, -5 },
  { 13, 2, 3, 2, 0, -4 },
  { 14, 1, 2, 1, 0, -1 },
  { 15, 1, 1, 2, 0, -2 },
  { 16, 1, 1, 1, 0, -1 },
  { 17, 2, 4, 2, 0, -4 },
  { 18, 2, 4, 2, 0, -4 },
  { 19, 2, 4, 2, 0, -4 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 2, 4, 2, 0, -4 },
  { 28, 1, 3, 1, 0, -3 },
  { 29, 1, 4, 1, 0, -3 },
  { 30, 2, 2, 2, 0, -3 },
  { 31, 2, 2, 2, 0, -3 },
  { 32, 2, 2, 2, 0, -3 },
  { 33, 2, 4, 2, 0, -4 },
  { 34, 3, 5, 4, 0, -4 },
  { 36, 2, 4, 2, 0, -4 },
  { 37, 2, 4, 3, 0, -4 },
  { 38, 2, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 2, 4, 2, 0, -4 },
  { 42, 2, 4, 2, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 1, 4, 1, 0, -4 },
  { 48, 1, 5, 1, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 4, 4, 4, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 2, 4, 2, 0, -4 },
  { 58, 3, 5, 3, 0, -4 },
  { 60, 2, 4, 3, 0, -4 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 2, 5, 2, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 1, 5, 2, 0, -4 },
  { 75, 2, 2, 2, 0, -4 },
  { 76, 2, 1, 2, 0, 0 },
  { 77, 1, 1, 1, 0, -5 },
  { 78, 2, 3, 2, 0, -3 },
  { 79, 2, 5, 3, 0, -5 },
  { 81, 2, 3, 2, 0, -3 },
  { 82, 2, 5, 3, 0, -5 },
  { 84, 2, 3, 2, 0, -3 },
  { 85, 1, 5, 1, 0, -5 },
  { 86, 2, 4, 3, 0, -3 },
  { 87, 2, 5, 3, 0, -5 },
  { 89, 1, 4, 1, 0, -4 },
  { 90, 1, 5, 1, 0, -4 },
  { 91, 2, 5, 2, 0, -5 },
  { 93, 1, 5, 1, 0, -5 },
  { 94, 3, 3, 4, 0, -3 },
  { 96, 2, 3, 3, 0, -3 },
  { 97, 2, 3, 2, 0, -3 },
  { 98, 2, 4, 3, 0, -3 },
  { 99, 2, 4, 3, 0, -3 },
  { 100, 2, 3, 2, 0, -3 },
  { 101, 2, 3, 2, 0, -3 },
  { 102, 1, 4, 1, 0, -4 },
  { 103, 2, 3, 3, 0, -3 },
  { 104, 2, 3, 2, 0, -3 },
  { 105, 3, 3, 3, 0, -3 },
  { 107, 2, 3, 2, 0, -3 },
  { 108, 2, 4, 2, 0, -3 },
  { 109, 1, 3, 2, 0, -3 },
  { 110, 2, 5, 2, 0, -4 },
  { 112, 1, 6, 2, 1, -5 },
  { 113, 2, 5, 2, 0, -4 },
  { 115, 2, 1, 2, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT6PT7B_H_
