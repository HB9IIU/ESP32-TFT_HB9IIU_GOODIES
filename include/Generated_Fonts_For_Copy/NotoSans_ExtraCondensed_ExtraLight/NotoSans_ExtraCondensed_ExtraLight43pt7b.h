#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xD9, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x0F,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x02, 0x04, 0x01, 0x06, 0x00, 0x83, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x30,
  0x40, 0x18, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0,
  0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x18, 0x20, 0x08, 0x10,
  0x04, 0x08, 0x02, 0x04, 0x01, 0x06, 0x0F, 0xFF, 0xF0, 0xC1, 0x80, 0x60,
  0xC0, 0x30, 0x40, 0x18, 0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01,
  0x06, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x7F, 0x81, 0xD7, 0xC6, 0x21, 0x18, 0x40, 0x20, 0x80, 0x41, 0x01, 0x82,
  0x03, 0x04, 0x02, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x0C, 0x80,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x09, 0x80, 0x11, 0x80, 0x21, 0x80,
  0x41, 0x80, 0x83, 0x01, 0x06, 0x02, 0x0C, 0x04, 0x18, 0x08, 0x20, 0x10,
  0xD8, 0x23, 0x1F, 0xFC, 0x07, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x3C, 0x01, 0x01, 0x98, 0x04, 0x04, 0x30, 0x30, 0x10, 0xC0,
  0x80, 0xC1, 0x02, 0x03, 0x04, 0x18, 0x08, 0x10, 0x40, 0x20, 0x61, 0x00,
  0x81, 0x8C, 0x02, 0x06, 0x20, 0x08, 0x18, 0x80, 0x20, 0x66, 0x00, 0x81,
  0x10, 0xE3, 0x04, 0x46, 0xCC, 0x13, 0x21, 0x10, 0xC8, 0x86, 0x43, 0x26,
  0x09, 0x99, 0x98, 0x23, 0xC4, 0x40, 0x80, 0x11, 0x02, 0x00, 0xC4, 0x08,
  0x03, 0x10, 0x30, 0x08, 0x40, 0xC0, 0x61, 0x02, 0x01, 0x84, 0x08, 0x04,
  0x10, 0x20, 0x30, 0x60, 0x80, 0xC1, 0x86, 0x02, 0x02, 0x18, 0x18, 0x0C,
  0xC0, 0x60, 0x1E, 0x00, 0x07, 0x80, 0x0C, 0xC0, 0x18, 0x40, 0x10, 0x60,
  0x10, 0x60, 0x10, 0x20, 0x10, 0x20, 0x10, 0x60, 0x10, 0x60, 0x18, 0x60,
  0x18, 0x40, 0x08, 0xC0, 0x0D, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x1B, 0x00, 0x31, 0x80, 0x60, 0x82, 0x60, 0xC2, 0x40, 0x42, 0xC0, 0x66,
  0xC0, 0x26, 0xC0, 0x34, 0xC0, 0x1C, 0xC0, 0x0C, 0x40, 0x1C, 0x60, 0x14,
  0x60, 0x36, 0x38, 0xE3, 0x1F, 0x83, 0xFF, 0xFE, 0xA8, 0x03, 0x06, 0x04,
  0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x81,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC3, 0x04, 0x10, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0C, 0x46, 0xEB, 0x83, 0x80, 0x70, 0x1B, 0x02, 0x30, 0x82,
  0x30, 0x20, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x36, 0x66, 0x64, 0xCC, 0x88, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x0F, 0x80, 0xEE, 0x0C, 0x18, 0x60, 0x66, 0x03,
  0x30, 0x09, 0x00, 0x48, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x68, 0x03, 0x40, 0x1B, 0x00, 0x98, 0x0C,
  0x60, 0x63, 0x06, 0x0E, 0x60, 0x3E, 0x00, 0x03, 0x07, 0x0F, 0x1B, 0x33,
  0x63, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x1F, 0x83, 0xCE, 0x30, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xDE, 0x30, 0x19, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x7E, 0x03, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x68, 0x07, 0x60, 0x73, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x50, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xB0, 0x01, 0xB0, 0x01, 0x30,
  0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x30, 0x08, 0x30,
  0x18, 0x30, 0x10, 0x30, 0x30, 0x30, 0x20, 0x30, 0x60, 0x30, 0x60, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x7F, 0xF3,
  0xFF, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xE1, 0x83, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x68, 0x06, 0x70, 0xE1, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x87, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x78, 0x6F, 0xF3,
  0x40, 0xDC, 0x06, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x06, 0xC0, 0x23, 0x03,
  0x0C, 0x30, 0x3F, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0xF7, 0x87,
  0x03, 0x18, 0x04, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x19,
  0x00, 0x66, 0x03, 0x0C, 0x0C, 0x18, 0x60, 0x37, 0x00, 0x70, 0x03, 0xE0,
  0x18, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x06, 0xC0, 0x1A, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xB0, 0x06, 0x60, 0x30, 0xC1,
  0x81, 0xFC, 0x00, 0x0F, 0x81, 0xCE, 0x18, 0x18, 0xC0, 0x4C, 0x03, 0x60,
  0x0B, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x68, 0x07, 0x60, 0x79, 0x86, 0xC7, 0xE6, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x21, 0xC1, 0xFC, 0x00, 0xFD, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x67, 0x72, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x66, 0x66,
  0x4C, 0xC8, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x7E, 0x39, 0xC8, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xBE, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x20, 0x60, 0x00, 0xC1, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x20, 0x00, 0x09,
  0x80, 0xF8, 0x26, 0x06, 0x20, 0xD0, 0x30, 0x83, 0x41, 0x82, 0x05, 0x06,
  0x08, 0x1C, 0x10, 0x20, 0x70, 0x40, 0x81, 0xC1, 0x02, 0x07, 0x04, 0x18,
  0x1C, 0x10, 0x60, 0x70, 0x41, 0x81, 0xC1, 0x06, 0x0F, 0x04, 0x18, 0x3C,
  0x10, 0x60, 0x90, 0x63, 0x86, 0x40, 0xD9, 0x31, 0x81, 0xC7, 0xC6, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x09, 0x80, 0x04, 0x40, 0x06, 0x20, 0x03, 0x18, 0x01, 0x0C, 0x00,
  0x82, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x10, 0x10, 0x18, 0x08,
  0x0C, 0x06, 0x07, 0xFF, 0x02, 0x01, 0x81, 0x00, 0x41, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x64,
  0x00, 0x16, 0x00, 0x0F, 0x00, 0x06, 0xFF, 0x83, 0xFF, 0x8C, 0x03, 0x30,
  0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x2C,
  0x00, 0xB0, 0x06, 0xC0, 0x33, 0x01, 0xCF, 0xFC, 0x3F, 0xF8, 0xC0, 0x33,
  0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x3B, 0xFF, 0xCF, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0x3C, 0x38, 0x08, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0xC0, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0x83, 0x01, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x01, 0xB0,
  0x03, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x66, 0x00, 0xCC, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEF, 0xFE, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0xFB, 0xE0, 0x60, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1F, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x58, 0x00, 0x16, 0x00,
  0x05, 0x80, 0x01, 0x20, 0x00, 0x4C, 0x00, 0x11, 0x80, 0x04, 0x60, 0x01,
  0x0C, 0x00, 0x41, 0xE0, 0x70, 0x1F, 0xF8, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0x80, 0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0xDF, 0x9C, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0x30, 0x0C,
  0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x0C, 0x30,
  0x31, 0x80, 0xCC, 0x03, 0x30, 0x0D, 0xC0, 0x35, 0x00, 0xF6, 0x03, 0x88,
  0x0C, 0x30, 0x30, 0x40, 0xC1, 0x83, 0x02, 0x0C, 0x0C, 0x30, 0x10, 0xC0,
  0x63, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xC0,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x17, 0x40, 0x00, 0xDD,
  0x80, 0x03, 0x76, 0x00, 0x09, 0xC8, 0x00, 0x67, 0x20, 0x01, 0x9C, 0xC0,
  0x04, 0x73, 0x00, 0x11, 0xC4, 0x00, 0xC7, 0x18, 0x03, 0x1C, 0x60, 0x08,
  0x70, 0x80, 0x61, 0xC3, 0x01, 0x87, 0x0C, 0x04, 0x1C, 0x10, 0x30, 0x70,
  0x40, 0xC1, 0xC1, 0x82, 0x07, 0x06, 0x08, 0x1C, 0x08, 0x60, 0x70, 0x31,
  0x81, 0xC0, 0xC4, 0x07, 0x01, 0x30, 0x1C, 0x06, 0xC0, 0x70, 0x1A, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x40, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xC8,
  0x03, 0xCC, 0x03, 0xC4, 0x03, 0xC6, 0x03, 0xC2, 0x03, 0xC3, 0x03, 0xC3,
  0x03, 0xC1, 0x03, 0xC1, 0x83, 0xC0, 0x83, 0xC0, 0xC3, 0xC0, 0x43, 0xC0,
  0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x13, 0xC0, 0x1B, 0xC0,
  0x0B, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x03,
  0xF0, 0x03, 0xEF, 0x01, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0x90, 0x00, 0x34, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00,
  0x36, 0x00, 0x09, 0x80, 0x02, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30,
  0x60, 0x0C, 0x1C, 0x06, 0x03, 0x87, 0x00, 0x7F, 0x80, 0xFC, 0x07, 0xFE,
  0x30, 0x39, 0x80, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0B, 0x00, 0xD8, 0x0C, 0xC3,
  0xC7, 0xFC, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xEF, 0x01, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0x90, 0x00, 0x34, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0,
  0x00, 0x36, 0x00, 0x09, 0x80, 0x02, 0x60, 0x01, 0x88, 0x00, 0x63, 0x00,
  0x30, 0x60, 0x0C, 0x1C, 0x06, 0x03, 0x87, 0x00, 0x7F, 0x80, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0xFE, 0x03, 0xFF, 0x0C, 0x0E, 0x30, 0x0C, 0xC0, 0x13, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x13, 0x00, 0xCC, 0x06, 0x30, 0x70, 0xFF, 0x83, 0x0C, 0x0C, 0x10, 0x30,
  0x60, 0xC0, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC,
  0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xC0, 0x0F, 0xE1, 0xF7,
  0xDC, 0x02, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x70, 0x73, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x63,
  0x00, 0xC7, 0x87, 0x03, 0xFC, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x60, 0x02, 0x60, 0x02, 0x60, 0x06, 0x20, 0x06, 0x30, 0x04,
  0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x18, 0x18,
  0x08, 0x18, 0x08, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x30,
  0x06, 0x20, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x36, 0x00, 0x70, 0x03, 0x60, 0x07,
  0x00, 0x26, 0x00, 0xF0, 0x06, 0x20, 0x0D, 0x00, 0x62, 0x00, 0xD0, 0x06,
  0x30, 0x09, 0x80, 0x43, 0x00, 0x98, 0x04, 0x30, 0x19, 0x80, 0xC1, 0x01,
  0x88, 0x0C, 0x10, 0x18, 0x80, 0xC1, 0x81, 0x0C, 0x08, 0x18, 0x10, 0xC1,
  0x81, 0x83, 0x0C, 0x18, 0x08, 0x30, 0x41, 0x80, 0xC3, 0x04, 0x18, 0x0C,
  0x20, 0x61, 0x00, 0xC2, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0x46, 0x02,
  0x30, 0x06, 0x60, 0x22, 0x00, 0x64, 0x03, 0x20, 0x06, 0x40, 0x36, 0x00,
  0x2C, 0x03, 0x60, 0x02, 0xC0, 0x16, 0x00, 0x3C, 0x01, 0x40, 0x03, 0x80,
  0x14, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x04, 0xC0,
  0x33, 0x00, 0xC4, 0x06, 0x18, 0x18, 0x60, 0x40, 0x83, 0x03, 0x0C, 0x0C,
  0x20, 0x11, 0x80, 0x64, 0x00, 0xB0, 0x02, 0xC0, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0B, 0x00, 0x6C, 0x01, 0x90, 0x04, 0x60, 0x31, 0x80,
  0x82, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x43, 0x01, 0x88, 0x06, 0x60, 0x0D,
  0x80, 0x3C, 0x00, 0x40, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x06, 0x60,
  0x18, 0x80, 0x63, 0x03, 0x0C, 0x0C, 0x10, 0x30, 0x60, 0x81, 0x86, 0x02,
  0x18, 0x0C, 0x40, 0x33, 0x00, 0x48, 0x01, 0xA0, 0x07, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x30,
  0x08, 0x30, 0x18, 0x10, 0x10, 0x18, 0x30, 0x08, 0x20, 0x0C, 0x60, 0x04,
  0x40, 0x06, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0xC3, 0x06, 0x0C, 0x18, 0x30,
  0x40, 0x1F, 0x8E, 0x39, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x1F, 0x9E, 0x16, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x0A, 0xC3, 0x4F, 0xC8, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0xFC, 0x37, 0x38, 0xF0, 0x33, 0x80, 0x4E, 0x01, 0xB0,
  0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x1B,
  0x80, 0x4B, 0x03, 0x26, 0x18, 0x8F, 0xC0, 0x07, 0xE3, 0xCC, 0xC0, 0x18,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x43, 0xF8, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xF8, 0xC7, 0x33,
  0x30, 0x2D, 0x80, 0x76, 0x01, 0xD0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x40, 0x1D, 0x80, 0x72, 0x02, 0xCE, 0x1B, 0x1F,
  0xCC, 0x0F, 0x80, 0xC6, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x20, 0x0B, 0x00,
  0x58, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x01, 0x0C,
  0x18, 0x3F, 0x80, 0x03, 0xC1, 0xF0, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x07, 0xF3, 0xFC, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0F, 0x8C, 0x73,
  0xB3, 0x02, 0xD8, 0x07, 0x60, 0x1D, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x74, 0x01, 0xD8, 0x07, 0x20, 0x2C, 0xE1, 0x31,
  0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x68, 0x03, 0x18, 0x38, 0x7F, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D,
  0xDE, 0xF0, 0x6E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x46, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x01, 0xE0, 0x6C,
  0x09, 0x83, 0x30, 0xC6, 0x18, 0xC6, 0x18, 0x83, 0x30, 0x6E, 0x0D, 0x41,
  0xEC, 0x39, 0x86, 0x10, 0xC3, 0x18, 0x23, 0x06, 0x60, 0xCC, 0x09, 0x81,
  0xB0, 0x16, 0x03, 0xC0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x8F, 0x87, 0xC4, 0xCE, 0x73, 0xA8, 0x12, 0x0D, 0x40, 0xE0,
  0x2C, 0x07, 0x01, 0xE0, 0x18, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03, 0xC0,
  0x20, 0x1E, 0x01, 0x00, 0xF0, 0x08, 0x07, 0x80, 0x40, 0x3C, 0x02, 0x01,
  0xE0, 0x10, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03, 0xC0, 0x20, 0x1E, 0x01,
  0x00, 0xF0, 0x08, 0x07, 0x80, 0x40, 0x3C, 0x02, 0x01, 0xE0, 0x10, 0x0F,
  0x00, 0x80, 0x60, 0x8F, 0xC9, 0xCE, 0xB0, 0x6A, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x30, 0x0F, 0xC0, 0x63, 0x83, 0x03, 0x18, 0x04, 0x60, 0x19, 0x00,
  0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x09, 0x00, 0x24, 0x01, 0x98,
  0x06, 0x30, 0x30, 0xE1, 0x80, 0xFC, 0x00, 0x8F, 0xC2, 0x73, 0x89, 0x03,
  0x28, 0x04, 0xA0, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0,
  0x0B, 0x00, 0x6E, 0x01, 0xB8, 0x04, 0xF0, 0x33, 0x61, 0x8C, 0xFC, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0x8C, 0x73, 0xB3, 0x02, 0xD8, 0x07,
  0x60, 0x1D, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x74, 0x01, 0xD8, 0x07, 0x30, 0x2C, 0xE1, 0x31, 0xFC, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x8F, 0x9F, 0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x1F, 0xC7, 0x1D, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x01, 0x80, 0x38, 0x07, 0xC3, 0x9F, 0xE0, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x31, 0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x05, 0x60, 0xD7, 0x19, 0x3F,
  0x10, 0xC0, 0x1A, 0x00, 0xD0, 0x06, 0xC0, 0x26, 0x03, 0x30, 0x18, 0x80,
  0xC6, 0x04, 0x30, 0x61, 0x83, 0x04, 0x18, 0x20, 0x81, 0x84, 0x0C, 0x60,
  0x23, 0x01, 0x10, 0x0C, 0x80, 0x6C, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x03,
  0x80, 0x0C, 0x00, 0xC0, 0x10, 0x05, 0x00, 0xE0, 0x14, 0x03, 0x80, 0xD8,
  0x0A, 0x03, 0x60, 0x28, 0x08, 0x81, 0xB0, 0x22, 0x06, 0xC1, 0x8C, 0x1B,
  0x06, 0x30, 0x44, 0x18, 0xC1, 0x10, 0x41, 0x0C, 0x61, 0x04, 0x31, 0x8C,
  0x18, 0xC2, 0x30, 0x62, 0x08, 0xC0, 0x88, 0x22, 0x02, 0x60, 0xC8, 0x0D,
  0x83, 0x60, 0x34, 0x05, 0x80, 0xD0, 0x14, 0x01, 0x40, 0x50, 0x07, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x34, 0x03, 0x60, 0x62,
  0x06, 0x30, 0xC1, 0x0C, 0x18, 0x81, 0x98, 0x09, 0x00, 0xF0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0xF0, 0x09, 0x01, 0x98, 0x10, 0x83, 0x0C, 0x20, 0x46,
  0x06, 0x60, 0x6C, 0x03, 0xC0, 0x30, 0x60, 0x0D, 0x80, 0x26, 0x00, 0x88,
  0x06, 0x30, 0x18, 0xC0, 0x43, 0x01, 0x04, 0x0C, 0x10, 0x30, 0x60, 0x81,
  0x82, 0x02, 0x18, 0x08, 0x60, 0x31, 0x00, 0xC4, 0x01, 0x30, 0x04, 0xC0,
  0x1A, 0x00, 0x68, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x26, 0x00, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0F, 0xFC, 0x00, 0x60, 0x7C,
  0x1C, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x03, 0xC0, 0x78,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x3E,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x1F, 0x00, 0x70, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x07, 0x80, 0xF0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x0F, 0x81, 0xC0, 0x00, 0x3E, 0x02, 0xCF, 0x06, 0x03, 0xFC,
  0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 8, 11, 13, 3, -31 },
  { 24, 17, 31, 19, 1, -31 },
  { 90, 15, 36, 17, 1, -33 },
  { 158, 22, 31, 25, 2, -31 },
  { 244, 16, 31, 17, 1, -31 },
  { 306, 2, 11, 7, 3, -31 },
  { 309, 8, 38, 12, 2, -31 },
  { 347, 7, 38, 12, 2, -31 },
  { 381, 11, 12, 15, 2, -33 },
  { 398, 15, 20, 17, 1, -25 },
  { 436, 4, 10, 8, 2, -4 },
  { 441, 9, 2, 11, 1, -13 },
  { 444, 2, 3, 8, 3, -3 },
  { 445, 13, 31, 14, 1, -31 },
  { 496, 13, 31, 17, 2, -31 },
  { 547, 8, 31, 17, 3, -31 },
  { 578, 13, 31, 17, 2, -31 },
  { 629, 13, 31, 17, 2, -31 },
  { 680, 16, 31, 17, 1, -31 },
  { 742, 13, 31, 17, 2, -31 },
  { 793, 13, 32, 17, 2, -31 },
  { 845, 13, 31, 17, 2, -31 },
  { 896, 14, 31, 17, 2, -31 },
  { 951, 13, 31, 17, 2, -31 },
  { 1002, 2, 23, 8, 3, -23 },
  { 1008, 4, 29, 8, 2, -23 },
  { 1023, 15, 18, 17, 1, -24 },
  { 1057, 15, 11, 17, 1, -21 },
  { 1078, 15, 18, 17, 1, -24 },
  { 1112, 10, 31, 12, 1, -31 },
  { 1151, 22, 35, 26, 2, -31 },
  { 1248, 17, 31, 17, 0, -31 },
  { 1314, 14, 31, 19, 3, -31 },
  { 1369, 15, 31, 18, 2, -31 },
  { 1428, 15, 31, 21, 3, -31 },
  { 1487, 12, 31, 17, 3, -31 },
  { 1534, 12, 31, 15, 3, -31 },
  { 1581, 18, 31, 23, 2, -31 },
  { 1651, 15, 31, 21, 3, -31 },
  { 1710, 6, 31, 10, 2, -31 },
  { 1734, 7, 39, 8, -2, -31 },
  { 1769, 14, 31, 17, 3, -31 },
  { 1824, 11, 31, 15, 3, -31 },
  { 1867, 22, 31, 29, 3, -31 },
  { 1953, 16, 31, 22, 3, -31 },
  { 2015, 18, 31, 22, 2, -31 },
  { 2085, 13, 31, 17, 3, -31 },
  { 2136, 18, 38, 22, 2, -31 },
  { 2222, 14, 31, 18, 3, -31 },
  { 2277, 13, 31, 17, 2, -31 },
  { 2328, 14, 31, 15, 0, -31 },
  { 2383, 15, 31, 21, 3, -31 },
  { 2442, 16, 31, 16, 0, -31 },
  { 2504, 28, 31, 28, 0, -31 },
  { 2613, 14, 31, 15, 0, -31 },
  { 2668, 14, 31, 14, 0, -31 },
  { 2723, 12, 31, 14, 1, -31 },
  { 2770, 8, 38, 13, 4, -31 },
  { 2808, 13, 31, 14, 1, -31 },
  { 2859, 9, 38, 13, 1, -31 },
  { 2902, 16, 15, 17, 1, -31 },
  { 2932, 17, 1, 17, 0, 4 },
  { 2935, 6, 7, 10, 2, -33 },
  { 2941, 11, 23, 16, 2, -23 },
  { 2973, 14, 33, 19, 3, -33 },
  { 3031, 11, 23, 14, 2, -23 },
  { 3063, 14, 33, 19, 2, -33 },
  { 3121, 13, 23, 17, 2, -23 },
  { 3159, 10, 33, 9, 0, -33 },
  { 3201, 14, 33, 18, 2, -23 },
  { 3259, 12, 33, 18, 3, -33 },
  { 3309, 2, 31, 8, 3, -31 },
  { 3317, 5, 41, 8, 0, -31 },
  { 3343, 11, 33, 15, 3, -33 },
  { 3389, 2, 33, 8, 3, -33 },
  { 3398, 21, 23, 27, 3, -23 },
  { 3459, 12, 23, 18, 3, -23 },
  { 3494, 14, 23, 18, 2, -23 },
  { 3535, 14, 33, 19, 3, -23 },
  { 3593, 14, 33, 18, 2, -23 },
  { 3651, 8, 23, 12, 3, -23 },
  { 3674, 11, 23, 14, 1, -23 },
  { 3706, 8, 28, 9, 1, -28 },
  { 3734, 12, 23, 18, 3, -23 },
  { 3769, 13, 23, 13, 0, -23 },
  { 3807, 22, 23, 23, 0, -23 },
  { 3871, 12, 23, 14, 1, -23 },
  { 3906, 14, 33, 14, 0, -23 },
  { 3964, 10, 23, 11, 1, -23 },
  { 3993, 11, 38, 15, 2, -31 },
  { 4046, 2, 43, 16, 7, -33 },
  { 4057, 11, 38, 15, 2, -31 },
  { 4110, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT43PT7B_H_
