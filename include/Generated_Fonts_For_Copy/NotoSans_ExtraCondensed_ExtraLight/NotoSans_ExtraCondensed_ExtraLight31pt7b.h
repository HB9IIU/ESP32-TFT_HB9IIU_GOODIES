#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x55, 0x55, 0x40, 0xF0, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xA2, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x10, 0x81, 0x08, 0xFF, 0xF1,
  0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x02, 0x10, 0xFF, 0xE2,
  0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x23, 0x06, 0x20, 0x04, 0x01,
  0x01, 0xE0, 0xDF, 0x44, 0x31, 0x08, 0x42, 0x10, 0x84, 0x31, 0x04, 0x40,
  0xD0, 0x1C, 0x01, 0xC0, 0x58, 0x13, 0x04, 0x41, 0x10, 0x44, 0x11, 0x04,
  0x71, 0x67, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x38, 0x10, 0x44, 0x10, 0x44,
  0x20, 0x44, 0x20, 0x86, 0x20, 0x82, 0x40, 0x82, 0x40, 0x82, 0x40, 0x86,
  0x88, 0x44, 0x96, 0x44, 0xA2, 0x45, 0x21, 0x39, 0x21, 0x01, 0x21, 0x03,
  0x21, 0x02, 0x21, 0x02, 0x21, 0x06, 0x21, 0x04, 0x21, 0x04, 0x23, 0x0C,
  0x12, 0x08, 0x1E, 0x1E, 0x02, 0x20, 0x23, 0x02, 0x10, 0x21, 0x02, 0x30,
  0x22, 0x02, 0x20, 0x14, 0x01, 0xC0, 0x18, 0x02, 0xC0, 0x44, 0x24, 0x62,
  0x82, 0x28, 0x14, 0x81, 0x48, 0x0C, 0x80, 0xCC, 0x1C, 0x43, 0x63, 0xE3,
  0xFF, 0x18, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x84, 0x21, 0x84, 0x30, 0x82, 0xC1, 0x82, 0x0C, 0x10, 0x40, 0x82,
  0x08, 0x20, 0xC3, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x0C,
  0x21, 0x0C, 0x00, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0x40, 0x50, 0x44,
  0x43, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07,
  0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x2D, 0xA4,
  0xA0, 0xFC, 0xF0, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x08, 0x04, 0x00, 0x1F, 0x0C, 0x42, 0x09, 0x02, 0x40, 0x90, 0x34,
  0x05, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x05, 0x01,
  0x40, 0xD0, 0x26, 0x08, 0x82, 0x31, 0x07, 0x80, 0x0C, 0x53, 0x71, 0x44,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x7F, 0x10, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x3F, 0xF0, 0x7F, 0x30, 0x60, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0xC3, 0xC0, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x81, 0xBF, 0x80, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x88,
  0x10, 0x83, 0x08, 0x20, 0x86, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x81, 0x1F, 0x80, 0x0F, 0x86,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x44, 0x16, 0xCE, 0x0B,
  0x03, 0xC0, 0x70, 0x14, 0x05, 0x01, 0x40, 0x50, 0x14, 0x0D, 0x82, 0x21,
  0x87, 0xC0, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x00, 0x3F, 0x18, 0x24, 0x0D, 0x01, 0x40,
  0x50, 0x14, 0x0D, 0x82, 0x31, 0x07, 0x80, 0xC0, 0x4C, 0x21, 0x90, 0x2C,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x05, 0x03, 0x60, 0x8F, 0xC0, 0x3F, 0x18,
  0x44, 0x09, 0x02, 0xC0, 0xA0, 0x38, 0x06, 0x01, 0xC0, 0xF0, 0x34, 0x0D,
  0x85, 0x3E, 0x42, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x02,
  0x1F, 0x00, 0xBC, 0x00, 0x00, 0x03, 0xC0, 0x2D, 0x80, 0x00, 0x00, 0x00,
  0x0B, 0x69, 0x28, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x02, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x08, 0x00, 0xFC, 0x42, 0x03, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x04,
  0x0C, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x07, 0xE0, 0x30, 0x20, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x70,
  0x78, 0xC3, 0x31, 0x84, 0x43, 0x08, 0x86, 0x21, 0x0C, 0x42, 0x18, 0x84,
  0x31, 0x08, 0x62, 0x10, 0xC4, 0x21, 0x84, 0xA7, 0x0F, 0x7A, 0x08, 0x42,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x07, 0x80, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x01, 0x88, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x0C, 0x20, 0x43, 0xFC, 0x20, 0x42, 0x06, 0x60,
  0x24, 0x02, 0x40, 0x24, 0x03, 0xC0, 0x18, 0x01, 0xFF, 0x30, 0x6C, 0x0F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xB0, 0xCF, 0xE3, 0x06, 0xC0,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC1, 0xBF, 0xC0,
  0x0F, 0xCC, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x43, 0xF0, 0xFE, 0x18, 0x33, 0x02, 0x60, 0x2C, 0x05, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0x4C, 0x31, 0xFC, 0x00, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xEC, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x0F, 0xF0,
  0xC0, 0x88, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x1A, 0x00, 0xD8, 0x06, 0x40, 0x31, 0x81, 0x87, 0xF8, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x40, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x7C, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x23, 0x18, 0xBC,
  0x80, 0xC0, 0xF0, 0x2C, 0x13, 0x0C, 0xC2, 0x31, 0x8C, 0x43, 0x20, 0xD8,
  0x34, 0x0F, 0x83, 0xA0, 0xCC, 0x31, 0x0C, 0x63, 0x08, 0xC3, 0x30, 0x4C,
  0x1B, 0x02, 0xC0, 0xB0, 0x10, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xA0, 0x03, 0xE0, 0x07, 0xE0,
  0x05, 0xD0, 0x05, 0xD0, 0x05, 0xD0, 0x09, 0xC8, 0x09, 0xC8, 0x09, 0xC8,
  0x11, 0xCC, 0x11, 0xC4, 0x11, 0xC4, 0x31, 0xC4, 0x21, 0xC2, 0x21, 0xC2,
  0x21, 0xC2, 0x41, 0xC1, 0x41, 0xC1, 0x41, 0xC1, 0x81, 0xC1, 0x81, 0xC0,
  0x1E, 0x01, 0xA0, 0x1E, 0x01, 0xD0, 0x1D, 0x01, 0xC8, 0x1C, 0x81, 0xCC,
  0x1C, 0x41, 0xC4, 0x1C, 0x21, 0xC2, 0x1C, 0x11, 0xC1, 0x1C, 0x19, 0xC0,
  0x9C, 0x0D, 0xC0, 0x5C, 0x05, 0xC0, 0x3C, 0x03, 0x1F, 0x83, 0x04, 0x60,
  0x64, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0x40,
  0x26, 0x06, 0x30, 0xC1, 0xF8, 0xFE, 0x30, 0xCC, 0x1B, 0x02, 0xC0, 0xB0,
  0x3C, 0x0F, 0x02, 0xC0, 0xB0, 0x2C, 0x1B, 0x1C, 0xF8, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x83, 0x04,
  0x60, 0x64, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03,
  0x40, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x60, 0xFE, 0x30, 0xCC, 0x0B, 0x02, 0xC0, 0xB0, 0x3C, 0x0F, 0x02,
  0xC0, 0xB0, 0x6C, 0x33, 0xF8, 0xC4, 0x31, 0x0C, 0x23, 0x08, 0xC1, 0x30,
  0x4C, 0x1B, 0x02, 0xC0, 0xF0, 0x10, 0x1F, 0xD8, 0x14, 0x01, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x81, 0xBF, 0xC0, 0xFF, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x05, 0x01, 0xA0, 0x22, 0x0C, 0x3F, 0x00, 0x80, 0x3C, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x0C,
  0x30, 0x81, 0x08, 0x10, 0x81, 0x18, 0x19, 0x00, 0x90, 0x09, 0x00, 0x90,
  0x0A, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x20, 0x14, 0x06, 0x01, 0x40,
  0x60, 0x14, 0x07, 0x03, 0x40, 0x50, 0x26, 0x05, 0x02, 0x20, 0x90, 0x22,
  0x09, 0x06, 0x20, 0x90, 0x62, 0x08, 0x84, 0x30, 0x88, 0x41, 0x10, 0x84,
  0x11, 0x08, 0xC1, 0x10, 0x88, 0x11, 0x04, 0x81, 0x90, 0x48, 0x0A, 0x04,
  0x80, 0xA0, 0x58, 0x0A, 0x05, 0x00, 0xA0, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x40, 0x48, 0x32, 0x08, 0xC2, 0x11, 0x84, 0x41, 0x90, 0x28, 0x0A,
  0x01, 0x80, 0x40, 0x38, 0x0A, 0x02, 0x81, 0x10, 0x44, 0x31, 0x08, 0x22,
  0x09, 0x83, 0x40, 0x70, 0x10, 0x80, 0x50, 0x34, 0x09, 0x02, 0x20, 0x88,
  0x42, 0x10, 0x44, 0x12, 0x04, 0x80, 0xA0, 0x30, 0x0C, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xFF, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x07, 0xFC, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3E, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x04, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F,
  0xC0, 0x04, 0x01, 0xC0, 0x28, 0x09, 0x81, 0x10, 0x43, 0x08, 0x22, 0x06,
  0x40, 0x50, 0x0A, 0x00, 0x80, 0xFF, 0xF8, 0xC2, 0x08, 0x20, 0x80, 0x1C,
  0x31, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x1F, 0xB0, 0xD0, 0x70,
  0x38, 0x1C, 0x0F, 0x06, 0x85, 0x3C, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x38, 0xB3, 0x28, 0x2C, 0x0B, 0x03, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x03, 0xC0, 0xB0, 0x2A, 0x1A,
  0x7C, 0x0E, 0x19, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0x30, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x31, 0x3B, 0x48, 0x34, 0x0D, 0x01, 0x40, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x14, 0x05, 0x01, 0x40, 0x58, 0x32, 0x14, 0x79,
  0x0C, 0x0E, 0xC2, 0x19, 0x02, 0x40, 0x90, 0x24, 0x07, 0x01, 0xFF, 0xF0,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC2, 0x1F, 0x80, 0x0F, 0x1A,
  0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0xFC, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x0E, 0x0E,
  0xD2, 0x0D, 0x03, 0x40, 0x50, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x05,
  0x01, 0x40, 0x50, 0x36, 0x0C, 0x85, 0x1E, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x34, 0x09, 0xFC, 0x08, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x18, 0xB3, 0x50, 0xB0, 0x78, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xBC, 0x02, 0xAA,
  0xAA, 0xAA, 0xA8, 0x23, 0x30, 0x00, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x2E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x81, 0x82, 0x82, 0x84, 0x8C, 0x88, 0x90, 0xB0, 0xA8, 0xC8,
  0xCC, 0x84, 0x84, 0x82, 0x82, 0x83, 0x81, 0xFF, 0xFF, 0xFF, 0x0C, 0x39,
  0x6C, 0xDA, 0x86, 0x1E, 0x0C, 0x1C, 0x18, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x0C, 0x59, 0xA8, 0x58, 0x3C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x0E, 0x0E, 0xC2, 0x09, 0x03, 0x40, 0x50, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x05, 0x01, 0x40, 0x50, 0x16, 0x08, 0x86, 0x1F, 0x00,
  0x0E, 0x24, 0xCA, 0x1B, 0x02, 0xC0, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0xF0, 0x2C, 0x0A, 0x86, 0x9F, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0E, 0x0E, 0xD2, 0x0D, 0x03, 0x40,
  0x50, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x05, 0x01, 0x40, 0x50, 0x36,
  0x0C, 0x85, 0x1E, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x0E, 0x7A, 0x30, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x1C, 0x63, 0x40, 0x80, 0x80, 0x80, 0x40, 0x60, 0x18, 0x0C, 0x02,
  0x03, 0x01, 0x01, 0x03, 0x82, 0xFC, 0x42, 0x10, 0x8F, 0xA1, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x18, 0x70, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1E, 0x0D, 0x0A,
  0xF9, 0xC0, 0xA0, 0x50, 0x28, 0x24, 0x11, 0x08, 0x84, 0x46, 0x22, 0x09,
  0x04, 0x82, 0xC1, 0x40, 0xE0, 0x30, 0x18, 0xC1, 0x81, 0x41, 0x81, 0x41,
  0x43, 0x41, 0x42, 0x61, 0x42, 0x23, 0x42, 0x22, 0x42, 0x22, 0x24, 0x22,
  0x24, 0x32, 0x24, 0x14, 0x24, 0x14, 0x2C, 0x14, 0x18, 0x14, 0x18, 0x0C,
  0x18, 0x08, 0x18, 0x40, 0x88, 0x62, 0x10, 0x4C, 0x12, 0x02, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x81, 0x20, 0x4C, 0x21, 0x08, 0x44, 0x0B, 0x03, 0x40,
  0xD0, 0x24, 0x08, 0x82, 0x21, 0x88, 0x42, 0x10, 0x44, 0x13, 0x04, 0x81,
  0x20, 0x28, 0x0E, 0x03, 0x00, 0xC0, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x0F, 0x01, 0x00, 0xFC, 0x08, 0x10, 0x40, 0x83, 0x04, 0x08,
  0x30, 0x40, 0x82, 0x04, 0x18, 0x20, 0x7F, 0x0E, 0x30, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x86, 0x18, 0x08, 0x18, 0x30, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0xF8, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 6, 8, 10, 2, -22 },
  { 13, 12, 22, 13, 1, -22 },
  { 46, 10, 26, 12, 1, -24 },
  { 79, 16, 22, 18, 1, -22 },
  { 123, 12, 22, 13, 1, -22 },
  { 156, 1, 8, 5, 2, -22 },
  { 157, 5, 27, 8, 2, -22 },
  { 174, 6, 27, 8, 1, -22 },
  { 195, 9, 9, 11, 1, -24 },
  { 206, 11, 14, 13, 1, -18 },
  { 226, 3, 7, 6, 1, -3 },
  { 229, 6, 1, 8, 1, -9 },
  { 230, 2, 2, 6, 2, -2 },
  { 231, 9, 22, 10, 1, -22 },
  { 256, 10, 22, 12, 1, -22 },
  { 284, 6, 22, 12, 2, -22 },
  { 301, 10, 22, 12, 1, -22 },
  { 329, 10, 22, 12, 1, -22 },
  { 357, 12, 22, 12, 0, -22 },
  { 390, 10, 22, 12, 1, -22 },
  { 418, 10, 22, 12, 1, -22 },
  { 446, 10, 22, 12, 1, -22 },
  { 474, 10, 22, 12, 1, -22 },
  { 502, 10, 22, 12, 1, -22 },
  { 530, 2, 17, 6, 2, -17 },
  { 535, 3, 21, 6, 1, -17 },
  { 543, 11, 13, 13, 1, -17 },
  { 561, 11, 8, 13, 1, -15 },
  { 572, 11, 13, 13, 1, -17 },
  { 590, 8, 22, 9, 0, -22 },
  { 612, 15, 25, 19, 2, -22 },
  { 659, 12, 22, 12, 0, -22 },
  { 692, 10, 22, 14, 2, -22 },
  { 720, 10, 22, 13, 2, -22 },
  { 748, 11, 22, 15, 2, -22 },
  { 779, 8, 22, 12, 2, -22 },
  { 801, 9, 22, 11, 2, -22 },
  { 826, 13, 22, 16, 2, -22 },
  { 862, 11, 22, 15, 2, -22 },
  { 893, 5, 22, 7, 1, -22 },
  { 907, 5, 28, 6, -1, -22 },
  { 925, 10, 22, 12, 2, -22 },
  { 953, 8, 22, 11, 2, -22 },
  { 975, 16, 22, 21, 2, -22 },
  { 1019, 12, 22, 16, 2, -22 },
  { 1052, 12, 22, 16, 2, -22 },
  { 1085, 10, 22, 13, 2, -22 },
  { 1113, 12, 27, 16, 2, -22 },
  { 1154, 10, 22, 13, 2, -22 },
  { 1182, 10, 22, 12, 1, -22 },
  { 1210, 10, 22, 11, 0, -22 },
  { 1238, 11, 22, 15, 2, -22 },
  { 1269, 12, 22, 12, 0, -22 },
  { 1302, 20, 22, 21, 0, -22 },
  { 1357, 10, 22, 11, 0, -22 },
  { 1385, 10, 22, 10, 0, -22 },
  { 1413, 9, 22, 10, 1, -22 },
  { 1438, 5, 27, 10, 3, -22 },
  { 1455, 9, 22, 10, 1, -22 },
  { 1480, 6, 27, 10, 1, -22 },
  { 1501, 11, 11, 13, 1, -22 },
  { 1517, 13, 1, 12, 0, 3 },
  { 1519, 5, 5, 7, 1, -24 },
  { 1523, 9, 17, 12, 1, -17 },
  { 1543, 10, 24, 13, 2, -24 },
  { 1573, 8, 17, 10, 1, -17 },
  { 1590, 10, 24, 13, 1, -24 },
  { 1620, 10, 17, 12, 1, -17 },
  { 1642, 8, 24, 7, 0, -24 },
  { 1666, 10, 25, 13, 1, -17 },
  { 1698, 9, 24, 13, 2, -24 },
  { 1725, 2, 23, 6, 2, -23 },
  { 1731, 4, 31, 6, 0, -23 },
  { 1747, 8, 24, 11, 2, -24 },
  { 1771, 1, 24, 5, 2, -24 },
  { 1774, 15, 17, 19, 2, -17 },
  { 1806, 9, 17, 13, 2, -17 },
  { 1826, 10, 17, 13, 1, -17 },
  { 1848, 10, 24, 13, 2, -17 },
  { 1878, 10, 24, 13, 1, -17 },
  { 1908, 6, 17, 8, 2, -17 },
  { 1921, 8, 17, 10, 1, -17 },
  { 1938, 5, 20, 7, 1, -20 },
  { 1951, 9, 16, 13, 2, -16 },
  { 1969, 9, 16, 10, 0, -16 },
  { 1987, 16, 16, 16, 0, -16 },
  { 2019, 10, 16, 10, 0, -16 },
  { 2039, 10, 24, 10, 0, -16 },
  { 2069, 7, 16, 8, 1, -16 },
  { 2083, 7, 27, 11, 2, -22 },
  { 2107, 2, 31, 12, 5, -24 },
  { 2115, 8, 27, 11, 1, -22 },
  { 2142, 11, 2, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT31PT7B_H_
