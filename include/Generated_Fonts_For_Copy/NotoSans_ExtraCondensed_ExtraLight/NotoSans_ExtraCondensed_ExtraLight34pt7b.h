#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00, 0xBE, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x61, 0x84, 0x0C, 0x20, 0x41, 0x02, 0x18, 0x10, 0x80,
  0x84, 0x04, 0x20, 0x21, 0x1F, 0xFF, 0x18, 0x40, 0x82, 0x04, 0x10, 0x21,
  0x81, 0x08, 0x08, 0x40, 0x42, 0x1F, 0xFE, 0x10, 0x81, 0x84, 0x08, 0x20,
  0x41, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x04, 0x00, 0x40, 0x0F,
  0x83, 0xDE, 0x64, 0x04, 0x40, 0xC4, 0x08, 0x40, 0x84, 0x0C, 0x40, 0x44,
  0x06, 0x40, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x4C, 0x04, 0x60, 0x42, 0x04,
  0x20, 0x43, 0x04, 0x20, 0x42, 0x04, 0x6E, 0x4C, 0x3F, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x20, 0x08, 0x3C, 0x08, 0x23, 0x04, 0x10, 0x82, 0x08, 0x42,
  0x04, 0x21, 0x02, 0x10, 0x81, 0x08, 0x80, 0x84, 0x40, 0x42, 0x20, 0x21,
  0x23, 0x10, 0x92, 0x48, 0x4B, 0x16, 0x69, 0x09, 0xE4, 0x84, 0x22, 0x42,
  0x02, 0x21, 0x81, 0x10, 0xC0, 0x88, 0x60, 0x84, 0x30, 0x42, 0x10, 0x21,
  0x08, 0x20, 0x84, 0x10, 0x26, 0x18, 0x1E, 0x00, 0x0C, 0x00, 0xF0, 0x0C,
  0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x31, 0x00, 0x98,
  0x06, 0x80, 0x18, 0x01, 0xC0, 0x1A, 0x01, 0x98, 0x48, 0x42, 0xC1, 0x14,
  0x09, 0xA0, 0x29, 0x01, 0xC8, 0x06, 0x60, 0x31, 0x02, 0x8C, 0x32, 0x3E,
  0x18, 0xFF, 0xFF, 0x80, 0x0C, 0x61, 0x0C, 0x21, 0x84, 0x10, 0xC3, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0x81,
  0x06, 0x0C, 0xC1, 0x82, 0x04, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x08, 0xC0,
  0x0C, 0x06, 0x01, 0x09, 0x1B, 0xF0, 0x60, 0x48, 0x24, 0x61, 0x00, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x24,
  0xB6, 0x96, 0xFE, 0x7C, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x08, 0x0F,
  0xC6, 0x11, 0x06, 0x40, 0xB0, 0x28, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xC0,
  0x90, 0x26, 0x18, 0x8C, 0x1E, 0x00, 0x0C, 0xF6, 0xF3, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0E, 0x0F, 0xF1, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xFF, 0xE0, 0x0C,
  0x0F, 0xF3, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x01, 0x81, 0xE0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x36, 0x0C, 0x7F, 0x00, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81,
  0x08, 0x10, 0x82, 0x08, 0x20, 0x84, 0x08, 0x40, 0x88, 0x08, 0x80, 0x8F,
  0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x90,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x26, 0x0F, 0xF0,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x68, 0x33, 0xF8, 0x02, 0x07, 0xE3, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x09, 0xE2, 0xCE, 0xC0, 0xB0, 0x38, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x34, 0x09, 0x86, 0x3F, 0x00,
  0xFF, 0xE0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x06, 0x03, 0xF0,
  0x83, 0x30, 0x24, 0x06, 0x80, 0x50, 0x0A, 0x03, 0x60, 0x44, 0x18, 0x46,
  0x07, 0x80, 0xE0, 0x33, 0x08, 0x33, 0x02, 0x40, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x02, 0x80, 0x50, 0x19, 0x86, 0x1F, 0x80, 0x0E, 0x03, 0xE0, 0x82,
  0x30, 0x64, 0x04, 0x80, 0xB0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0,
  0x34, 0x06, 0xC1, 0x4E, 0xD8, 0x73, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x7E, 0x00, 0xF4, 0x00, 0x00, 0x01, 0xF0,
  0x6C, 0x80, 0x00, 0x00, 0x00, 0x09, 0x2D, 0xA5, 0x80, 0x00, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x08, 0x00, 0x30, 0xFC, 0x86, 0x02, 0x02, 0x03, 0x03, 0x02, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x70, 0x30, 0x07, 0xF0, 0x06, 0x06, 0x04, 0x01, 0x86, 0x00,
  0x42, 0x00, 0x32, 0x00, 0x09, 0x01, 0x04, 0x83, 0xE3, 0xC2, 0x30, 0xC3,
  0x18, 0x61, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x21, 0x86, 0x10, 0x83,
  0x08, 0x41, 0x84, 0x20, 0xC2, 0x28, 0xA1, 0x94, 0x58, 0x71, 0xC4, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x08, 0x01,
  0xF8, 0x00, 0x03, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0x58, 0x06, 0x40,
  0x22, 0x01, 0x10, 0x08, 0xC0, 0xC2, 0x06, 0x10, 0x20, 0x81, 0x06, 0x08,
  0x10, 0xFF, 0x84, 0x04, 0x20, 0x31, 0x01, 0x98, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0xD0, 0x12, 0x1C, 0x7F, 0x08, 0x19, 0x01,
  0xA0, 0x14, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x01, 0xA0,
  0xE7, 0xF0, 0x01, 0x80, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x81, 0x0F, 0xE0, 0xFE, 0x08, 0x38, 0x80, 0x88, 0x04, 0x80, 0x68,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8,
  0x18, 0x83, 0x0F, 0xC0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xF4, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x3F, 0xE1, 0x80,
  0xCC, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x60, 0x04, 0x80, 0x13, 0x00, 0x47,
  0x03, 0x07, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x43, 0x9B, 0xE0, 0x80, 0xE0, 0x28, 0x12, 0x0C, 0x82, 0x21,
  0x88, 0x42, 0x30, 0x98, 0x24, 0x0B, 0x02, 0xC0, 0xD8, 0x32, 0x08, 0xC2,
  0x10, 0x86, 0x20, 0x88, 0x32, 0x04, 0x81, 0xA0, 0x28, 0x0E, 0x01, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x5A, 0x00, 0x2D, 0x00, 0x36,
  0xC0, 0x13, 0x20, 0x09, 0x90, 0x0C, 0xC8, 0x04, 0x66, 0x02, 0x31, 0x01,
  0x18, 0x81, 0x8C, 0x60, 0x86, 0x10, 0x43, 0x08, 0x61, 0x86, 0x20, 0xC1,
  0x10, 0x60, 0x98, 0x30, 0x48, 0x18, 0x34, 0x0C, 0x0A, 0x06, 0x07, 0x03,
  0x03, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1A, 0x01, 0xA0, 0x1B, 0x01, 0x90,
  0x19, 0x81, 0x88, 0x18, 0x81, 0x84, 0x18, 0x41, 0x86, 0x18, 0x21, 0x83,
  0x18, 0x11, 0x81, 0x98, 0x09, 0x80, 0x98, 0x05, 0x80, 0x58, 0x07, 0x80,
  0x38, 0x03, 0x02, 0x00, 0x7F, 0x03, 0x02, 0x08, 0x04, 0x60, 0x19, 0x00,
  0x2C, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x90,
  0x02, 0x40, 0x19, 0x80, 0x42, 0x03, 0x06, 0x18, 0x0F, 0xC0, 0xFE, 0x20,
  0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x28, 0x0A,
  0x04, 0x8F, 0x3E, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x03, 0x00, 0x7F, 0x03, 0x02, 0x08, 0x04, 0x60,
  0x19, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x90, 0x02, 0x40, 0x19, 0x80, 0x42, 0x03, 0x06, 0x18, 0x0F, 0xC0,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0xFE,
  0x10, 0x62, 0x06, 0x40, 0x48, 0x0D, 0x01, 0xA0, 0x34, 0x06, 0x80, 0x90,
  0x12, 0x06, 0x41, 0x8F, 0xC1, 0x18, 0x21, 0x04, 0x30, 0x82, 0x10, 0x62,
  0x04, 0x40, 0x88, 0x19, 0x01, 0x20, 0x34, 0x03, 0x02, 0x03, 0xFC, 0xC0,
  0xB0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x16, 0x0C, 0xFF, 0x00, 0xFF, 0xE0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x36,
  0x02, 0x30, 0x61, 0xFC, 0x80, 0x1E, 0x00, 0xD0, 0x04, 0x80, 0x24, 0x01,
  0x30, 0x18, 0x80, 0x84, 0x04, 0x20, 0x21, 0x83, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x60, 0x62, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x03, 0x60, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0x40, 0xC0, 0x30, 0x05, 0x00, 0xC0,
  0x14, 0x03, 0x00, 0xD0, 0x0E, 0x03, 0x60, 0x28, 0x09, 0x81, 0xA0, 0x22,
  0x04, 0x80, 0x88, 0x12, 0x06, 0x20, 0x4C, 0x10, 0xC1, 0x10, 0x43, 0x0C,
  0x41, 0x04, 0x21, 0x0C, 0x10, 0x84, 0x30, 0x42, 0x18, 0x81, 0x88, 0x22,
  0x06, 0x60, 0x88, 0x09, 0x82, 0x60, 0x24, 0x09, 0x00, 0x90, 0x34, 0x03,
  0x40, 0x50, 0x07, 0x01, 0x40, 0x1C, 0x07, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x60, 0x24, 0x0C, 0x81, 0x18, 0x21, 0x0C, 0x31, 0x02, 0x60, 0x48,
  0x0D, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x02, 0x40, 0x48, 0x19,
  0x82, 0x10, 0x42, 0x10, 0x62, 0x04, 0xC0, 0xD0, 0x0E, 0x01, 0xC0, 0x28,
  0x0D, 0x01, 0x30, 0x22, 0x0C, 0x41, 0x0C, 0x20, 0x8C, 0x11, 0x03, 0x20,
  0x2C, 0x05, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x03,
  0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80,
  0x30, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x06, 0x00, 0x60, 0x09, 0x00,
  0x90, 0x19, 0x81, 0x08, 0x30, 0xC2, 0x04, 0x60, 0x64, 0x02, 0xC0, 0x38,
  0x01, 0xFF, 0xFC, 0xC1, 0x83, 0x04, 0x0C, 0x7F, 0x10, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x1F, 0x98, 0x50, 0x28, 0x1C, 0x0E, 0x07, 0x02,
  0x83, 0x61, 0x9F, 0x40, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xDF, 0x9E, 0x1B, 0x81, 0x60, 0x3C, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x17,
  0x02, 0xF0, 0x93, 0xF0, 0x1F, 0x20, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x3F, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x3E, 0x58, 0x54, 0x0F,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x0D, 0x03, 0x61, 0x4F, 0x90, 0x3E, 0x18, 0x44, 0x1B, 0x02,
  0x80, 0xA0, 0x28, 0x0E, 0x03, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x8F, 0xE0, 0x0F, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x3E, 0x58, 0x54, 0x0F,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x0D, 0x03, 0x61, 0x4F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x02, 0x81, 0x9F, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xDF, 0x3C, 0x6E, 0x0B, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x10, 0x7C, 0x01, 0x55, 0x55, 0x55, 0x55, 0x40, 0x13, 0x30, 0x00,
  0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x32, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC1,
  0xE0, 0xB0, 0x98, 0xCC, 0x46, 0x63, 0x21, 0xB0, 0xF8, 0x72, 0x31, 0x18,
  0xCC, 0x26, 0x1B, 0x05, 0x82, 0xC1, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x9F, 0x1E, 0x50, 0x91, 0xA8, 0x30, 0x78, 0x18, 0x3C,
  0x08, 0x0E, 0x04, 0x07, 0x02, 0x03, 0x81, 0x01, 0xC0, 0x80, 0xE0, 0x40,
  0x70, 0x20, 0x38, 0x10, 0x1C, 0x08, 0x0E, 0x04, 0x07, 0x02, 0x03, 0x81,
  0x01, 0xC0, 0x80, 0xE0, 0x40, 0x40, 0x9F, 0x2C, 0x6A, 0x0F, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x10, 0x3F, 0x18, 0x64, 0x0B, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x0D,
  0x02, 0x61, 0x8F, 0xC0, 0x9F, 0x92, 0x1A, 0x81, 0x50, 0x2C, 0x07, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x17, 0x02, 0xD0, 0x9B, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x3E, 0x58, 0x54, 0x0F, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x0D, 0x03,
  0x61, 0x4F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x9F, 0x22, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x3F, 0xB0, 0x90, 0x18, 0x0C, 0x06, 0x01,
  0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x02, 0x83,
  0x3F, 0x00, 0x20, 0x86, 0x18, 0xFD, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x20, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0D, 0x05, 0x63, 0x4F, 0x90, 0xC0, 0x50, 0x14, 0x0D, 0x03, 0x60,
  0x98, 0x22, 0x18, 0x86, 0x21, 0x0C, 0x41, 0x10, 0x4C, 0x12, 0x06, 0x80,
  0xA0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0xD0, 0x30, 0x24, 0x0C, 0x09,
  0x03, 0x82, 0x61, 0xA1, 0x88, 0x48, 0x62, 0x12, 0x10, 0x84, 0x84, 0x21,
  0x31, 0x0C, 0xC4, 0xC1, 0x21, 0x20, 0x48, 0x48, 0x12, 0x12, 0x06, 0x86,
  0x80, 0xE0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x90,
  0x64, 0x11, 0x8C, 0x22, 0x0C, 0x81, 0x40, 0x70, 0x0C, 0x07, 0x01, 0x40,
  0x58, 0x22, 0x08, 0xC6, 0x11, 0x04, 0xC1, 0xA0, 0x30, 0x40, 0x68, 0x09,
  0x81, 0x10, 0x22, 0x0C, 0x41, 0x0C, 0x20, 0x84, 0x11, 0x82, 0x20, 0x64,
  0x04, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x1E, 0x00, 0xFE, 0x04, 0x18,
  0x20, 0x41, 0x82, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x81,
  0xFC, 0x07, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x30, 0xC0, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x08, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x30, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x0C, 0x03, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x30, 0xE0, 0x10, 0x0F, 0xC1, 0x83, 0xE0, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 24, 7, 2, -24 },
  { 10, 6, 9, 11, 2, -24 },
  { 17, 13, 24, 15, 1, -24 },
  { 56, 12, 28, 14, 1, -26 },
  { 98, 17, 25, 20, 2, -25 },
  { 152, 13, 25, 14, 1, -25 },
  { 193, 2, 9, 6, 2, -24 },
  { 196, 6, 29, 9, 2, -24 },
  { 218, 6, 29, 9, 1, -24 },
  { 240, 9, 9, 12, 1, -26 },
  { 251, 12, 16, 14, 1, -20 },
  { 275, 3, 8, 6, 1, -4 },
  { 278, 7, 1, 9, 1, -10 },
  { 279, 2, 3, 6, 2, -3 },
  { 280, 10, 24, 11, 1, -24 },
  { 310, 10, 25, 14, 2, -25 },
  { 342, 6, 24, 14, 3, -24 },
  { 360, 11, 25, 14, 1, -25 },
  { 395, 11, 25, 14, 1, -25 },
  { 430, 12, 24, 14, 1, -24 },
  { 466, 10, 24, 14, 2, -24 },
  { 496, 10, 25, 14, 2, -25 },
  { 528, 11, 24, 14, 1, -24 },
  { 561, 11, 25, 14, 1, -25 },
  { 596, 11, 25, 14, 1, -25 },
  { 631, 2, 18, 6, 2, -18 },
  { 636, 3, 22, 6, 1, -18 },
  { 645, 12, 14, 14, 1, -19 },
  { 666, 12, 8, 14, 1, -16 },
  { 678, 12, 14, 14, 1, -19 },
  { 699, 8, 25, 9, 1, -25 },
  { 724, 17, 27, 21, 2, -24 },
  { 782, 13, 24, 13, 0, -24 },
  { 821, 11, 24, 15, 3, -24 },
  { 854, 12, 25, 14, 2, -25 },
  { 892, 12, 24, 16, 3, -24 },
  { 928, 8, 24, 13, 3, -24 },
  { 952, 9, 24, 12, 3, -24 },
  { 979, 14, 25, 18, 2, -25 },
  { 1023, 11, 24, 17, 3, -24 },
  { 1056, 6, 24, 8, 1, -24 },
  { 1074, 6, 30, 7, -2, -24 },
  { 1097, 10, 24, 13, 3, -24 },
  { 1127, 8, 24, 12, 3, -24 },
  { 1151, 17, 24, 23, 3, -24 },
  { 1202, 12, 24, 18, 3, -24 },
  { 1238, 14, 25, 18, 2, -25 },
  { 1282, 10, 24, 14, 3, -24 },
  { 1312, 14, 31, 18, 2, -25 },
  { 1367, 11, 24, 14, 3, -24 },
  { 1400, 11, 25, 13, 1, -25 },
  { 1435, 11, 24, 12, 0, -24 },
  { 1468, 12, 24, 17, 2, -24 },
  { 1504, 13, 24, 13, 0, -24 },
  { 1543, 22, 24, 23, 0, -24 },
  { 1609, 11, 24, 12, 0, -24 },
  { 1642, 11, 24, 11, 0, -24 },
  { 1675, 10, 24, 11, 1, -24 },
  { 1705, 6, 29, 10, 3, -24 },
  { 1727, 10, 24, 11, 1, -24 },
  { 1757, 7, 29, 10, 1, -24 },
  { 1783, 12, 12, 14, 1, -24 },
  { 1801, 14, 1, 14, 0, 3 },
  { 1803, 6, 5, 8, 1, -26 },
  { 1807, 9, 18, 13, 1, -18 },
  { 1828, 11, 26, 15, 2, -26 },
  { 1864, 8, 18, 11, 2, -18 },
  { 1882, 10, 26, 15, 2, -26 },
  { 1915, 10, 18, 13, 2, -18 },
  { 1938, 8, 26, 7, 0, -26 },
  { 1964, 10, 26, 15, 2, -18 },
  { 1997, 10, 26, 14, 2, -26 },
  { 2030, 2, 25, 6, 2, -25 },
  { 2037, 4, 33, 6, 0, -25 },
  { 2054, 9, 26, 12, 2, -26 },
  { 2084, 2, 26, 6, 2, -26 },
  { 2091, 17, 18, 21, 2, -18 },
  { 2130, 10, 18, 14, 2, -18 },
  { 2153, 10, 18, 14, 2, -18 },
  { 2176, 11, 26, 15, 2, -18 },
  { 2212, 10, 26, 15, 2, -18 },
  { 2245, 7, 18, 9, 2, -18 },
  { 2261, 9, 18, 11, 1, -18 },
  { 2282, 6, 22, 7, 1, -22 },
  { 2299, 10, 18, 14, 2, -18 },
  { 2322, 10, 18, 11, 0, -18 },
  { 2345, 18, 18, 18, 0, -18 },
  { 2386, 10, 18, 11, 1, -18 },
  { 2409, 11, 26, 11, 0, -18 },
  { 2445, 7, 18, 9, 1, -18 },
  { 2461, 8, 29, 12, 2, -24 },
  { 2490, 1, 34, 13, 6, -26 },
  { 2495, 8, 29, 12, 2, -24 },
  { 2524, 12, 4, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT34PT7B_H_
